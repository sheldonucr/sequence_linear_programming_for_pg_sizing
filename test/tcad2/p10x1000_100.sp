num_node 10001
matrix_size 10002

* 10 x 1000 ground network
*seg: 1
* inter-segment connection
R1 10 1010 6.16 0.8 49.28 37
R2 20 1020 6.16 0.8 49.28 37
R3 30 1030 6.16 0.8 49.28 37
R4 40 1040 6.16 0.8 49.28 37
R5 50 1050 6.16 0.8 49.28 37
R6 60 1060 6.16 0.8 49.28 37
R7 70 1070 6.16 0.8 49.28 37
R8 80 1080 6.16 0.8 49.28 37
R9 90 1090 6.16 0.8 49.28 37
R10 100 1100 6.16 0.8 49.28 37
R11 110 1110 6.16 0.8 49.28 37
R12 120 1120 6.16 0.8 49.28 37
R13 130 1130 6.16 0.8 49.28 37
R14 140 1140 6.16 0.8 49.28 37
R15 150 1150 6.16 0.8 49.28 37
R16 160 1160 6.16 0.8 49.28 37
R17 170 1170 6.16 0.8 49.28 37
R18 180 1180 6.16 0.8 49.28 37
R19 190 1190 6.16 0.8 49.28 37
R20 200 1200 6.16 0.8 49.28 37
R21 210 1210 6.16 0.8 49.28 37
R22 220 1220 6.16 0.8 49.28 37
R23 230 1230 6.16 0.8 49.28 37
R24 240 1240 6.16 0.8 49.28 37
R25 250 1250 6.16 0.8 49.28 37
R26 260 1260 6.16 0.8 49.28 37
R27 270 1270 6.16 0.8 49.28 37
R28 280 1280 6.16 0.8 49.28 37
R29 290 1290 6.16 0.8 49.28 37
R30 300 1300 6.16 0.8 49.28 37
R31 310 1310 6.16 0.8 49.28 37
R32 320 1320 6.16 0.8 49.28 37
R33 330 1330 6.16 0.8 49.28 37
R34 340 1340 6.16 0.8 49.28 37
R35 350 1350 6.16 0.8 49.28 37
R36 360 1360 6.16 0.8 49.28 37
R37 370 1370 6.16 0.8 49.28 37
R38 380 1380 6.16 0.8 49.28 37
R39 390 1390 6.16 0.8 49.28 37
R40 400 1400 6.16 0.8 49.28 37
R41 410 1410 6.16 0.8 49.28 37
R42 420 1420 6.16 0.8 49.28 37
R43 430 1430 6.16 0.8 49.28 37
R44 440 1440 6.16 0.8 49.28 37
R45 450 1450 6.16 0.8 49.28 37
R46 460 1460 6.16 0.8 49.28 37
R47 470 1470 6.16 0.8 49.28 37
R48 480 1480 6.16 0.8 49.28 37
R49 490 1490 6.16 0.8 49.28 37
R50 500 1500 6.16 0.8 49.28 37
R51 510 1510 6.16 0.8 49.28 37
R52 520 1520 6.16 0.8 49.28 37
R53 530 1530 6.16 0.8 49.28 37
R54 540 1540 6.16 0.8 49.28 37
R55 550 1550 6.16 0.8 49.28 37
R56 560 1560 6.16 0.8 49.28 37
R57 570 1570 6.16 0.8 49.28 37
R58 580 1580 6.16 0.8 49.28 37
R59 590 1590 6.16 0.8 49.28 37
R60 600 1600 6.16 0.8 49.28 37
R61 610 1610 6.16 0.8 49.28 37
R62 620 1620 6.16 0.8 49.28 37
R63 630 1630 6.16 0.8 49.28 37
R64 640 1640 6.16 0.8 49.28 37
R65 650 1650 6.16 0.8 49.28 37
R66 660 1660 6.16 0.8 49.28 37
R67 670 1670 6.16 0.8 49.28 37
R68 680 1680 6.16 0.8 49.28 37
R69 690 1690 6.16 0.8 49.28 37
R70 700 1700 6.16 0.8 49.28 37
R71 710 1710 6.16 0.8 49.28 37
R72 720 1720 6.16 0.8 49.28 37
R73 730 1730 6.16 0.8 49.28 37
R74 740 1740 6.16 0.8 49.28 37
R75 750 1750 6.16 0.8 49.28 37
R76 760 1760 6.16 0.8 49.28 37
R77 770 1770 6.16 0.8 49.28 37
R78 780 1780 6.16 0.8 49.28 37
R79 790 1790 6.16 0.8 49.28 37
R80 800 1800 6.16 0.8 49.28 37
R81 810 1810 6.16 0.8 49.28 37
R82 820 1820 6.16 0.8 49.28 37
R83 830 1830 6.16 0.8 49.28 37
R84 840 1840 6.16 0.8 49.28 37
R85 850 1850 6.16 0.8 49.28 37
R86 860 1860 6.16 0.8 49.28 37
R87 870 1870 6.16 0.8 49.28 37
R88 880 1880 6.16 0.8 49.28 37
R89 890 1890 6.16 0.8 49.28 37
R90 900 1900 6.16 0.8 49.28 37
R91 910 1910 6.16 0.8 49.28 37
R92 920 1920 6.16 0.8 49.28 37
R93 930 1930 6.16 0.8 49.28 37
R94 940 1940 6.16 0.8 49.28 37
R95 950 1950 6.16 0.8 49.28 37
R96 960 1960 6.16 0.8 49.28 37
R97 970 1970 6.16 0.8 49.28 37
R98 980 1980 6.16 0.8 49.28 37
R99 990 1990 6.16 0.8 49.28 37
R100 1000 2000 6.16 0.8 49.28 37
R101 10001 1 0.4 20 80 37
I1 1 0 1.27395e-05
R102 1 2 1.696 0.8 13.568 37
I2 2 0 1.32342e-05
R103 2 3 1.68 0.8 13.44 37
I3 3 0 1.27395e-05
R104 3 4 1.68 0.8 13.44 37
I4 4 0 1.31105e-05
R105 4 5 1.632 0.8 13.056 37
I5 5 0 1.34816e-05
R106 5 6 1.616 0.8 12.928 37
I6 6 0 1.26158e-05
R107 6 7 1.712 0.8 13.696 37
I7 7 0 1.23684e-05
R108 7 8 1.744 0.8 13.952 37
I8 8 0 1.27395e-05
R109 8 9 1.696 0.8 13.568 37
I9 9 0 1.23684e-05
R110 9 10 1.696 0.8 13.568 37
I10 10 0 1.26158e-05
R111 10 11 1.696 0.8 13.568 37
I11 11 0 1.24921e-05
R112 11 12 1.728 0.8 13.824 37
I12 12 0 1.32342e-05
R113 12 13 1.744 0.8 13.952 37
I13 13 0 1.26158e-05
R114 13 14 1.6 0.8 12.8 37
I14 14 0 1.26158e-05
R115 14 15 1.648 0.8 13.184 37
I15 15 0 1.32342e-05
R116 15 16 1.68 0.8 13.44 37
I16 16 0 1.34816e-05
R117 16 17 1.632 0.8 13.056 37
I17 17 0 1.26158e-05
R118 17 18 1.728 0.8 13.824 37
I18 18 0 1.34816e-05
R119 18 19 1.712 0.8 13.696 37
I19 19 0 1.27395e-05
R120 19 20 1.696 0.8 13.568 37
I20 20 0 1.24921e-05
R121 20 21 1.632 0.8 13.056 37
I21 21 0 1.34816e-05
R122 21 22 1.648 0.8 13.184 37
I22 22 0 1.24921e-05
R123 22 23 1.744 0.8 13.952 37
I23 23 0 1.28631e-05
R124 23 24 1.712 0.8 13.696 37
I24 24 0 1.33579e-05
R125 24 25 1.664 0.8 13.312 37
I25 25 0 1.29868e-05
R126 25 26 1.6 0.8 12.8 37
I26 26 0 1.27395e-05
R127 26 27 1.696 0.8 13.568 37
I27 27 0 1.24921e-05
R128 27 28 1.6 0.8 12.8 37
I28 28 0 1.31105e-05
R129 28 29 1.648 0.8 13.184 37
I29 29 0 1.26158e-05
R130 29 30 1.6 0.8 12.8 37
I30 30 0 1.31105e-05
R131 30 31 1.616 0.8 12.928 37
I31 31 0 1.29868e-05
R132 31 32 1.68 0.8 13.44 37
I32 32 0 1.28631e-05
R133 32 33 1.712 0.8 13.696 37
I33 33 0 1.31105e-05
R134 33 34 1.68 0.8 13.44 37
I34 34 0 1.31105e-05
R135 34 35 1.744 0.8 13.952 37
I35 35 0 1.27395e-05
R136 35 36 1.712 0.8 13.696 37
I36 36 0 1.28631e-05
R137 36 37 1.68 0.8 13.44 37
I37 37 0 1.26158e-05
R138 37 38 1.68 0.8 13.44 37
I38 38 0 1.28631e-05
R139 38 39 1.712 0.8 13.696 37
I39 39 0 1.28631e-05
R140 39 40 1.664 0.8 13.312 37
I40 40 0 1.27395e-05
R141 40 41 1.6 0.8 12.8 37
I41 41 0 1.32342e-05
R142 41 42 1.728 0.8 13.824 37
I42 42 0 1.31105e-05
R143 42 43 1.728 0.8 13.824 37
I43 43 0 1.33579e-05
R144 43 44 1.664 0.8 13.312 37
I44 44 0 1.27395e-05
R145 44 45 1.616 0.8 12.928 37
I45 45 0 1.28631e-05
R146 45 46 1.744 0.8 13.952 37
I46 46 0 1.26158e-05
R147 46 47 1.6 0.8 12.8 37
I47 47 0 1.31105e-05
R148 47 48 1.728 0.8 13.824 37
I48 48 0 1.34816e-05
R149 48 49 1.632 0.8 13.056 37
I49 49 0 1.31105e-05
R150 49 50 1.696 0.8 13.568 37
I50 50 0 1.28631e-05
R151 50 51 1.744 0.8 13.952 37
I51 51 0 1.29868e-05
R152 51 52 1.6 0.8 12.8 37
I52 52 0 1.28631e-05
R153 52 53 1.728 0.8 13.824 37
I53 53 0 1.32342e-05
R154 53 54 1.616 0.8 12.928 37
I54 54 0 1.32342e-05
R155 54 55 1.632 0.8 13.056 37
I55 55 0 1.32342e-05
R156 55 56 1.632 0.8 13.056 37
I56 56 0 1.26158e-05
R157 56 57 1.696 0.8 13.568 37
I57 57 0 1.24921e-05
R158 57 58 1.6 0.8 12.8 37
I58 58 0 1.31105e-05
R159 58 59 1.616 0.8 12.928 37
I59 59 0 1.29868e-05
R160 59 60 1.744 0.8 13.952 37
I60 60 0 1.28631e-05
R161 60 61 1.744 0.8 13.952 37
I61 61 0 1.23684e-05
R162 61 62 1.744 0.8 13.952 37
I62 62 0 1.24921e-05
R163 62 63 1.712 0.8 13.696 37
I63 63 0 1.32342e-05
R164 63 64 1.616 0.8 12.928 37
I64 64 0 1.24921e-05
R165 64 65 1.68 0.8 13.44 37
I65 65 0 1.34816e-05
R166 65 66 1.712 0.8 13.696 37
I66 66 0 1.32342e-05
R167 66 67 1.696 0.8 13.568 37
I67 67 0 1.32342e-05
R168 67 68 1.648 0.8 13.184 37
I68 68 0 1.31105e-05
R169 68 69 1.68 0.8 13.44 37
I69 69 0 1.31105e-05
R170 69 70 1.648 0.8 13.184 37
I70 70 0 1.34816e-05
R171 70 71 1.664 0.8 13.312 37
I71 71 0 1.33579e-05
R172 71 72 1.616 0.8 12.928 37
I72 72 0 1.26158e-05
R173 72 73 1.744 0.8 13.952 37
I73 73 0 1.27395e-05
R174 73 74 1.744 0.8 13.952 37
I74 74 0 1.23684e-05
R175 74 75 1.728 0.8 13.824 37
I75 75 0 1.33579e-05
R176 75 76 1.68 0.8 13.44 37
I76 76 0 1.23684e-05
R177 76 77 1.744 0.8 13.952 37
I77 77 0 1.31105e-05
R178 77 78 1.648 0.8 13.184 37
I78 78 0 1.33579e-05
R179 78 79 1.68 0.8 13.44 37
I79 79 0 1.31105e-05
R180 79 80 1.616 0.8 12.928 37
I80 80 0 1.24921e-05
R181 80 81 1.68 0.8 13.44 37
I81 81 0 1.34816e-05
R182 81 82 1.728 0.8 13.824 37
I82 82 0 1.28631e-05
R183 82 83 1.728 0.8 13.824 37
I83 83 0 1.24921e-05
R184 83 84 1.6 0.8 12.8 37
I84 84 0 1.27395e-05
R185 84 85 1.6 0.8 12.8 37
I85 85 0 1.28631e-05
R186 85 86 1.664 0.8 13.312 37
I86 86 0 1.28631e-05
R187 86 87 1.664 0.8 13.312 37
I87 87 0 1.32342e-05
R188 87 88 1.696 0.8 13.568 37
I88 88 0 1.27395e-05
R189 88 89 1.616 0.8 12.928 37
I89 89 0 1.32342e-05
R190 89 90 1.68 0.8 13.44 37
I90 90 0 1.34816e-05
R191 90 91 1.696 0.8 13.568 37
I91 91 0 1.26158e-05
R192 91 92 1.616 0.8 12.928 37
I92 92 0 1.32342e-05
R193 92 93 1.728 0.8 13.824 37
I93 93 0 1.29868e-05
R194 93 94 1.712 0.8 13.696 37
I94 94 0 1.28631e-05
R195 94 95 1.616 0.8 12.928 37
I95 95 0 1.33579e-05
R196 95 96 1.68 0.8 13.44 37
I96 96 0 1.34816e-05
R197 96 97 1.712 0.8 13.696 37
I97 97 0 1.29868e-05
R198 97 98 1.648 0.8 13.184 37
I98 98 0 1.33579e-05
R199 98 99 1.728 0.8 13.824 37
I99 99 0 1.27395e-05
R200 99 100 1.616 0.8 12.928 37
I100 100 0 1.33579e-05
R201 100 101 1.744 0.8 13.952 37
I101 101 0 1.31105e-05
R202 101 102 1.664 0.8 13.312 37
I102 102 0 1.27395e-05
R203 102 103 1.648 0.8 13.184 37
I103 103 0 1.27395e-05
R204 103 104 1.728 0.8 13.824 37
I104 104 0 1.31105e-05
R205 104 105 1.6 0.8 12.8 37
I105 105 0 1.28631e-05
R206 105 106 1.728 0.8 13.824 37
I106 106 0 1.33579e-05
R207 106 107 1.728 0.8 13.824 37
I107 107 0 1.34816e-05
R208 107 108 1.712 0.8 13.696 37
I108 108 0 1.32342e-05
R209 108 109 1.696 0.8 13.568 37
I109 109 0 1.28631e-05
R210 109 110 1.648 0.8 13.184 37
I110 110 0 1.23684e-05
R211 110 111 1.648 0.8 13.184 37
I111 111 0 1.23684e-05
R212 111 112 1.744 0.8 13.952 37
I112 112 0 1.26158e-05
R213 112 113 1.68 0.8 13.44 37
I113 113 0 1.28631e-05
R214 113 114 1.6 0.8 12.8 37
I114 114 0 1.29868e-05
R215 114 115 1.744 0.8 13.952 37
I115 115 0 1.28631e-05
R216 115 116 1.696 0.8 13.568 37
I116 116 0 1.34816e-05
R217 116 117 1.632 0.8 13.056 37
I117 117 0 1.26158e-05
R218 117 118 1.664 0.8 13.312 37
I118 118 0 1.32342e-05
R219 118 119 1.712 0.8 13.696 37
I119 119 0 1.29868e-05
R220 119 120 1.664 0.8 13.312 37
I120 120 0 1.33579e-05
R221 120 121 1.616 0.8 12.928 37
I121 121 0 1.26158e-05
R222 121 122 1.728 0.8 13.824 37
I122 122 0 1.34816e-05
R223 122 123 1.648 0.8 13.184 37
I123 123 0 1.31105e-05
R224 123 124 1.728 0.8 13.824 37
I124 124 0 1.23684e-05
R225 124 125 1.632 0.8 13.056 37
I125 125 0 1.24921e-05
R226 125 126 1.6 0.8 12.8 37
I126 126 0 1.29868e-05
R227 126 127 1.616 0.8 12.928 37
I127 127 0 1.24921e-05
R228 127 128 1.6 0.8 12.8 37
I128 128 0 1.33579e-05
R229 128 129 1.68 0.8 13.44 37
I129 129 0 1.23684e-05
R230 129 130 1.696 0.8 13.568 37
I130 130 0 1.28631e-05
R231 130 131 1.696 0.8 13.568 37
I131 131 0 1.26158e-05
R232 131 132 1.68 0.8 13.44 37
I132 132 0 1.33579e-05
R233 132 133 1.696 0.8 13.568 37
I133 133 0 1.26158e-05
R234 133 134 1.728 0.8 13.824 37
I134 134 0 1.28631e-05
R235 134 135 1.712 0.8 13.696 37
I135 135 0 1.26158e-05
R236 135 136 1.664 0.8 13.312 37
I136 136 0 1.23684e-05
R237 136 137 1.696 0.8 13.568 37
I137 137 0 1.26158e-05
R238 137 138 1.744 0.8 13.952 37
I138 138 0 1.34816e-05
R239 138 139 1.6 0.8 12.8 37
I139 139 0 1.33579e-05
R240 139 140 1.616 0.8 12.928 37
I140 140 0 1.27395e-05
R241 140 141 1.616 0.8 12.928 37
I141 141 0 1.24921e-05
R242 141 142 1.6 0.8 12.8 37
I142 142 0 1.27395e-05
R243 142 143 1.664 0.8 13.312 37
I143 143 0 1.23684e-05
R244 143 144 1.648 0.8 13.184 37
I144 144 0 1.34816e-05
R245 144 145 1.616 0.8 12.928 37
I145 145 0 1.34816e-05
R246 145 146 1.696 0.8 13.568 37
I146 146 0 1.34816e-05
R247 146 147 1.648 0.8 13.184 37
I147 147 0 1.27395e-05
R248 147 148 1.728 0.8 13.824 37
I148 148 0 1.23684e-05
R249 148 149 1.68 0.8 13.44 37
I149 149 0 1.31105e-05
R250 149 150 1.696 0.8 13.568 37
I150 150 0 1.28631e-05
R251 150 151 1.6 0.8 12.8 37
I151 151 0 1.23684e-05
R252 151 152 1.664 0.8 13.312 37
I152 152 0 1.31105e-05
R253 152 153 1.632 0.8 13.056 37
I153 153 0 1.31105e-05
R254 153 154 1.712 0.8 13.696 37
I154 154 0 1.29868e-05
R255 154 155 1.696 0.8 13.568 37
I155 155 0 1.34816e-05
R256 155 156 1.728 0.8 13.824 37
I156 156 0 1.32342e-05
R257 156 157 1.632 0.8 13.056 37
I157 157 0 1.33579e-05
R258 157 158 1.632 0.8 13.056 37
I158 158 0 1.34816e-05
R259 158 159 1.744 0.8 13.952 37
I159 159 0 1.31105e-05
R260 159 160 1.6 0.8 12.8 37
I160 160 0 1.26158e-05
R261 160 161 1.712 0.8 13.696 37
I161 161 0 1.31105e-05
R262 161 162 1.616 0.8 12.928 37
I162 162 0 1.27395e-05
R263 162 163 1.632 0.8 13.056 37
I163 163 0 1.24921e-05
R264 163 164 1.68 0.8 13.44 37
I164 164 0 1.34816e-05
R265 164 165 1.744 0.8 13.952 37
I165 165 0 1.24921e-05
R266 165 166 1.664 0.8 13.312 37
I166 166 0 1.34816e-05
R267 166 167 1.616 0.8 12.928 37
I167 167 0 1.23684e-05
R268 167 168 1.712 0.8 13.696 37
I168 168 0 1.29868e-05
R269 168 169 1.728 0.8 13.824 37
I169 169 0 1.32342e-05
R270 169 170 1.6 0.8 12.8 37
I170 170 0 1.28631e-05
R271 170 171 1.728 0.8 13.824 37
I171 171 0 1.23684e-05
R272 171 172 1.664 0.8 13.312 37
I172 172 0 1.26158e-05
R273 172 173 1.744 0.8 13.952 37
I173 173 0 1.31105e-05
R274 173 174 1.616 0.8 12.928 37
I174 174 0 1.23684e-05
R275 174 175 1.664 0.8 13.312 37
I175 175 0 1.26158e-05
R276 175 176 1.632 0.8 13.056 37
I176 176 0 1.26158e-05
R277 176 177 1.6 0.8 12.8 37
I177 177 0 1.29868e-05
R278 177 178 1.68 0.8 13.44 37
I178 178 0 1.26158e-05
R279 178 179 1.744 0.8 13.952 37
I179 179 0 1.23684e-05
R280 179 180 1.632 0.8 13.056 37
I180 180 0 1.33579e-05
R281 180 181 1.648 0.8 13.184 37
I181 181 0 1.33579e-05
R282 181 182 1.6 0.8 12.8 37
I182 182 0 1.28631e-05
R283 182 183 1.6 0.8 12.8 37
I183 183 0 1.34816e-05
R284 183 184 1.616 0.8 12.928 37
I184 184 0 1.34816e-05
R285 184 185 1.696 0.8 13.568 37
I185 185 0 1.26158e-05
R286 185 186 1.68 0.8 13.44 37
I186 186 0 1.28631e-05
R287 186 187 1.664 0.8 13.312 37
I187 187 0 1.34816e-05
R288 187 188 1.744 0.8 13.952 37
I188 188 0 1.27395e-05
R289 188 189 1.696 0.8 13.568 37
I189 189 0 1.23684e-05
R290 189 190 1.68 0.8 13.44 37
I190 190 0 1.23684e-05
R291 190 191 1.632 0.8 13.056 37
I191 191 0 1.34816e-05
R292 191 192 1.664 0.8 13.312 37
I192 192 0 1.27395e-05
R293 192 193 1.68 0.8 13.44 37
I193 193 0 1.24921e-05
R294 193 194 1.712 0.8 13.696 37
I194 194 0 1.28631e-05
R295 194 195 1.648 0.8 13.184 37
I195 195 0 1.24921e-05
R296 195 196 1.664 0.8 13.312 37
I196 196 0 1.31105e-05
R297 196 197 1.744 0.8 13.952 37
I197 197 0 1.28631e-05
R298 197 198 1.632 0.8 13.056 37
I198 198 0 1.26158e-05
R299 198 199 1.696 0.8 13.568 37
I199 199 0 1.28631e-05
R300 199 200 1.616 0.8 12.928 37
I200 200 0 1.26158e-05
R301 200 201 1.728 0.8 13.824 37
I201 201 0 1.33579e-05
R302 201 202 1.744 0.8 13.952 37
I202 202 0 1.26158e-05
R303 202 203 1.728 0.8 13.824 37
I203 203 0 1.33579e-05
R304 203 204 1.728 0.8 13.824 37
I204 204 0 1.31105e-05
R305 204 205 1.728 0.8 13.824 37
I205 205 0 1.27395e-05
R306 205 206 1.728 0.8 13.824 37
I206 206 0 1.27395e-05
R307 206 207 1.648 0.8 13.184 37
I207 207 0 1.27395e-05
R308 207 208 1.728 0.8 13.824 37
I208 208 0 1.23684e-05
R309 208 209 1.664 0.8 13.312 37
I209 209 0 1.32342e-05
R310 209 210 1.696 0.8 13.568 37
I210 210 0 1.33579e-05
R311 210 211 1.744 0.8 13.952 37
I211 211 0 1.23684e-05
R312 211 212 1.696 0.8 13.568 37
I212 212 0 1.33579e-05
R313 212 213 1.712 0.8 13.696 37
I213 213 0 1.34816e-05
R314 213 214 1.6 0.8 12.8 37
I214 214 0 1.27395e-05
R315 214 215 1.648 0.8 13.184 37
I215 215 0 1.27395e-05
R316 215 216 1.712 0.8 13.696 37
I216 216 0 1.27395e-05
R317 216 217 1.632 0.8 13.056 37
I217 217 0 1.31105e-05
R318 217 218 1.68 0.8 13.44 37
I218 218 0 1.26158e-05
R319 218 219 1.696 0.8 13.568 37
I219 219 0 1.29868e-05
R320 219 220 1.728 0.8 13.824 37
I220 220 0 1.32342e-05
R321 220 221 1.744 0.8 13.952 37
I221 221 0 1.31105e-05
R322 221 222 1.6 0.8 12.8 37
I222 222 0 1.28631e-05
R323 222 223 1.616 0.8 12.928 37
I223 223 0 1.23684e-05
R324 223 224 1.664 0.8 13.312 37
I224 224 0 1.33579e-05
R325 224 225 1.712 0.8 13.696 37
I225 225 0 1.23684e-05
R326 225 226 1.728 0.8 13.824 37
I226 226 0 1.31105e-05
R327 226 227 1.632 0.8 13.056 37
I227 227 0 1.28631e-05
R328 227 228 1.712 0.8 13.696 37
I228 228 0 1.34816e-05
R329 228 229 1.648 0.8 13.184 37
I229 229 0 1.34816e-05
R330 229 230 1.632 0.8 13.056 37
I230 230 0 1.33579e-05
R331 230 231 1.648 0.8 13.184 37
I231 231 0 1.23684e-05
R332 231 232 1.616 0.8 12.928 37
I232 232 0 1.32342e-05
R333 232 233 1.728 0.8 13.824 37
I233 233 0 1.34816e-05
R334 233 234 1.616 0.8 12.928 37
I234 234 0 1.29868e-05
R335 234 235 1.664 0.8 13.312 37
I235 235 0 1.34816e-05
R336 235 236 1.632 0.8 13.056 37
I236 236 0 1.29868e-05
R337 236 237 1.712 0.8 13.696 37
I237 237 0 1.28631e-05
R338 237 238 1.744 0.8 13.952 37
I238 238 0 1.34816e-05
R339 238 239 1.664 0.8 13.312 37
I239 239 0 1.29868e-05
R340 239 240 1.744 0.8 13.952 37
I240 240 0 1.27395e-05
R341 240 241 1.68 0.8 13.44 37
I241 241 0 1.32342e-05
R342 241 242 1.6 0.8 12.8 37
I242 242 0 1.33579e-05
R343 242 243 1.616 0.8 12.928 37
I243 243 0 1.34816e-05
R344 243 244 1.744 0.8 13.952 37
I244 244 0 1.32342e-05
R345 244 245 1.728 0.8 13.824 37
I245 245 0 1.26158e-05
R346 245 246 1.68 0.8 13.44 37
I246 246 0 1.27395e-05
R347 246 247 1.664 0.8 13.312 37
I247 247 0 1.34816e-05
R348 247 248 1.6 0.8 12.8 37
I248 248 0 1.26158e-05
R349 248 249 1.6 0.8 12.8 37
I249 249 0 1.24921e-05
R350 249 250 1.744 0.8 13.952 37
I250 250 0 1.31105e-05
R351 250 251 1.632 0.8 13.056 37
I251 251 0 1.24921e-05
R352 251 252 1.632 0.8 13.056 37
I252 252 0 1.23684e-05
R353 252 253 1.712 0.8 13.696 37
I253 253 0 1.27395e-05
R354 253 254 1.616 0.8 12.928 37
I254 254 0 1.24921e-05
R355 254 255 1.744 0.8 13.952 37
I255 255 0 1.23684e-05
R356 255 256 1.68 0.8 13.44 37
I256 256 0 1.31105e-05
R357 256 257 1.712 0.8 13.696 37
I257 257 0 1.32342e-05
R358 257 258 1.664 0.8 13.312 37
I258 258 0 1.23684e-05
R359 258 259 1.696 0.8 13.568 37
I259 259 0 1.28631e-05
R360 259 260 1.712 0.8 13.696 37
I260 260 0 1.28631e-05
R361 260 261 1.728 0.8 13.824 37
I261 261 0 1.29868e-05
R362 261 262 1.728 0.8 13.824 37
I262 262 0 1.26158e-05
R363 262 263 1.696 0.8 13.568 37
I263 263 0 1.23684e-05
R364 263 264 1.696 0.8 13.568 37
I264 264 0 1.31105e-05
R365 264 265 1.664 0.8 13.312 37
I265 265 0 1.31105e-05
R366 265 266 1.632 0.8 13.056 37
I266 266 0 1.33579e-05
R367 266 267 1.744 0.8 13.952 37
I267 267 0 1.31105e-05
R368 267 268 1.6 0.8 12.8 37
I268 268 0 1.32342e-05
R369 268 269 1.6 0.8 12.8 37
I269 269 0 1.24921e-05
R370 269 270 1.6 0.8 12.8 37
I270 270 0 1.24921e-05
R371 270 271 1.648 0.8 13.184 37
I271 271 0 1.32342e-05
R372 271 272 1.712 0.8 13.696 37
I272 272 0 1.26158e-05
R373 272 273 1.696 0.8 13.568 37
I273 273 0 1.28631e-05
R374 273 274 1.68 0.8 13.44 37
I274 274 0 1.26158e-05
R375 274 275 1.6 0.8 12.8 37
I275 275 0 1.26158e-05
R376 275 276 1.744 0.8 13.952 37
I276 276 0 1.23684e-05
R377 276 277 1.744 0.8 13.952 37
I277 277 0 1.34816e-05
R378 277 278 1.664 0.8 13.312 37
I278 278 0 1.29868e-05
R379 278 279 1.616 0.8 12.928 37
I279 279 0 1.23684e-05
R380 279 280 1.648 0.8 13.184 37
I280 280 0 1.32342e-05
R381 280 281 1.728 0.8 13.824 37
I281 281 0 1.33579e-05
R382 281 282 1.696 0.8 13.568 37
I282 282 0 1.23684e-05
R383 282 283 1.664 0.8 13.312 37
I283 283 0 1.31105e-05
R384 283 284 1.712 0.8 13.696 37
I284 284 0 1.31105e-05
R385 284 285 1.6 0.8 12.8 37
I285 285 0 1.34816e-05
R386 285 286 1.712 0.8 13.696 37
I286 286 0 1.29868e-05
R387 286 287 1.744 0.8 13.952 37
I287 287 0 1.32342e-05
R388 287 288 1.728 0.8 13.824 37
I288 288 0 1.29868e-05
R389 288 289 1.648 0.8 13.184 37
I289 289 0 1.27395e-05
R390 289 290 1.728 0.8 13.824 37
I290 290 0 1.27395e-05
R391 290 291 1.712 0.8 13.696 37
I291 291 0 1.34816e-05
R392 291 292 1.648 0.8 13.184 37
I292 292 0 1.32342e-05
R393 292 293 1.728 0.8 13.824 37
I293 293 0 1.32342e-05
R394 293 294 1.664 0.8 13.312 37
I294 294 0 1.24921e-05
R395 294 295 1.744 0.8 13.952 37
I295 295 0 1.23684e-05
R396 295 296 1.744 0.8 13.952 37
I296 296 0 1.33579e-05
R397 296 297 1.728 0.8 13.824 37
I297 297 0 1.29868e-05
R398 297 298 1.728 0.8 13.824 37
I298 298 0 1.28631e-05
R399 298 299 1.648 0.8 13.184 37
I299 299 0 1.32342e-05
R400 299 300 1.616 0.8 12.928 37
I300 300 0 1.27395e-05
R401 300 301 1.728 0.8 13.824 37
I301 301 0 1.23684e-05
R402 301 302 1.744 0.8 13.952 37
I302 302 0 1.32342e-05
R403 302 303 1.744 0.8 13.952 37
I303 303 0 1.34816e-05
R404 303 304 1.648 0.8 13.184 37
I304 304 0 1.26158e-05
R405 304 305 1.664 0.8 13.312 37
I305 305 0 1.27395e-05
R406 305 306 1.712 0.8 13.696 37
I306 306 0 1.24921e-05
R407 306 307 1.632 0.8 13.056 37
I307 307 0 1.26158e-05
R408 307 308 1.6 0.8 12.8 37
I308 308 0 1.26158e-05
R409 308 309 1.616 0.8 12.928 37
I309 309 0 1.32342e-05
R410 309 310 1.68 0.8 13.44 37
I310 310 0 1.24921e-05
R411 310 311 1.712 0.8 13.696 37
I311 311 0 1.28631e-05
R412 311 312 1.616 0.8 12.928 37
I312 312 0 1.32342e-05
R413 312 313 1.616 0.8 12.928 37
I313 313 0 1.24921e-05
R414 313 314 1.616 0.8 12.928 37
I314 314 0 1.32342e-05
R415 314 315 1.6 0.8 12.8 37
I315 315 0 1.28631e-05
R416 315 316 1.6 0.8 12.8 37
I316 316 0 1.33579e-05
R417 316 317 1.68 0.8 13.44 37
I317 317 0 1.24921e-05
R418 317 318 1.696 0.8 13.568 37
I318 318 0 1.31105e-05
R419 318 319 1.632 0.8 13.056 37
I319 319 0 1.24921e-05
R420 319 320 1.744 0.8 13.952 37
I320 320 0 1.31105e-05
R421 320 321 1.664 0.8 13.312 37
I321 321 0 1.33579e-05
R422 321 322 1.6 0.8 12.8 37
I322 322 0 1.33579e-05
R423 322 323 1.616 0.8 12.928 37
I323 323 0 1.23684e-05
R424 323 324 1.632 0.8 13.056 37
I324 324 0 1.26158e-05
R425 324 325 1.744 0.8 13.952 37
I325 325 0 1.32342e-05
R426 325 326 1.68 0.8 13.44 37
I326 326 0 1.31105e-05
R427 326 327 1.664 0.8 13.312 37
I327 327 0 1.31105e-05
R428 327 328 1.648 0.8 13.184 37
I328 328 0 1.32342e-05
R429 328 329 1.744 0.8 13.952 37
I329 329 0 1.32342e-05
R430 329 330 1.664 0.8 13.312 37
I330 330 0 1.34816e-05
R431 330 331 1.616 0.8 12.928 37
I331 331 0 1.32342e-05
R432 331 332 1.6 0.8 12.8 37
I332 332 0 1.31105e-05
R433 332 333 1.6 0.8 12.8 37
I333 333 0 1.33579e-05
R434 333 334 1.68 0.8 13.44 37
I334 334 0 1.27395e-05
R435 334 335 1.744 0.8 13.952 37
I335 335 0 1.28631e-05
R436 335 336 1.616 0.8 12.928 37
I336 336 0 1.29868e-05
R437 336 337 1.664 0.8 13.312 37
I337 337 0 1.24921e-05
R438 337 338 1.68 0.8 13.44 37
I338 338 0 1.29868e-05
R439 338 339 1.664 0.8 13.312 37
I339 339 0 1.34816e-05
R440 339 340 1.728 0.8 13.824 37
I340 340 0 1.27395e-05
R441 340 341 1.728 0.8 13.824 37
I341 341 0 1.29868e-05
R442 341 342 1.632 0.8 13.056 37
I342 342 0 1.26158e-05
R443 342 343 1.632 0.8 13.056 37
I343 343 0 1.32342e-05
R444 343 344 1.6 0.8 12.8 37
I344 344 0 1.27395e-05
R445 344 345 1.664 0.8 13.312 37
I345 345 0 1.31105e-05
R446 345 346 1.648 0.8 13.184 37
I346 346 0 1.31105e-05
R447 346 347 1.648 0.8 13.184 37
I347 347 0 1.27395e-05
R448 347 348 1.664 0.8 13.312 37
I348 348 0 1.28631e-05
R449 348 349 1.648 0.8 13.184 37
I349 349 0 1.34816e-05
R450 349 350 1.712 0.8 13.696 37
I350 350 0 1.26158e-05
R451 350 351 1.68 0.8 13.44 37
I351 351 0 1.33579e-05
R452 351 352 1.744 0.8 13.952 37
I352 352 0 1.23684e-05
R453 352 353 1.632 0.8 13.056 37
I353 353 0 1.28631e-05
R454 353 354 1.712 0.8 13.696 37
I354 354 0 1.31105e-05
R455 354 355 1.68 0.8 13.44 37
I355 355 0 1.32342e-05
R456 355 356 1.616 0.8 12.928 37
I356 356 0 1.27395e-05
R457 356 357 1.648 0.8 13.184 37
I357 357 0 1.27395e-05
R458 357 358 1.728 0.8 13.824 37
I358 358 0 1.29868e-05
R459 358 359 1.616 0.8 12.928 37
I359 359 0 1.23684e-05
R460 359 360 1.728 0.8 13.824 37
I360 360 0 1.32342e-05
R461 360 361 1.696 0.8 13.568 37
I361 361 0 1.27395e-05
R462 361 362 1.68 0.8 13.44 37
I362 362 0 1.23684e-05
R463 362 363 1.728 0.8 13.824 37
I363 363 0 1.23684e-05
R464 363 364 1.664 0.8 13.312 37
I364 364 0 1.24921e-05
R465 364 365 1.616 0.8 12.928 37
I365 365 0 1.27395e-05
R466 365 366 1.68 0.8 13.44 37
I366 366 0 1.34816e-05
R467 366 367 1.648 0.8 13.184 37
I367 367 0 1.28631e-05
R468 367 368 1.616 0.8 12.928 37
I368 368 0 1.29868e-05
R469 368 369 1.6 0.8 12.8 37
I369 369 0 1.33579e-05
R470 369 370 1.648 0.8 13.184 37
I370 370 0 1.29868e-05
R471 370 371 1.696 0.8 13.568 37
I371 371 0 1.29868e-05
R472 371 372 1.744 0.8 13.952 37
I372 372 0 1.34816e-05
R473 372 373 1.6 0.8 12.8 37
I373 373 0 1.32342e-05
R474 373 374 1.696 0.8 13.568 37
I374 374 0 1.27395e-05
R475 374 375 1.712 0.8 13.696 37
I375 375 0 1.31105e-05
R476 375 376 1.616 0.8 12.928 37
I376 376 0 1.29868e-05
R477 376 377 1.6 0.8 12.8 37
I377 377 0 1.31105e-05
R478 377 378 1.68 0.8 13.44 37
I378 378 0 1.23684e-05
R479 378 379 1.728 0.8 13.824 37
I379 379 0 1.24921e-05
R480 379 380 1.632 0.8 13.056 37
I380 380 0 1.26158e-05
R481 380 381 1.696 0.8 13.568 37
I381 381 0 1.34816e-05
R482 381 382 1.616 0.8 12.928 37
I382 382 0 1.23684e-05
R483 382 383 1.664 0.8 13.312 37
I383 383 0 1.26158e-05
R484 383 384 1.712 0.8 13.696 37
I384 384 0 1.28631e-05
R485 384 385 1.6 0.8 12.8 37
I385 385 0 1.27395e-05
R486 385 386 1.632 0.8 13.056 37
I386 386 0 1.33579e-05
R487 386 387 1.6 0.8 12.8 37
I387 387 0 1.27395e-05
R488 387 388 1.712 0.8 13.696 37
I388 388 0 1.23684e-05
R489 388 389 1.6 0.8 12.8 37
I389 389 0 1.27395e-05
R490 389 390 1.664 0.8 13.312 37
I390 390 0 1.34816e-05
R491 390 391 1.632 0.8 13.056 37
I391 391 0 1.32342e-05
R492 391 392 1.664 0.8 13.312 37
I392 392 0 1.26158e-05
R493 392 393 1.68 0.8 13.44 37
I393 393 0 1.26158e-05
R494 393 394 1.664 0.8 13.312 37
I394 394 0 1.28631e-05
R495 394 395 1.648 0.8 13.184 37
I395 395 0 1.33579e-05
R496 395 396 1.696 0.8 13.568 37
I396 396 0 1.23684e-05
R497 396 397 1.728 0.8 13.824 37
I397 397 0 1.34816e-05
R498 397 398 1.632 0.8 13.056 37
I398 398 0 1.26158e-05
R499 398 399 1.648 0.8 13.184 37
I399 399 0 1.24921e-05
R500 399 400 1.728 0.8 13.824 37
I400 400 0 1.27395e-05
R501 400 401 1.664 0.8 13.312 37
I401 401 0 1.26158e-05
R502 401 402 1.632 0.8 13.056 37
I402 402 0 1.28631e-05
R503 402 403 1.68 0.8 13.44 37
I403 403 0 1.24921e-05
R504 403 404 1.712 0.8 13.696 37
I404 404 0 1.29868e-05
R505 404 405 1.712 0.8 13.696 37
I405 405 0 1.24921e-05
R506 405 406 1.696 0.8 13.568 37
I406 406 0 1.34816e-05
R507 406 407 1.728 0.8 13.824 37
I407 407 0 1.24921e-05
R508 407 408 1.648 0.8 13.184 37
I408 408 0 1.27395e-05
R509 408 409 1.648 0.8 13.184 37
I409 409 0 1.32342e-05
R510 409 410 1.744 0.8 13.952 37
I410 410 0 1.33579e-05
R511 410 411 1.696 0.8 13.568 37
I411 411 0 1.32342e-05
R512 411 412 1.6 0.8 12.8 37
I412 412 0 1.28631e-05
R513 412 413 1.728 0.8 13.824 37
I413 413 0 1.28631e-05
R514 413 414 1.728 0.8 13.824 37
I414 414 0 1.24921e-05
R515 414 415 1.696 0.8 13.568 37
I415 415 0 1.33579e-05
R516 415 416 1.68 0.8 13.44 37
I416 416 0 1.26158e-05
R517 416 417 1.616 0.8 12.928 37
I417 417 0 1.34816e-05
R518 417 418 1.744 0.8 13.952 37
I418 418 0 1.31105e-05
R519 418 419 1.6 0.8 12.8 37
I419 419 0 1.31105e-05
R520 419 420 1.664 0.8 13.312 37
I420 420 0 1.34816e-05
R521 420 421 1.744 0.8 13.952 37
I421 421 0 1.23684e-05
R522 421 422 1.728 0.8 13.824 37
I422 422 0 1.34816e-05
R523 422 423 1.648 0.8 13.184 37
I423 423 0 1.24921e-05
R524 423 424 1.664 0.8 13.312 37
I424 424 0 1.33579e-05
R525 424 425 1.744 0.8 13.952 37
I425 425 0 1.31105e-05
R526 425 426 1.712 0.8 13.696 37
I426 426 0 1.32342e-05
R527 426 427 1.648 0.8 13.184 37
I427 427 0 1.32342e-05
R528 427 428 1.616 0.8 12.928 37
I428 428 0 1.26158e-05
R529 428 429 1.632 0.8 13.056 37
I429 429 0 1.24921e-05
R530 429 430 1.68 0.8 13.44 37
I430 430 0 1.23684e-05
R531 430 431 1.744 0.8 13.952 37
I431 431 0 1.23684e-05
R532 431 432 1.664 0.8 13.312 37
I432 432 0 1.23684e-05
R533 432 433 1.616 0.8 12.928 37
I433 433 0 1.27395e-05
R534 433 434 1.712 0.8 13.696 37
I434 434 0 1.28631e-05
R535 434 435 1.616 0.8 12.928 37
I435 435 0 1.24921e-05
R536 435 436 1.648 0.8 13.184 37
I436 436 0 1.23684e-05
R537 436 437 1.648 0.8 13.184 37
I437 437 0 1.26158e-05
R538 437 438 1.616 0.8 12.928 37
I438 438 0 1.32342e-05
R539 438 439 1.68 0.8 13.44 37
I439 439 0 1.31105e-05
R540 439 440 1.68 0.8 13.44 37
I440 440 0 1.28631e-05
R541 440 441 1.632 0.8 13.056 37
I441 441 0 1.26158e-05
R542 441 442 1.616 0.8 12.928 37
I442 442 0 1.32342e-05
R543 442 443 1.632 0.8 13.056 37
I443 443 0 1.28631e-05
R544 443 444 1.616 0.8 12.928 37
I444 444 0 1.31105e-05
R545 444 445 1.68 0.8 13.44 37
I445 445 0 1.32342e-05
R546 445 446 1.728 0.8 13.824 37
I446 446 0 1.29868e-05
R547 446 447 1.744 0.8 13.952 37
I447 447 0 1.26158e-05
R548 447 448 1.712 0.8 13.696 37
I448 448 0 1.27395e-05
R549 448 449 1.696 0.8 13.568 37
I449 449 0 1.28631e-05
R550 449 450 1.712 0.8 13.696 37
I450 450 0 1.34816e-05
R551 450 451 1.712 0.8 13.696 37
I451 451 0 1.26158e-05
R552 451 452 1.632 0.8 13.056 37
I452 452 0 1.24921e-05
R553 452 453 1.696 0.8 13.568 37
I453 453 0 1.27395e-05
R554 453 454 1.6 0.8 12.8 37
I454 454 0 1.26158e-05
R555 454 455 1.616 0.8 12.928 37
I455 455 0 1.29868e-05
R556 455 456 1.696 0.8 13.568 37
I456 456 0 1.29868e-05
R557 456 457 1.6 0.8 12.8 37
I457 457 0 1.23684e-05
R558 457 458 1.648 0.8 13.184 37
I458 458 0 1.28631e-05
R559 458 459 1.696 0.8 13.568 37
I459 459 0 1.31105e-05
R560 459 460 1.6 0.8 12.8 37
I460 460 0 1.26158e-05
R561 460 461 1.68 0.8 13.44 37
I461 461 0 1.33579e-05
R562 461 462 1.744 0.8 13.952 37
I462 462 0 1.29868e-05
R563 462 463 1.6 0.8 12.8 37
I463 463 0 1.31105e-05
R564 463 464 1.6 0.8 12.8 37
I464 464 0 1.33579e-05
R565 464 465 1.648 0.8 13.184 37
I465 465 0 1.32342e-05
R566 465 466 1.728 0.8 13.824 37
I466 466 0 1.26158e-05
R567 466 467 1.616 0.8 12.928 37
I467 467 0 1.23684e-05
R568 467 468 1.68 0.8 13.44 37
I468 468 0 1.33579e-05
R569 468 469 1.68 0.8 13.44 37
I469 469 0 1.29868e-05
R570 469 470 1.6 0.8 12.8 37
I470 470 0 1.32342e-05
R571 470 471 1.648 0.8 13.184 37
I471 471 0 1.33579e-05
R572 471 472 1.632 0.8 13.056 37
I472 472 0 1.27395e-05
R573 472 473 1.6 0.8 12.8 37
I473 473 0 1.32342e-05
R574 473 474 1.712 0.8 13.696 37
I474 474 0 1.32342e-05
R575 474 475 1.696 0.8 13.568 37
I475 475 0 1.34816e-05
R576 475 476 1.616 0.8 12.928 37
I476 476 0 1.24921e-05
R577 476 477 1.744 0.8 13.952 37
I477 477 0 1.23684e-05
R578 477 478 1.728 0.8 13.824 37
I478 478 0 1.34816e-05
R579 478 479 1.728 0.8 13.824 37
I479 479 0 1.33579e-05
R580 479 480 1.6 0.8 12.8 37
I480 480 0 1.27395e-05
R581 480 481 1.712 0.8 13.696 37
I481 481 0 1.23684e-05
R582 481 482 1.696 0.8 13.568 37
I482 482 0 1.34816e-05
R583 482 483 1.632 0.8 13.056 37
I483 483 0 1.24921e-05
R584 483 484 1.712 0.8 13.696 37
I484 484 0 1.32342e-05
R585 484 485 1.744 0.8 13.952 37
I485 485 0 1.32342e-05
R586 485 486 1.696 0.8 13.568 37
I486 486 0 1.26158e-05
R587 486 487 1.712 0.8 13.696 37
I487 487 0 1.24921e-05
R588 487 488 1.68 0.8 13.44 37
I488 488 0 1.33579e-05
R589 488 489 1.728 0.8 13.824 37
I489 489 0 1.28631e-05
R590 489 490 1.68 0.8 13.44 37
I490 490 0 1.31105e-05
R591 490 491 1.68 0.8 13.44 37
I491 491 0 1.31105e-05
R592 491 492 1.728 0.8 13.824 37
I492 492 0 1.28631e-05
R593 492 493 1.728 0.8 13.824 37
I493 493 0 1.33579e-05
R594 493 494 1.648 0.8 13.184 37
I494 494 0 1.33579e-05
R595 494 495 1.712 0.8 13.696 37
I495 495 0 1.29868e-05
R596 495 496 1.632 0.8 13.056 37
I496 496 0 1.28631e-05
R597 496 497 1.68 0.8 13.44 37
I497 497 0 1.23684e-05
R598 497 498 1.68 0.8 13.44 37
I498 498 0 1.32342e-05
R599 498 499 1.648 0.8 13.184 37
I499 499 0 1.26158e-05
R600 499 500 1.712 0.8 13.696 37
I500 500 0 1.26158e-05
R601 500 501 1.616 0.8 12.928 37
I501 501 0 1.27395e-05
R602 501 502 1.664 0.8 13.312 37
I502 502 0 1.34816e-05
R603 502 503 1.664 0.8 13.312 37
I503 503 0 1.24921e-05
R604 503 504 1.744 0.8 13.952 37
I504 504 0 1.29868e-05
R605 504 505 1.712 0.8 13.696 37
I505 505 0 1.28631e-05
R606 505 506 1.616 0.8 12.928 37
I506 506 0 1.26158e-05
R607 506 507 1.632 0.8 13.056 37
I507 507 0 1.24921e-05
R608 507 508 1.696 0.8 13.568 37
I508 508 0 1.26158e-05
R609 508 509 1.6 0.8 12.8 37
I509 509 0 1.26158e-05
R610 509 510 1.632 0.8 13.056 37
I510 510 0 1.34816e-05
R611 510 511 1.712 0.8 13.696 37
I511 511 0 1.28631e-05
R612 511 512 1.648 0.8 13.184 37
I512 512 0 1.29868e-05
R613 512 513 1.696 0.8 13.568 37
I513 513 0 1.24921e-05
R614 513 514 1.664 0.8 13.312 37
I514 514 0 1.23684e-05
R615 514 515 1.648 0.8 13.184 37
I515 515 0 1.24921e-05
R616 515 516 1.632 0.8 13.056 37
I516 516 0 1.32342e-05
R617 516 517 1.712 0.8 13.696 37
I517 517 0 1.34816e-05
R618 517 518 1.728 0.8 13.824 37
I518 518 0 1.24921e-05
R619 518 519 1.6 0.8 12.8 37
I519 519 0 1.32342e-05
R620 519 520 1.696 0.8 13.568 37
I520 520 0 1.23684e-05
R621 520 521 1.616 0.8 12.928 37
I521 521 0 1.23684e-05
R622 521 522 1.632 0.8 13.056 37
I522 522 0 1.29868e-05
R623 522 523 1.616 0.8 12.928 37
I523 523 0 1.34816e-05
R624 523 524 1.712 0.8 13.696 37
I524 524 0 1.24921e-05
R625 524 525 1.648 0.8 13.184 37
I525 525 0 1.24921e-05
R626 525 526 1.632 0.8 13.056 37
I526 526 0 1.23684e-05
R627 526 527 1.696 0.8 13.568 37
I527 527 0 1.33579e-05
R628 527 528 1.712 0.8 13.696 37
I528 528 0 1.28631e-05
R629 528 529 1.744 0.8 13.952 37
I529 529 0 1.26158e-05
R630 529 530 1.664 0.8 13.312 37
I530 530 0 1.28631e-05
R631 530 531 1.68 0.8 13.44 37
I531 531 0 1.34816e-05
R632 531 532 1.616 0.8 12.928 37
I532 532 0 1.26158e-05
R633 532 533 1.728 0.8 13.824 37
I533 533 0 1.34816e-05
R634 533 534 1.696 0.8 13.568 37
I534 534 0 1.23684e-05
R635 534 535 1.696 0.8 13.568 37
I535 535 0 1.28631e-05
R636 535 536 1.6 0.8 12.8 37
I536 536 0 1.34816e-05
R637 536 537 1.664 0.8 13.312 37
I537 537 0 1.29868e-05
R638 537 538 1.664 0.8 13.312 37
I538 538 0 1.31105e-05
R639 538 539 1.696 0.8 13.568 37
I539 539 0 1.27395e-05
R640 539 540 1.744 0.8 13.952 37
I540 540 0 1.34816e-05
R641 540 541 1.68 0.8 13.44 37
I541 541 0 1.26158e-05
R642 541 542 1.616 0.8 12.928 37
I542 542 0 1.27395e-05
R643 542 543 1.6 0.8 12.8 37
I543 543 0 1.34816e-05
R644 543 544 1.744 0.8 13.952 37
I544 544 0 1.24921e-05
R645 544 545 1.648 0.8 13.184 37
I545 545 0 1.28631e-05
R646 545 546 1.68 0.8 13.44 37
I546 546 0 1.33579e-05
R647 546 547 1.68 0.8 13.44 37
I547 547 0 1.32342e-05
R648 547 548 1.648 0.8 13.184 37
I548 548 0 1.27395e-05
R649 548 549 1.728 0.8 13.824 37
I549 549 0 1.34816e-05
R650 549 550 1.68 0.8 13.44 37
I550 550 0 1.29868e-05
R651 550 551 1.648 0.8 13.184 37
I551 551 0 1.33579e-05
R652 551 552 1.696 0.8 13.568 37
I552 552 0 1.23684e-05
R653 552 553 1.648 0.8 13.184 37
I553 553 0 1.27395e-05
R654 553 554 1.696 0.8 13.568 37
I554 554 0 1.24921e-05
R655 554 555 1.728 0.8 13.824 37
I555 555 0 1.32342e-05
R656 555 556 1.6 0.8 12.8 37
I556 556 0 1.29868e-05
R657 556 557 1.616 0.8 12.928 37
I557 557 0 1.24921e-05
R658 557 558 1.6 0.8 12.8 37
I558 558 0 1.27395e-05
R659 558 559 1.6 0.8 12.8 37
I559 559 0 1.23684e-05
R660 559 560 1.664 0.8 13.312 37
I560 560 0 1.29868e-05
R661 560 561 1.664 0.8 13.312 37
I561 561 0 1.26158e-05
R662 561 562 1.664 0.8 13.312 37
I562 562 0 1.34816e-05
R663 562 563 1.744 0.8 13.952 37
I563 563 0 1.34816e-05
R664 563 564 1.664 0.8 13.312 37
I564 564 0 1.34816e-05
R665 564 565 1.728 0.8 13.824 37
I565 565 0 1.24921e-05
R666 565 566 1.696 0.8 13.568 37
I566 566 0 1.27395e-05
R667 566 567 1.744 0.8 13.952 37
I567 567 0 1.27395e-05
R668 567 568 1.648 0.8 13.184 37
I568 568 0 1.28631e-05
R669 568 569 1.696 0.8 13.568 37
I569 569 0 1.24921e-05
R670 569 570 1.68 0.8 13.44 37
I570 570 0 1.31105e-05
R671 570 571 1.616 0.8 12.928 37
I571 571 0 1.32342e-05
R672 571 572 1.632 0.8 13.056 37
I572 572 0 1.26158e-05
R673 572 573 1.744 0.8 13.952 37
I573 573 0 1.26158e-05
R674 573 574 1.728 0.8 13.824 37
I574 574 0 1.24921e-05
R675 574 575 1.632 0.8 13.056 37
I575 575 0 1.28631e-05
R676 575 576 1.712 0.8 13.696 37
I576 576 0 1.33579e-05
R677 576 577 1.696 0.8 13.568 37
I577 577 0 1.27395e-05
R678 577 578 1.712 0.8 13.696 37
I578 578 0 1.32342e-05
R679 578 579 1.632 0.8 13.056 37
I579 579 0 1.27395e-05
R680 579 580 1.712 0.8 13.696 37
I580 580 0 1.26158e-05
R681 580 581 1.68 0.8 13.44 37
I581 581 0 1.27395e-05
R682 581 582 1.712 0.8 13.696 37
I582 582 0 1.31105e-05
R683 582 583 1.728 0.8 13.824 37
I583 583 0 1.24921e-05
R684 583 584 1.648 0.8 13.184 37
I584 584 0 1.31105e-05
R685 584 585 1.664 0.8 13.312 37
I585 585 0 1.23684e-05
R686 585 586 1.648 0.8 13.184 37
I586 586 0 1.29868e-05
R687 586 587 1.728 0.8 13.824 37
I587 587 0 1.29868e-05
R688 587 588 1.6 0.8 12.8 37
I588 588 0 1.34816e-05
R689 588 589 1.744 0.8 13.952 37
I589 589 0 1.33579e-05
R690 589 590 1.6 0.8 12.8 37
I590 590 0 1.26158e-05
R691 590 591 1.664 0.8 13.312 37
I591 591 0 1.34816e-05
R692 591 592 1.6 0.8 12.8 37
I592 592 0 1.24921e-05
R693 592 593 1.632 0.8 13.056 37
I593 593 0 1.23684e-05
R694 593 594 1.6 0.8 12.8 37
I594 594 0 1.31105e-05
R695 594 595 1.648 0.8 13.184 37
I595 595 0 1.34816e-05
R696 595 596 1.6 0.8 12.8 37
I596 596 0 1.33579e-05
R697 596 597 1.648 0.8 13.184 37
I597 597 0 1.33579e-05
R698 597 598 1.712 0.8 13.696 37
I598 598 0 1.27395e-05
R699 598 599 1.616 0.8 12.928 37
I599 599 0 1.23684e-05
R700 599 600 1.6 0.8 12.8 37
I600 600 0 1.29868e-05
R701 600 601 1.6 0.8 12.8 37
I601 601 0 1.27395e-05
R702 601 602 1.616 0.8 12.928 37
I602 602 0 1.33579e-05
R703 602 603 1.6 0.8 12.8 37
I603 603 0 1.24921e-05
R704 603 604 1.712 0.8 13.696 37
I604 604 0 1.34816e-05
R705 604 605 1.616 0.8 12.928 37
I605 605 0 1.23684e-05
R706 605 606 1.648 0.8 13.184 37
I606 606 0 1.29868e-05
R707 606 607 1.744 0.8 13.952 37
I607 607 0 1.28631e-05
R708 607 608 1.728 0.8 13.824 37
I608 608 0 1.28631e-05
R709 608 609 1.696 0.8 13.568 37
I609 609 0 1.34816e-05
R710 609 610 1.632 0.8 13.056 37
I610 610 0 1.34816e-05
R711 610 611 1.6 0.8 12.8 37
I611 611 0 1.27395e-05
R712 611 612 1.6 0.8 12.8 37
I612 612 0 1.27395e-05
R713 612 613 1.648 0.8 13.184 37
I613 613 0 1.32342e-05
R714 613 614 1.744 0.8 13.952 37
I614 614 0 1.28631e-05
R715 614 615 1.744 0.8 13.952 37
I615 615 0 1.34816e-05
R716 615 616 1.616 0.8 12.928 37
I616 616 0 1.34816e-05
R717 616 617 1.664 0.8 13.312 37
I617 617 0 1.26158e-05
R718 617 618 1.6 0.8 12.8 37
I618 618 0 1.31105e-05
R719 618 619 1.68 0.8 13.44 37
I619 619 0 1.34816e-05
R720 619 620 1.68 0.8 13.44 37
I620 620 0 1.31105e-05
R721 620 621 1.616 0.8 12.928 37
I621 621 0 1.24921e-05
R722 621 622 1.664 0.8 13.312 37
I622 622 0 1.27395e-05
R723 622 623 1.712 0.8 13.696 37
I623 623 0 1.26158e-05
R724 623 624 1.712 0.8 13.696 37
I624 624 0 1.27395e-05
R725 624 625 1.648 0.8 13.184 37
I625 625 0 1.34816e-05
R726 625 626 1.632 0.8 13.056 37
I626 626 0 1.28631e-05
R727 626 627 1.664 0.8 13.312 37
I627 627 0 1.28631e-05
R728 627 628 1.744 0.8 13.952 37
I628 628 0 1.34816e-05
R729 628 629 1.648 0.8 13.184 37
I629 629 0 1.33579e-05
R730 629 630 1.648 0.8 13.184 37
I630 630 0 1.26158e-05
R731 630 631 1.744 0.8 13.952 37
I631 631 0 1.29868e-05
R732 631 632 1.664 0.8 13.312 37
I632 632 0 1.27395e-05
R733 632 633 1.744 0.8 13.952 37
I633 633 0 1.28631e-05
R734 633 634 1.744 0.8 13.952 37
I634 634 0 1.29868e-05
R735 634 635 1.68 0.8 13.44 37
I635 635 0 1.32342e-05
R736 635 636 1.648 0.8 13.184 37
I636 636 0 1.34816e-05
R737 636 637 1.6 0.8 12.8 37
I637 637 0 1.32342e-05
R738 637 638 1.632 0.8 13.056 37
I638 638 0 1.32342e-05
R739 638 639 1.632 0.8 13.056 37
I639 639 0 1.34816e-05
R740 639 640 1.6 0.8 12.8 37
I640 640 0 1.29868e-05
R741 640 641 1.6 0.8 12.8 37
I641 641 0 1.28631e-05
R742 641 642 1.616 0.8 12.928 37
I642 642 0 1.32342e-05
R743 642 643 1.744 0.8 13.952 37
I643 643 0 1.27395e-05
R744 643 644 1.696 0.8 13.568 37
I644 644 0 1.26158e-05
R745 644 645 1.616 0.8 12.928 37
I645 645 0 1.26158e-05
R746 645 646 1.68 0.8 13.44 37
I646 646 0 1.27395e-05
R747 646 647 1.744 0.8 13.952 37
I647 647 0 1.24921e-05
R748 647 648 1.728 0.8 13.824 37
I648 648 0 1.33579e-05
R749 648 649 1.712 0.8 13.696 37
I649 649 0 1.23684e-05
R750 649 650 1.68 0.8 13.44 37
I650 650 0 1.26158e-05
R751 650 651 1.712 0.8 13.696 37
I651 651 0 1.34816e-05
R752 651 652 1.616 0.8 12.928 37
I652 652 0 1.34816e-05
R753 652 653 1.696 0.8 13.568 37
I653 653 0 1.27395e-05
R754 653 654 1.696 0.8 13.568 37
I654 654 0 1.33579e-05
R755 654 655 1.664 0.8 13.312 37
I655 655 0 1.31105e-05
R756 655 656 1.696 0.8 13.568 37
I656 656 0 1.32342e-05
R757 656 657 1.632 0.8 13.056 37
I657 657 0 1.32342e-05
R758 657 658 1.664 0.8 13.312 37
I658 658 0 1.24921e-05
R759 658 659 1.6 0.8 12.8 37
I659 659 0 1.23684e-05
R760 659 660 1.696 0.8 13.568 37
I660 660 0 1.28631e-05
R761 660 661 1.664 0.8 13.312 37
I661 661 0 1.27395e-05
R762 661 662 1.712 0.8 13.696 37
I662 662 0 1.27395e-05
R763 662 663 1.664 0.8 13.312 37
I663 663 0 1.32342e-05
R764 663 664 1.632 0.8 13.056 37
I664 664 0 1.24921e-05
R765 664 665 1.712 0.8 13.696 37
I665 665 0 1.34816e-05
R766 665 666 1.68 0.8 13.44 37
I666 666 0 1.31105e-05
R767 666 667 1.728 0.8 13.824 37
I667 667 0 1.34816e-05
R768 667 668 1.68 0.8 13.44 37
I668 668 0 1.29868e-05
R769 668 669 1.632 0.8 13.056 37
I669 669 0 1.24921e-05
R770 669 670 1.68 0.8 13.44 37
I670 670 0 1.34816e-05
R771 670 671 1.744 0.8 13.952 37
I671 671 0 1.24921e-05
R772 671 672 1.696 0.8 13.568 37
I672 672 0 1.26158e-05
R773 672 673 1.616 0.8 12.928 37
I673 673 0 1.23684e-05
R774 673 674 1.68 0.8 13.44 37
I674 674 0 1.27395e-05
R775 674 675 1.632 0.8 13.056 37
I675 675 0 1.24921e-05
R776 675 676 1.744 0.8 13.952 37
I676 676 0 1.32342e-05
R777 676 677 1.696 0.8 13.568 37
I677 677 0 1.33579e-05
R778 677 678 1.632 0.8 13.056 37
I678 678 0 1.23684e-05
R779 678 679 1.696 0.8 13.568 37
I679 679 0 1.28631e-05
R780 679 680 1.648 0.8 13.184 37
I680 680 0 1.27395e-05
R781 680 681 1.696 0.8 13.568 37
I681 681 0 1.34816e-05
R782 681 682 1.6 0.8 12.8 37
I682 682 0 1.28631e-05
R783 682 683 1.728 0.8 13.824 37
I683 683 0 1.29868e-05
R784 683 684 1.616 0.8 12.928 37
I684 684 0 1.26158e-05
R785 684 685 1.744 0.8 13.952 37
I685 685 0 1.32342e-05
R786 685 686 1.648 0.8 13.184 37
I686 686 0 1.33579e-05
R787 686 687 1.6 0.8 12.8 37
I687 687 0 1.34816e-05
R788 687 688 1.632 0.8 13.056 37
I688 688 0 1.27395e-05
R789 688 689 1.616 0.8 12.928 37
I689 689 0 1.33579e-05
R790 689 690 1.712 0.8 13.696 37
I690 690 0 1.28631e-05
R791 690 691 1.616 0.8 12.928 37
I691 691 0 1.31105e-05
R792 691 692 1.648 0.8 13.184 37
I692 692 0 1.33579e-05
R793 692 693 1.68 0.8 13.44 37
I693 693 0 1.29868e-05
R794 693 694 1.6 0.8 12.8 37
I694 694 0 1.24921e-05
R795 694 695 1.632 0.8 13.056 37
I695 695 0 1.31105e-05
R796 695 696 1.664 0.8 13.312 37
I696 696 0 1.33579e-05
R797 696 697 1.68 0.8 13.44 37
I697 697 0 1.31105e-05
R798 697 698 1.632 0.8 13.056 37
I698 698 0 1.29868e-05
R799 698 699 1.632 0.8 13.056 37
I699 699 0 1.31105e-05
R800 699 700 1.744 0.8 13.952 37
I700 700 0 1.24921e-05
R801 700 701 1.648 0.8 13.184 37
I701 701 0 1.27395e-05
R802 701 702 1.616 0.8 12.928 37
I702 702 0 1.29868e-05
R803 702 703 1.632 0.8 13.056 37
I703 703 0 1.31105e-05
R804 703 704 1.744 0.8 13.952 37
I704 704 0 1.28631e-05
R805 704 705 1.664 0.8 13.312 37
I705 705 0 1.31105e-05
R806 705 706 1.6 0.8 12.8 37
I706 706 0 1.32342e-05
R807 706 707 1.664 0.8 13.312 37
I707 707 0 1.27395e-05
R808 707 708 1.712 0.8 13.696 37
I708 708 0 1.34816e-05
R809 708 709 1.6 0.8 12.8 37
I709 709 0 1.23684e-05
R810 709 710 1.632 0.8 13.056 37
I710 710 0 1.26158e-05
R811 710 711 1.696 0.8 13.568 37
I711 711 0 1.34816e-05
R812 711 712 1.6 0.8 12.8 37
I712 712 0 1.27395e-05
R813 712 713 1.68 0.8 13.44 37
I713 713 0 1.29868e-05
R814 713 714 1.728 0.8 13.824 37
I714 714 0 1.32342e-05
R815 714 715 1.616 0.8 12.928 37
I715 715 0 1.32342e-05
R816 715 716 1.6 0.8 12.8 37
I716 716 0 1.31105e-05
R817 716 717 1.6 0.8 12.8 37
I717 717 0 1.28631e-05
R818 717 718 1.616 0.8 12.928 37
I718 718 0 1.27395e-05
R819 718 719 1.6 0.8 12.8 37
I719 719 0 1.26158e-05
R820 719 720 1.744 0.8 13.952 37
I720 720 0 1.31105e-05
R821 720 721 1.6 0.8 12.8 37
I721 721 0 1.34816e-05
R822 721 722 1.648 0.8 13.184 37
I722 722 0 1.29868e-05
R823 722 723 1.664 0.8 13.312 37
I723 723 0 1.27395e-05
R824 723 724 1.696 0.8 13.568 37
I724 724 0 1.28631e-05
R825 724 725 1.648 0.8 13.184 37
I725 725 0 1.24921e-05
R826 725 726 1.744 0.8 13.952 37
I726 726 0 1.24921e-05
R827 726 727 1.6 0.8 12.8 37
I727 727 0 1.34816e-05
R828 727 728 1.664 0.8 13.312 37
I728 728 0 1.29868e-05
R829 728 729 1.696 0.8 13.568 37
I729 729 0 1.26158e-05
R830 729 730 1.68 0.8 13.44 37
I730 730 0 1.34816e-05
R831 730 731 1.616 0.8 12.928 37
I731 731 0 1.32342e-05
R832 731 732 1.712 0.8 13.696 37
I732 732 0 1.28631e-05
R833 732 733 1.616 0.8 12.928 37
I733 733 0 1.24921e-05
R834 733 734 1.744 0.8 13.952 37
I734 734 0 1.24921e-05
R835 734 735 1.648 0.8 13.184 37
I735 735 0 1.33579e-05
R836 735 736 1.712 0.8 13.696 37
I736 736 0 1.28631e-05
R837 736 737 1.744 0.8 13.952 37
I737 737 0 1.27395e-05
R838 737 738 1.616 0.8 12.928 37
I738 738 0 1.27395e-05
R839 738 739 1.728 0.8 13.824 37
I739 739 0 1.32342e-05
R840 739 740 1.744 0.8 13.952 37
I740 740 0 1.27395e-05
R841 740 741 1.728 0.8 13.824 37
I741 741 0 1.33579e-05
R842 741 742 1.664 0.8 13.312 37
I742 742 0 1.23684e-05
R843 742 743 1.6 0.8 12.8 37
I743 743 0 1.33579e-05
R844 743 744 1.696 0.8 13.568 37
I744 744 0 1.33579e-05
R845 744 745 1.632 0.8 13.056 37
I745 745 0 1.27395e-05
R846 745 746 1.728 0.8 13.824 37
I746 746 0 1.29868e-05
R847 746 747 1.6 0.8 12.8 37
I747 747 0 1.29868e-05
R848 747 748 1.744 0.8 13.952 37
I748 748 0 1.26158e-05
R849 748 749 1.696 0.8 13.568 37
I749 749 0 1.33579e-05
R850 749 750 1.68 0.8 13.44 37
I750 750 0 1.26158e-05
R851 750 751 1.728 0.8 13.824 37
I751 751 0 1.27395e-05
R852 751 752 1.696 0.8 13.568 37
I752 752 0 1.32342e-05
R853 752 753 1.728 0.8 13.824 37
I753 753 0 1.32342e-05
R854 753 754 1.632 0.8 13.056 37
I754 754 0 1.31105e-05
R855 754 755 1.696 0.8 13.568 37
I755 755 0 1.26158e-05
R856 755 756 1.744 0.8 13.952 37
I756 756 0 1.32342e-05
R857 756 757 1.6 0.8 12.8 37
I757 757 0 1.27395e-05
R858 757 758 1.712 0.8 13.696 37
I758 758 0 1.26158e-05
R859 758 759 1.648 0.8 13.184 37
I759 759 0 1.29868e-05
R860 759 760 1.616 0.8 12.928 37
I760 760 0 1.32342e-05
R861 760 761 1.728 0.8 13.824 37
I761 761 0 1.34816e-05
R862 761 762 1.664 0.8 13.312 37
I762 762 0 1.24921e-05
R863 762 763 1.696 0.8 13.568 37
I763 763 0 1.28631e-05
R864 763 764 1.648 0.8 13.184 37
I764 764 0 1.29868e-05
R865 764 765 1.664 0.8 13.312 37
I765 765 0 1.33579e-05
R866 765 766 1.712 0.8 13.696 37
I766 766 0 1.27395e-05
R867 766 767 1.648 0.8 13.184 37
I767 767 0 1.29868e-05
R868 767 768 1.6 0.8 12.8 37
I768 768 0 1.24921e-05
R869 768 769 1.664 0.8 13.312 37
I769 769 0 1.29868e-05
R870 769 770 1.712 0.8 13.696 37
I770 770 0 1.23684e-05
R871 770 771 1.712 0.8 13.696 37
I771 771 0 1.33579e-05
R872 771 772 1.744 0.8 13.952 37
I772 772 0 1.34816e-05
R873 772 773 1.648 0.8 13.184 37
I773 773 0 1.34816e-05
R874 773 774 1.664 0.8 13.312 37
I774 774 0 1.31105e-05
R875 774 775 1.664 0.8 13.312 37
I775 775 0 1.29868e-05
R876 775 776 1.68 0.8 13.44 37
I776 776 0 1.29868e-05
R877 776 777 1.696 0.8 13.568 37
I777 777 0 1.23684e-05
R878 777 778 1.696 0.8 13.568 37
I778 778 0 1.26158e-05
R879 778 779 1.696 0.8 13.568 37
I779 779 0 1.34816e-05
R880 779 780 1.744 0.8 13.952 37
I780 780 0 1.26158e-05
R881 780 781 1.744 0.8 13.952 37
I781 781 0 1.31105e-05
R882 781 782 1.68 0.8 13.44 37
I782 782 0 1.29868e-05
R883 782 783 1.648 0.8 13.184 37
I783 783 0 1.33579e-05
R884 783 784 1.696 0.8 13.568 37
I784 784 0 1.32342e-05
R885 784 785 1.648 0.8 13.184 37
I785 785 0 1.31105e-05
R886 785 786 1.6 0.8 12.8 37
I786 786 0 1.26158e-05
R887 786 787 1.696 0.8 13.568 37
I787 787 0 1.34816e-05
R888 787 788 1.648 0.8 13.184 37
I788 788 0 1.23684e-05
R889 788 789 1.728 0.8 13.824 37
I789 789 0 1.32342e-05
R890 789 790 1.696 0.8 13.568 37
I790 790 0 1.29868e-05
R891 790 791 1.632 0.8 13.056 37
I791 791 0 1.28631e-05
R892 791 792 1.6 0.8 12.8 37
I792 792 0 1.23684e-05
R893 792 793 1.696 0.8 13.568 37
I793 793 0 1.33579e-05
R894 793 794 1.68 0.8 13.44 37
I794 794 0 1.28631e-05
R895 794 795 1.744 0.8 13.952 37
I795 795 0 1.28631e-05
R896 795 796 1.696 0.8 13.568 37
I796 796 0 1.33579e-05
R897 796 797 1.648 0.8 13.184 37
I797 797 0 1.26158e-05
R898 797 798 1.648 0.8 13.184 37
I798 798 0 1.31105e-05
R899 798 799 1.632 0.8 13.056 37
I799 799 0 1.26158e-05
R900 799 800 1.664 0.8 13.312 37
I800 800 0 1.32342e-05
R901 800 801 1.6 0.8 12.8 37
I801 801 0 1.28631e-05
R902 801 802 1.744 0.8 13.952 37
I802 802 0 1.31105e-05
R903 802 803 1.68 0.8 13.44 37
I803 803 0 1.28631e-05
R904 803 804 1.696 0.8 13.568 37
I804 804 0 1.28631e-05
R905 804 805 1.632 0.8 13.056 37
I805 805 0 1.29868e-05
R906 805 806 1.616 0.8 12.928 37
I806 806 0 1.31105e-05
R907 806 807 1.616 0.8 12.928 37
I807 807 0 1.27395e-05
R908 807 808 1.712 0.8 13.696 37
I808 808 0 1.32342e-05
R909 808 809 1.616 0.8 12.928 37
I809 809 0 1.26158e-05
R910 809 810 1.616 0.8 12.928 37
I810 810 0 1.23684e-05
R911 810 811 1.728 0.8 13.824 37
I811 811 0 1.34816e-05
R912 811 812 1.6 0.8 12.8 37
I812 812 0 1.24921e-05
R913 812 813 1.648 0.8 13.184 37
I813 813 0 1.28631e-05
R914 813 814 1.728 0.8 13.824 37
I814 814 0 1.29868e-05
R915 814 815 1.728 0.8 13.824 37
I815 815 0 1.26158e-05
R916 815 816 1.632 0.8 13.056 37
I816 816 0 1.23684e-05
R917 816 817 1.696 0.8 13.568 37
I817 817 0 1.27395e-05
R918 817 818 1.696 0.8 13.568 37
I818 818 0 1.24921e-05
R919 818 819 1.6 0.8 12.8 37
I819 819 0 1.29868e-05
R920 819 820 1.712 0.8 13.696 37
I820 820 0 1.28631e-05
R921 820 821 1.632 0.8 13.056 37
I821 821 0 1.23684e-05
R922 821 822 1.6 0.8 12.8 37
I822 822 0 1.27395e-05
R923 822 823 1.648 0.8 13.184 37
I823 823 0 1.34816e-05
R924 823 824 1.6 0.8 12.8 37
I824 824 0 1.28631e-05
R925 824 825 1.648 0.8 13.184 37
I825 825 0 1.27395e-05
R926 825 826 1.664 0.8 13.312 37
I826 826 0 1.26158e-05
R927 826 827 1.664 0.8 13.312 37
I827 827 0 1.29868e-05
R928 827 828 1.648 0.8 13.184 37
I828 828 0 1.33579e-05
R929 828 829 1.616 0.8 12.928 37
I829 829 0 1.24921e-05
R930 829 830 1.648 0.8 13.184 37
I830 830 0 1.24921e-05
R931 830 831 1.68 0.8 13.44 37
I831 831 0 1.33579e-05
R932 831 832 1.616 0.8 12.928 37
I832 832 0 1.27395e-05
R933 832 833 1.648 0.8 13.184 37
I833 833 0 1.34816e-05
R934 833 834 1.712 0.8 13.696 37
I834 834 0 1.29868e-05
R935 834 835 1.664 0.8 13.312 37
I835 835 0 1.28631e-05
R936 835 836 1.744 0.8 13.952 37
I836 836 0 1.31105e-05
R937 836 837 1.712 0.8 13.696 37
I837 837 0 1.26158e-05
R938 837 838 1.616 0.8 12.928 37
I838 838 0 1.23684e-05
R939 838 839 1.616 0.8 12.928 37
I839 839 0 1.27395e-05
R940 839 840 1.712 0.8 13.696 37
I840 840 0 1.32342e-05
R941 840 841 1.696 0.8 13.568 37
I841 841 0 1.27395e-05
R942 841 842 1.744 0.8 13.952 37
I842 842 0 1.24921e-05
R943 842 843 1.6 0.8 12.8 37
I843 843 0 1.28631e-05
R944 843 844 1.616 0.8 12.928 37
I844 844 0 1.24921e-05
R945 844 845 1.728 0.8 13.824 37
I845 845 0 1.31105e-05
R946 845 846 1.664 0.8 13.312 37
I846 846 0 1.27395e-05
R947 846 847 1.664 0.8 13.312 37
I847 847 0 1.32342e-05
R948 847 848 1.712 0.8 13.696 37
I848 848 0 1.23684e-05
R949 848 849 1.712 0.8 13.696 37
I849 849 0 1.28631e-05
R950 849 850 1.68 0.8 13.44 37
I850 850 0 1.27395e-05
R951 850 851 1.6 0.8 12.8 37
I851 851 0 1.32342e-05
R952 851 852 1.632 0.8 13.056 37
I852 852 0 1.34816e-05
R953 852 853 1.744 0.8 13.952 37
I853 853 0 1.27395e-05
R954 853 854 1.6 0.8 12.8 37
I854 854 0 1.26158e-05
R955 854 855 1.712 0.8 13.696 37
I855 855 0 1.34816e-05
R956 855 856 1.744 0.8 13.952 37
I856 856 0 1.29868e-05
R957 856 857 1.632 0.8 13.056 37
I857 857 0 1.23684e-05
R958 857 858 1.728 0.8 13.824 37
I858 858 0 1.27395e-05
R959 858 859 1.68 0.8 13.44 37
I859 859 0 1.34816e-05
R960 859 860 1.696 0.8 13.568 37
I860 860 0 1.29868e-05
R961 860 861 1.696 0.8 13.568 37
I861 861 0 1.27395e-05
R962 861 862 1.6 0.8 12.8 37
I862 862 0 1.26158e-05
R963 862 863 1.6 0.8 12.8 37
I863 863 0 1.32342e-05
R964 863 864 1.664 0.8 13.312 37
I864 864 0 1.32342e-05
R965 864 865 1.648 0.8 13.184 37
I865 865 0 1.23684e-05
R966 865 866 1.616 0.8 12.928 37
I866 866 0 1.31105e-05
R967 866 867 1.712 0.8 13.696 37
I867 867 0 1.29868e-05
R968 867 868 1.712 0.8 13.696 37
I868 868 0 1.33579e-05
R969 868 869 1.728 0.8 13.824 37
I869 869 0 1.34816e-05
R970 869 870 1.6 0.8 12.8 37
I870 870 0 1.32342e-05
R971 870 871 1.728 0.8 13.824 37
I871 871 0 1.23684e-05
R972 871 872 1.648 0.8 13.184 37
I872 872 0 1.24921e-05
R973 872 873 1.6 0.8 12.8 37
I873 873 0 1.27395e-05
R974 873 874 1.696 0.8 13.568 37
I874 874 0 1.32342e-05
R975 874 875 1.648 0.8 13.184 37
I875 875 0 1.26158e-05
R976 875 876 1.632 0.8 13.056 37
I876 876 0 1.24921e-05
R977 876 877 1.68 0.8 13.44 37
I877 877 0 1.27395e-05
R978 877 878 1.648 0.8 13.184 37
I878 878 0 1.33579e-05
R979 878 879 1.632 0.8 13.056 37
I879 879 0 1.33579e-05
R980 879 880 1.68 0.8 13.44 37
I880 880 0 1.33579e-05
R981 880 881 1.6 0.8 12.8 37
I881 881 0 1.33579e-05
R982 881 882 1.696 0.8 13.568 37
I882 882 0 1.34816e-05
R983 882 883 1.648 0.8 13.184 37
I883 883 0 1.27395e-05
R984 883 884 1.712 0.8 13.696 37
I884 884 0 1.28631e-05
R985 884 885 1.648 0.8 13.184 37
I885 885 0 1.32342e-05
R986 885 886 1.616 0.8 12.928 37
I886 886 0 1.27395e-05
R987 886 887 1.744 0.8 13.952 37
I887 887 0 1.31105e-05
R988 887 888 1.664 0.8 13.312 37
I888 888 0 1.26158e-05
R989 888 889 1.6 0.8 12.8 37
I889 889 0 1.26158e-05
R990 889 890 1.744 0.8 13.952 37
I890 890 0 1.29868e-05
R991 890 891 1.712 0.8 13.696 37
I891 891 0 1.28631e-05
R992 891 892 1.696 0.8 13.568 37
I892 892 0 1.28631e-05
R993 892 893 1.744 0.8 13.952 37
I893 893 0 1.24921e-05
R994 893 894 1.632 0.8 13.056 37
I894 894 0 1.27395e-05
R995 894 895 1.616 0.8 12.928 37
I895 895 0 1.33579e-05
R996 895 896 1.616 0.8 12.928 37
I896 896 0 1.27395e-05
R997 896 897 1.728 0.8 13.824 37
I897 897 0 1.34816e-05
R998 897 898 1.632 0.8 13.056 37
I898 898 0 1.28631e-05
R999 898 899 1.68 0.8 13.44 37
I899 899 0 1.24921e-05
R1000 899 900 1.6 0.8 12.8 37
I900 900 0 1.23684e-05
R1001 900 901 1.616 0.8 12.928 37
I901 901 0 1.27395e-05
R1002 901 902 1.648 0.8 13.184 37
I902 902 0 1.23684e-05
R1003 902 903 1.6 0.8 12.8 37
I903 903 0 1.23684e-05
R1004 903 904 1.632 0.8 13.056 37
I904 904 0 1.26158e-05
R1005 904 905 1.632 0.8 13.056 37
I905 905 0 1.28631e-05
R1006 905 906 1.712 0.8 13.696 37
I906 906 0 1.34816e-05
R1007 906 907 1.728 0.8 13.824 37
I907 907 0 1.29868e-05
R1008 907 908 1.664 0.8 13.312 37
I908 908 0 1.32342e-05
R1009 908 909 1.728 0.8 13.824 37
I909 909 0 1.31105e-05
R1010 909 910 1.6 0.8 12.8 37
I910 910 0 1.23684e-05
R1011 910 911 1.696 0.8 13.568 37
I911 911 0 1.28631e-05
R1012 911 912 1.648 0.8 13.184 37
I912 912 0 1.32342e-05
R1013 912 913 1.68 0.8 13.44 37
I913 913 0 1.33579e-05
R1014 913 914 1.616 0.8 12.928 37
I914 914 0 1.23684e-05
R1015 914 915 1.744 0.8 13.952 37
I915 915 0 1.27395e-05
R1016 915 916 1.6 0.8 12.8 37
I916 916 0 1.26158e-05
R1017 916 917 1.696 0.8 13.568 37
I917 917 0 1.28631e-05
R1018 917 918 1.648 0.8 13.184 37
I918 918 0 1.33579e-05
R1019 918 919 1.696 0.8 13.568 37
I919 919 0 1.32342e-05
R1020 919 920 1.6 0.8 12.8 37
I920 920 0 1.33579e-05
R1021 920 921 1.616 0.8 12.928 37
I921 921 0 1.34816e-05
R1022 921 922 1.728 0.8 13.824 37
I922 922 0 1.24921e-05
R1023 922 923 1.696 0.8 13.568 37
I923 923 0 1.28631e-05
R1024 923 924 1.728 0.8 13.824 37
I924 924 0 1.29868e-05
R1025 924 925 1.6 0.8 12.8 37
I925 925 0 1.24921e-05
R1026 925 926 1.68 0.8 13.44 37
I926 926 0 1.34816e-05
R1027 926 927 1.712 0.8 13.696 37
I927 927 0 1.23684e-05
R1028 927 928 1.696 0.8 13.568 37
I928 928 0 1.26158e-05
R1029 928 929 1.728 0.8 13.824 37
I929 929 0 1.34816e-05
R1030 929 930 1.68 0.8 13.44 37
I930 930 0 1.23684e-05
R1031 930 931 1.632 0.8 13.056 37
I931 931 0 1.32342e-05
R1032 931 932 1.632 0.8 13.056 37
I932 932 0 1.33579e-05
R1033 932 933 1.616 0.8 12.928 37
I933 933 0 1.32342e-05
R1034 933 934 1.712 0.8 13.696 37
I934 934 0 1.34816e-05
R1035 934 935 1.712 0.8 13.696 37
I935 935 0 1.34816e-05
R1036 935 936 1.728 0.8 13.824 37
I936 936 0 1.33579e-05
R1037 936 937 1.744 0.8 13.952 37
I937 937 0 1.33579e-05
R1038 937 938 1.6 0.8 12.8 37
I938 938 0 1.29868e-05
R1039 938 939 1.632 0.8 13.056 37
I939 939 0 1.23684e-05
R1040 939 940 1.632 0.8 13.056 37
I940 940 0 1.28631e-05
R1041 940 941 1.648 0.8 13.184 37
I941 941 0 1.32342e-05
R1042 941 942 1.648 0.8 13.184 37
I942 942 0 1.23684e-05
R1043 942 943 1.6 0.8 12.8 37
I943 943 0 1.24921e-05
R1044 943 944 1.68 0.8 13.44 37
I944 944 0 1.33579e-05
R1045 944 945 1.6 0.8 12.8 37
I945 945 0 1.23684e-05
R1046 945 946 1.6 0.8 12.8 37
I946 946 0 1.28631e-05
R1047 946 947 1.712 0.8 13.696 37
I947 947 0 1.29868e-05
R1048 947 948 1.648 0.8 13.184 37
I948 948 0 1.24921e-05
R1049 948 949 1.664 0.8 13.312 37
I949 949 0 1.26158e-05
R1050 949 950 1.6 0.8 12.8 37
I950 950 0 1.24921e-05
R1051 950 951 1.648 0.8 13.184 37
I951 951 0 1.23684e-05
R1052 951 952 1.6 0.8 12.8 37
I952 952 0 1.28631e-05
R1053 952 953 1.728 0.8 13.824 37
I953 953 0 1.26158e-05
R1054 953 954 1.632 0.8 13.056 37
I954 954 0 1.23684e-05
R1055 954 955 1.632 0.8 13.056 37
I955 955 0 1.28631e-05
R1056 955 956 1.68 0.8 13.44 37
I956 956 0 1.33579e-05
R1057 956 957 1.664 0.8 13.312 37
I957 957 0 1.23684e-05
R1058 957 958 1.728 0.8 13.824 37
I958 958 0 1.28631e-05
R1059 958 959 1.632 0.8 13.056 37
I959 959 0 1.29868e-05
R1060 959 960 1.664 0.8 13.312 37
I960 960 0 1.26158e-05
R1061 960 961 1.712 0.8 13.696 37
I961 961 0 1.29868e-05
R1062 961 962 1.712 0.8 13.696 37
I962 962 0 1.29868e-05
R1063 962 963 1.632 0.8 13.056 37
I963 963 0 1.26158e-05
R1064 963 964 1.728 0.8 13.824 37
I964 964 0 1.31105e-05
R1065 964 965 1.696 0.8 13.568 37
I965 965 0 1.23684e-05
R1066 965 966 1.6 0.8 12.8 37
I966 966 0 1.34816e-05
R1067 966 967 1.616 0.8 12.928 37
I967 967 0 1.26158e-05
R1068 967 968 1.696 0.8 13.568 37
I968 968 0 1.34816e-05
R1069 968 969 1.664 0.8 13.312 37
I969 969 0 1.33579e-05
R1070 969 970 1.632 0.8 13.056 37
I970 970 0 1.33579e-05
R1071 970 971 1.632 0.8 13.056 37
I971 971 0 1.32342e-05
R1072 971 972 1.728 0.8 13.824 37
I972 972 0 1.31105e-05
R1073 972 973 1.712 0.8 13.696 37
I973 973 0 1.32342e-05
R1074 973 974 1.6 0.8 12.8 37
I974 974 0 1.34816e-05
R1075 974 975 1.664 0.8 13.312 37
I975 975 0 1.29868e-05
R1076 975 976 1.664 0.8 13.312 37
I976 976 0 1.26158e-05
R1077 976 977 1.632 0.8 13.056 37
I977 977 0 1.27395e-05
R1078 977 978 1.744 0.8 13.952 37
I978 978 0 1.31105e-05
R1079 978 979 1.68 0.8 13.44 37
I979 979 0 1.32342e-05
R1080 979 980 1.664 0.8 13.312 37
I980 980 0 1.27395e-05
R1081 980 981 1.744 0.8 13.952 37
I981 981 0 1.28631e-05
R1082 981 982 1.664 0.8 13.312 37
I982 982 0 1.23684e-05
R1083 982 983 1.696 0.8 13.568 37
I983 983 0 1.23684e-05
R1084 983 984 1.632 0.8 13.056 37
I984 984 0 1.26158e-05
R1085 984 985 1.728 0.8 13.824 37
I985 985 0 1.28631e-05
R1086 985 986 1.648 0.8 13.184 37
I986 986 0 1.24921e-05
R1087 986 987 1.616 0.8 12.928 37
I987 987 0 1.24921e-05
R1088 987 988 1.744 0.8 13.952 37
I988 988 0 1.23684e-05
R1089 988 989 1.6 0.8 12.8 37
I989 989 0 1.23684e-05
R1090 989 990 1.632 0.8 13.056 37
I990 990 0 1.29868e-05
R1091 990 991 1.712 0.8 13.696 37
I991 991 0 1.31105e-05
R1092 991 992 1.744 0.8 13.952 37
I992 992 0 1.24921e-05
R1093 992 993 1.744 0.8 13.952 37
I993 993 0 1.33579e-05
R1094 993 994 1.712 0.8 13.696 37
I994 994 0 1.31105e-05
R1095 994 995 1.68 0.8 13.44 37
I995 995 0 1.24921e-05
R1096 995 996 1.616 0.8 12.928 37
I996 996 0 1.28631e-05
R1097 996 997 1.728 0.8 13.824 37
I997 997 0 1.29868e-05
R1098 997 998 1.712 0.8 13.696 37
I998 998 0 1.31105e-05
R1099 998 999 1.696 0.8 13.568 37
I999 999 0 1.34816e-05
R1100 999 1000 1.616 0.8 12.928 37
I1000 1000 0 1.23684e-05
R1101 1000 10001 0.5 10 50 37
*seg: 2
* inter-segment connection
R1102 1010 2010 6.16 0.8 49.28 37
R1103 1020 2020 6.16 0.8 49.28 37
R1104 1030 2030 6.16 0.8 49.28 37
R1105 1040 2040 6.16 0.8 49.28 37
R1106 1050 2050 6.16 0.8 49.28 37
R1107 1060 2060 6.16 0.8 49.28 37
R1108 1070 2070 6.16 0.8 49.28 37
R1109 1080 2080 6.16 0.8 49.28 37
R1110 1090 2090 6.16 0.8 49.28 37
R1111 1100 2100 6.16 0.8 49.28 37
R1112 1110 2110 6.16 0.8 49.28 37
R1113 1120 2120 6.16 0.8 49.28 37
R1114 1130 2130 6.16 0.8 49.28 37
R1115 1140 2140 6.16 0.8 49.28 37
R1116 1150 2150 6.16 0.8 49.28 37
R1117 1160 2160 6.16 0.8 49.28 37
R1118 1170 2170 6.16 0.8 49.28 37
R1119 1180 2180 6.16 0.8 49.28 37
R1120 1190 2190 6.16 0.8 49.28 37
R1121 1200 2200 6.16 0.8 49.28 37
R1122 1210 2210 6.16 0.8 49.28 37
R1123 1220 2220 6.16 0.8 49.28 37
R1124 1230 2230 6.16 0.8 49.28 37
R1125 1240 2240 6.16 0.8 49.28 37
R1126 1250 2250 6.16 0.8 49.28 37
R1127 1260 2260 6.16 0.8 49.28 37
R1128 1270 2270 6.16 0.8 49.28 37
R1129 1280 2280 6.16 0.8 49.28 37
R1130 1290 2290 6.16 0.8 49.28 37
R1131 1300 2300 6.16 0.8 49.28 37
R1132 1310 2310 6.16 0.8 49.28 37
R1133 1320 2320 6.16 0.8 49.28 37
R1134 1330 2330 6.16 0.8 49.28 37
R1135 1340 2340 6.16 0.8 49.28 37
R1136 1350 2350 6.16 0.8 49.28 37
R1137 1360 2360 6.16 0.8 49.28 37
R1138 1370 2370 6.16 0.8 49.28 37
R1139 1380 2380 6.16 0.8 49.28 37
R1140 1390 2390 6.16 0.8 49.28 37
R1141 1400 2400 6.16 0.8 49.28 37
R1142 1410 2410 6.16 0.8 49.28 37
R1143 1420 2420 6.16 0.8 49.28 37
R1144 1430 2430 6.16 0.8 49.28 37
R1145 1440 2440 6.16 0.8 49.28 37
R1146 1450 2450 6.16 0.8 49.28 37
R1147 1460 2460 6.16 0.8 49.28 37
R1148 1470 2470 6.16 0.8 49.28 37
R1149 1480 2480 6.16 0.8 49.28 37
R1150 1490 2490 6.16 0.8 49.28 37
R1151 1500 2500 6.16 0.8 49.28 37
R1152 1510 2510 6.16 0.8 49.28 37
R1153 1520 2520 6.16 0.8 49.28 37
R1154 1530 2530 6.16 0.8 49.28 37
R1155 1540 2540 6.16 0.8 49.28 37
R1156 1550 2550 6.16 0.8 49.28 37
R1157 1560 2560 6.16 0.8 49.28 37
R1158 1570 2570 6.16 0.8 49.28 37
R1159 1580 2580 6.16 0.8 49.28 37
R1160 1590 2590 6.16 0.8 49.28 37
R1161 1600 2600 6.16 0.8 49.28 37
R1162 1610 2610 6.16 0.8 49.28 37
R1163 1620 2620 6.16 0.8 49.28 37
R1164 1630 2630 6.16 0.8 49.28 37
R1165 1640 2640 6.16 0.8 49.28 37
R1166 1650 2650 6.16 0.8 49.28 37
R1167 1660 2660 6.16 0.8 49.28 37
R1168 1670 2670 6.16 0.8 49.28 37
R1169 1680 2680 6.16 0.8 49.28 37
R1170 1690 2690 6.16 0.8 49.28 37
R1171 1700 2700 6.16 0.8 49.28 37
R1172 1710 2710 6.16 0.8 49.28 37
R1173 1720 2720 6.16 0.8 49.28 37
R1174 1730 2730 6.16 0.8 49.28 37
R1175 1740 2740 6.16 0.8 49.28 37
R1176 1750 2750 6.16 0.8 49.28 37
R1177 1760 2760 6.16 0.8 49.28 37
R1178 1770 2770 6.16 0.8 49.28 37
R1179 1780 2780 6.16 0.8 49.28 37
R1180 1790 2790 6.16 0.8 49.28 37
R1181 1800 2800 6.16 0.8 49.28 37
R1182 1810 2810 6.16 0.8 49.28 37
R1183 1820 2820 6.16 0.8 49.28 37
R1184 1830 2830 6.16 0.8 49.28 37
R1185 1840 2840 6.16 0.8 49.28 37
R1186 1850 2850 6.16 0.8 49.28 37
R1187 1860 2860 6.16 0.8 49.28 37
R1188 1870 2870 6.16 0.8 49.28 37
R1189 1880 2880 6.16 0.8 49.28 37
R1190 1890 2890 6.16 0.8 49.28 37
R1191 1900 2900 6.16 0.8 49.28 37
R1192 1910 2910 6.16 0.8 49.28 37
R1193 1920 2920 6.16 0.8 49.28 37
R1194 1930 2930 6.16 0.8 49.28 37
R1195 1940 2940 6.16 0.8 49.28 37
R1196 1950 2950 6.16 0.8 49.28 37
R1197 1960 2960 6.16 0.8 49.28 37
R1198 1970 2970 6.16 0.8 49.28 37
R1199 1980 2980 6.16 0.8 49.28 37
R1200 1990 2990 6.16 0.8 49.28 37
R1201 2000 3000 6.16 0.8 49.28 37
R1202 10001 1001 0.4 20 80 37
I1001 1001 0 1.28631e-05
R1203 1001 1002 1.648 0.8 13.184 37
I1002 1002 0 1.31105e-05
R1204 1002 1003 1.712 0.8 13.696 37
I1003 1003 0 1.31105e-05
R1205 1003 1004 1.744 0.8 13.952 37
I1004 1004 0 1.32342e-05
R1206 1004 1005 1.696 0.8 13.568 37
I1005 1005 0 1.23684e-05
R1207 1005 1006 1.744 0.8 13.952 37
I1006 1006 0 1.23684e-05
R1208 1006 1007 1.712 0.8 13.696 37
I1007 1007 0 1.31105e-05
R1209 1007 1008 1.696 0.8 13.568 37
I1008 1008 0 1.33579e-05
R1210 1008 1009 1.712 0.8 13.696 37
I1009 1009 0 1.32342e-05
R1211 1009 1010 1.696 0.8 13.568 37
I1010 1010 0 1.31105e-05
R1212 1010 1011 1.68 0.8 13.44 37
I1011 1011 0 1.27395e-05
R1213 1011 1012 1.712 0.8 13.696 37
I1012 1012 0 1.31105e-05
R1214 1012 1013 1.744 0.8 13.952 37
I1013 1013 0 1.32342e-05
R1215 1013 1014 1.632 0.8 13.056 37
I1014 1014 0 1.31105e-05
R1216 1014 1015 1.664 0.8 13.312 37
I1015 1015 0 1.23684e-05
R1217 1015 1016 1.712 0.8 13.696 37
I1016 1016 0 1.29868e-05
R1218 1016 1017 1.664 0.8 13.312 37
I1017 1017 0 1.23684e-05
R1219 1017 1018 1.616 0.8 12.928 37
I1018 1018 0 1.26158e-05
R1220 1018 1019 1.728 0.8 13.824 37
I1019 1019 0 1.23684e-05
R1221 1019 1020 1.616 0.8 12.928 37
I1020 1020 0 1.29868e-05
R1222 1020 1021 1.632 0.8 13.056 37
I1021 1021 0 1.23684e-05
R1223 1021 1022 1.712 0.8 13.696 37
I1022 1022 0 1.24921e-05
R1224 1022 1023 1.696 0.8 13.568 37
I1023 1023 0 1.28631e-05
R1225 1023 1024 1.744 0.8 13.952 37
I1024 1024 0 1.29868e-05
R1226 1024 1025 1.648 0.8 13.184 37
I1025 1025 0 1.29868e-05
R1227 1025 1026 1.616 0.8 12.928 37
I1026 1026 0 1.24921e-05
R1228 1026 1027 1.6 0.8 12.8 37
I1027 1027 0 1.23684e-05
R1229 1027 1028 1.712 0.8 13.696 37
I1028 1028 0 1.23684e-05
R1230 1028 1029 1.728 0.8 13.824 37
I1029 1029 0 1.24921e-05
R1231 1029 1030 1.696 0.8 13.568 37
I1030 1030 0 1.28631e-05
R1232 1030 1031 1.616 0.8 12.928 37
I1031 1031 0 1.28631e-05
R1233 1031 1032 1.744 0.8 13.952 37
I1032 1032 0 1.33579e-05
R1234 1032 1033 1.696 0.8 13.568 37
I1033 1033 0 1.26158e-05
R1235 1033 1034 1.632 0.8 13.056 37
I1034 1034 0 1.29868e-05
R1236 1034 1035 1.632 0.8 13.056 37
I1035 1035 0 1.27395e-05
R1237 1035 1036 1.632 0.8 13.056 37
I1036 1036 0 1.32342e-05
R1238 1036 1037 1.648 0.8 13.184 37
I1037 1037 0 1.34816e-05
R1239 1037 1038 1.6 0.8 12.8 37
I1038 1038 0 1.24921e-05
R1240 1038 1039 1.68 0.8 13.44 37
I1039 1039 0 1.23684e-05
R1241 1039 1040 1.696 0.8 13.568 37
I1040 1040 0 1.34816e-05
R1242 1040 1041 1.712 0.8 13.696 37
I1041 1041 0 1.34816e-05
R1243 1041 1042 1.632 0.8 13.056 37
I1042 1042 0 1.33579e-05
R1244 1042 1043 1.744 0.8 13.952 37
I1043 1043 0 1.34816e-05
R1245 1043 1044 1.728 0.8 13.824 37
I1044 1044 0 1.34816e-05
R1246 1044 1045 1.648 0.8 13.184 37
I1045 1045 0 1.31105e-05
R1247 1045 1046 1.648 0.8 13.184 37
I1046 1046 0 1.31105e-05
R1248 1046 1047 1.6 0.8 12.8 37
I1047 1047 0 1.28631e-05
R1249 1047 1048 1.664 0.8 13.312 37
I1048 1048 0 1.34816e-05
R1250 1048 1049 1.696 0.8 13.568 37
I1049 1049 0 1.31105e-05
R1251 1049 1050 1.664 0.8 13.312 37
I1050 1050 0 1.24921e-05
R1252 1050 1051 1.744 0.8 13.952 37
I1051 1051 0 1.33579e-05
R1253 1051 1052 1.6 0.8 12.8 37
I1052 1052 0 1.28631e-05
R1254 1052 1053 1.744 0.8 13.952 37
I1053 1053 0 1.23684e-05
R1255 1053 1054 1.68 0.8 13.44 37
I1054 1054 0 1.29868e-05
R1256 1054 1055 1.6 0.8 12.8 37
I1055 1055 0 1.24921e-05
R1257 1055 1056 1.696 0.8 13.568 37
I1056 1056 0 1.23684e-05
R1258 1056 1057 1.632 0.8 13.056 37
I1057 1057 0 1.33579e-05
R1259 1057 1058 1.728 0.8 13.824 37
I1058 1058 0 1.28631e-05
R1260 1058 1059 1.744 0.8 13.952 37
I1059 1059 0 1.33579e-05
R1261 1059 1060 1.648 0.8 13.184 37
I1060 1060 0 1.28631e-05
R1262 1060 1061 1.664 0.8 13.312 37
I1061 1061 0 1.34816e-05
R1263 1061 1062 1.616 0.8 12.928 37
I1062 1062 0 1.32342e-05
R1264 1062 1063 1.68 0.8 13.44 37
I1063 1063 0 1.32342e-05
R1265 1063 1064 1.696 0.8 13.568 37
I1064 1064 0 1.26158e-05
R1266 1064 1065 1.664 0.8 13.312 37
I1065 1065 0 1.26158e-05
R1267 1065 1066 1.68 0.8 13.44 37
I1066 1066 0 1.29868e-05
R1268 1066 1067 1.6 0.8 12.8 37
I1067 1067 0 1.29868e-05
R1269 1067 1068 1.632 0.8 13.056 37
I1068 1068 0 1.34816e-05
R1270 1068 1069 1.712 0.8 13.696 37
I1069 1069 0 1.32342e-05
R1271 1069 1070 1.696 0.8 13.568 37
I1070 1070 0 1.33579e-05
R1272 1070 1071 1.616 0.8 12.928 37
I1071 1071 0 1.26158e-05
R1273 1071 1072 1.6 0.8 12.8 37
I1072 1072 0 1.27395e-05
R1274 1072 1073 1.632 0.8 13.056 37
I1073 1073 0 1.33579e-05
R1275 1073 1074 1.712 0.8 13.696 37
I1074 1074 0 1.28631e-05
R1276 1074 1075 1.696 0.8 13.568 37
I1075 1075 0 1.27395e-05
R1277 1075 1076 1.728 0.8 13.824 37
I1076 1076 0 1.23684e-05
R1278 1076 1077 1.664 0.8 13.312 37
I1077 1077 0 1.34816e-05
R1279 1077 1078 1.712 0.8 13.696 37
I1078 1078 0 1.34816e-05
R1280 1078 1079 1.712 0.8 13.696 37
I1079 1079 0 1.29868e-05
R1281 1079 1080 1.616 0.8 12.928 37
I1080 1080 0 1.27395e-05
R1282 1080 1081 1.712 0.8 13.696 37
I1081 1081 0 1.33579e-05
R1283 1081 1082 1.6 0.8 12.8 37
I1082 1082 0 1.34816e-05
R1284 1082 1083 1.68 0.8 13.44 37
I1083 1083 0 1.26158e-05
R1285 1083 1084 1.616 0.8 12.928 37
I1084 1084 0 1.27395e-05
R1286 1084 1085 1.632 0.8 13.056 37
I1085 1085 0 1.32342e-05
R1287 1085 1086 1.648 0.8 13.184 37
I1086 1086 0 1.27395e-05
R1288 1086 1087 1.632 0.8 13.056 37
I1087 1087 0 1.27395e-05
R1289 1087 1088 1.728 0.8 13.824 37
I1088 1088 0 1.31105e-05
R1290 1088 1089 1.616 0.8 12.928 37
I1089 1089 0 1.31105e-05
R1291 1089 1090 1.6 0.8 12.8 37
I1090 1090 0 1.34816e-05
R1292 1090 1091 1.616 0.8 12.928 37
I1091 1091 0 1.34816e-05
R1293 1091 1092 1.616 0.8 12.928 37
I1092 1092 0 1.29868e-05
R1294 1092 1093 1.6 0.8 12.8 37
I1093 1093 0 1.34816e-05
R1295 1093 1094 1.664 0.8 13.312 37
I1094 1094 0 1.34816e-05
R1296 1094 1095 1.696 0.8 13.568 37
I1095 1095 0 1.33579e-05
R1297 1095 1096 1.632 0.8 13.056 37
I1096 1096 0 1.28631e-05
R1298 1096 1097 1.696 0.8 13.568 37
I1097 1097 0 1.29868e-05
R1299 1097 1098 1.648 0.8 13.184 37
I1098 1098 0 1.28631e-05
R1300 1098 1099 1.712 0.8 13.696 37
I1099 1099 0 1.28631e-05
R1301 1099 1100 1.712 0.8 13.696 37
I1100 1100 0 1.24921e-05
R1302 1100 1101 1.664 0.8 13.312 37
I1101 1101 0 1.23684e-05
R1303 1101 1102 1.664 0.8 13.312 37
I1102 1102 0 1.33579e-05
R1304 1102 1103 1.648 0.8 13.184 37
I1103 1103 0 1.27395e-05
R1305 1103 1104 1.664 0.8 13.312 37
I1104 1104 0 1.31105e-05
R1306 1104 1105 1.616 0.8 12.928 37
I1105 1105 0 1.29868e-05
R1307 1105 1106 1.68 0.8 13.44 37
I1106 1106 0 1.28631e-05
R1308 1106 1107 1.696 0.8 13.568 37
I1107 1107 0 1.31105e-05
R1309 1107 1108 1.744 0.8 13.952 37
I1108 1108 0 1.31105e-05
R1310 1108 1109 1.712 0.8 13.696 37
I1109 1109 0 1.29868e-05
R1311 1109 1110 1.696 0.8 13.568 37
I1110 1110 0 1.28631e-05
R1312 1110 1111 1.648 0.8 13.184 37
I1111 1111 0 1.23684e-05
R1313 1111 1112 1.6 0.8 12.8 37
I1112 1112 0 1.26158e-05
R1314 1112 1113 1.68 0.8 13.44 37
I1113 1113 0 1.27395e-05
R1315 1113 1114 1.728 0.8 13.824 37
I1114 1114 0 1.29868e-05
R1316 1114 1115 1.6 0.8 12.8 37
I1115 1115 0 1.29868e-05
R1317 1115 1116 1.696 0.8 13.568 37
I1116 1116 0 1.31105e-05
R1318 1116 1117 1.712 0.8 13.696 37
I1117 1117 0 1.27395e-05
R1319 1117 1118 1.664 0.8 13.312 37
I1118 1118 0 1.23684e-05
R1320 1118 1119 1.728 0.8 13.824 37
I1119 1119 0 1.23684e-05
R1321 1119 1120 1.728 0.8 13.824 37
I1120 1120 0 1.24921e-05
R1322 1120 1121 1.68 0.8 13.44 37
I1121 1121 0 1.27395e-05
R1323 1121 1122 1.68 0.8 13.44 37
I1122 1122 0 1.24921e-05
R1324 1122 1123 1.616 0.8 12.928 37
I1123 1123 0 1.28631e-05
R1325 1123 1124 1.6 0.8 12.8 37
I1124 1124 0 1.24921e-05
R1326 1124 1125 1.616 0.8 12.928 37
I1125 1125 0 1.33579e-05
R1327 1125 1126 1.68 0.8 13.44 37
I1126 1126 0 1.32342e-05
R1328 1126 1127 1.728 0.8 13.824 37
I1127 1127 0 1.29868e-05
R1329 1127 1128 1.616 0.8 12.928 37
I1128 1128 0 1.31105e-05
R1330 1128 1129 1.6 0.8 12.8 37
I1129 1129 0 1.34816e-05
R1331 1129 1130 1.616 0.8 12.928 37
I1130 1130 0 1.26158e-05
R1332 1130 1131 1.664 0.8 13.312 37
I1131 1131 0 1.34816e-05
R1333 1131 1132 1.6 0.8 12.8 37
I1132 1132 0 1.24921e-05
R1334 1132 1133 1.664 0.8 13.312 37
I1133 1133 0 1.28631e-05
R1335 1133 1134 1.648 0.8 13.184 37
I1134 1134 0 1.26158e-05
R1336 1134 1135 1.68 0.8 13.44 37
I1135 1135 0 1.24921e-05
R1337 1135 1136 1.648 0.8 13.184 37
I1136 1136 0 1.26158e-05
R1338 1136 1137 1.696 0.8 13.568 37
I1137 1137 0 1.23684e-05
R1339 1137 1138 1.696 0.8 13.568 37
I1138 1138 0 1.34816e-05
R1340 1138 1139 1.696 0.8 13.568 37
I1139 1139 0 1.33579e-05
R1341 1139 1140 1.6 0.8 12.8 37
I1140 1140 0 1.33579e-05
R1342 1140 1141 1.696 0.8 13.568 37
I1141 1141 0 1.32342e-05
R1343 1141 1142 1.68 0.8 13.44 37
I1142 1142 0 1.28631e-05
R1344 1142 1143 1.664 0.8 13.312 37
I1143 1143 0 1.31105e-05
R1345 1143 1144 1.6 0.8 12.8 37
I1144 1144 0 1.29868e-05
R1346 1144 1145 1.68 0.8 13.44 37
I1145 1145 0 1.27395e-05
R1347 1145 1146 1.744 0.8 13.952 37
I1146 1146 0 1.24921e-05
R1348 1146 1147 1.68 0.8 13.44 37
I1147 1147 0 1.23684e-05
R1349 1147 1148 1.664 0.8 13.312 37
I1148 1148 0 1.34816e-05
R1350 1148 1149 1.696 0.8 13.568 37
I1149 1149 0 1.32342e-05
R1351 1149 1150 1.664 0.8 13.312 37
I1150 1150 0 1.27395e-05
R1352 1150 1151 1.6 0.8 12.8 37
I1151 1151 0 1.34816e-05
R1353 1151 1152 1.696 0.8 13.568 37
I1152 1152 0 1.31105e-05
R1354 1152 1153 1.6 0.8 12.8 37
I1153 1153 0 1.28631e-05
R1355 1153 1154 1.68 0.8 13.44 37
I1154 1154 0 1.33579e-05
R1356 1154 1155 1.632 0.8 13.056 37
I1155 1155 0 1.33579e-05
R1357 1155 1156 1.696 0.8 13.568 37
I1156 1156 0 1.33579e-05
R1358 1156 1157 1.68 0.8 13.44 37
I1157 1157 0 1.27395e-05
R1359 1157 1158 1.664 0.8 13.312 37
I1158 1158 0 1.23684e-05
R1360 1158 1159 1.616 0.8 12.928 37
I1159 1159 0 1.32342e-05
R1361 1159 1160 1.712 0.8 13.696 37
I1160 1160 0 1.33579e-05
R1362 1160 1161 1.6 0.8 12.8 37
I1161 1161 0 1.33579e-05
R1363 1161 1162 1.744 0.8 13.952 37
I1162 1162 0 1.32342e-05
R1364 1162 1163 1.728 0.8 13.824 37
I1163 1163 0 1.27395e-05
R1365 1163 1164 1.744 0.8 13.952 37
I1164 1164 0 1.32342e-05
R1366 1164 1165 1.632 0.8 13.056 37
I1165 1165 0 1.29868e-05
R1367 1165 1166 1.6 0.8 12.8 37
I1166 1166 0 1.26158e-05
R1368 1166 1167 1.664 0.8 13.312 37
I1167 1167 0 1.33579e-05
R1369 1167 1168 1.6 0.8 12.8 37
I1168 1168 0 1.31105e-05
R1370 1168 1169 1.632 0.8 13.056 37
I1169 1169 0 1.31105e-05
R1371 1169 1170 1.68 0.8 13.44 37
I1170 1170 0 1.31105e-05
R1372 1170 1171 1.696 0.8 13.568 37
I1171 1171 0 1.27395e-05
R1373 1171 1172 1.664 0.8 13.312 37
I1172 1172 0 1.24921e-05
R1374 1172 1173 1.712 0.8 13.696 37
I1173 1173 0 1.24921e-05
R1375 1173 1174 1.648 0.8 13.184 37
I1174 1174 0 1.23684e-05
R1376 1174 1175 1.728 0.8 13.824 37
I1175 1175 0 1.26158e-05
R1377 1175 1176 1.744 0.8 13.952 37
I1176 1176 0 1.23684e-05
R1378 1176 1177 1.616 0.8 12.928 37
I1177 1177 0 1.23684e-05
R1379 1177 1178 1.728 0.8 13.824 37
I1178 1178 0 1.24921e-05
R1380 1178 1179 1.696 0.8 13.568 37
I1179 1179 0 1.32342e-05
R1381 1179 1180 1.728 0.8 13.824 37
I1180 1180 0 1.33579e-05
R1382 1180 1181 1.632 0.8 13.056 37
I1181 1181 0 1.24921e-05
R1383 1181 1182 1.648 0.8 13.184 37
I1182 1182 0 1.33579e-05
R1384 1182 1183 1.744 0.8 13.952 37
I1183 1183 0 1.27395e-05
R1385 1183 1184 1.68 0.8 13.44 37
I1184 1184 0 1.28631e-05
R1386 1184 1185 1.616 0.8 12.928 37
I1185 1185 0 1.26158e-05
R1387 1185 1186 1.632 0.8 13.056 37
I1186 1186 0 1.32342e-05
R1388 1186 1187 1.712 0.8 13.696 37
I1187 1187 0 1.34816e-05
R1389 1187 1188 1.616 0.8 12.928 37
I1188 1188 0 1.28631e-05
R1390 1188 1189 1.6 0.8 12.8 37
I1189 1189 0 1.28631e-05
R1391 1189 1190 1.712 0.8 13.696 37
I1190 1190 0 1.33579e-05
R1392 1190 1191 1.712 0.8 13.696 37
I1191 1191 0 1.31105e-05
R1393 1191 1192 1.728 0.8 13.824 37
I1192 1192 0 1.23684e-05
R1394 1192 1193 1.728 0.8 13.824 37
I1193 1193 0 1.31105e-05
R1395 1193 1194 1.616 0.8 12.928 37
I1194 1194 0 1.28631e-05
R1396 1194 1195 1.68 0.8 13.44 37
I1195 1195 0 1.26158e-05
R1397 1195 1196 1.68 0.8 13.44 37
I1196 1196 0 1.34816e-05
R1398 1196 1197 1.648 0.8 13.184 37
I1197 1197 0 1.33579e-05
R1399 1197 1198 1.728 0.8 13.824 37
I1198 1198 0 1.28631e-05
R1400 1198 1199 1.648 0.8 13.184 37
I1199 1199 0 1.29868e-05
R1401 1199 1200 1.6 0.8 12.8 37
I1200 1200 0 1.29868e-05
R1402 1200 1201 1.744 0.8 13.952 37
I1201 1201 0 1.27395e-05
R1403 1201 1202 1.664 0.8 13.312 37
I1202 1202 0 1.31105e-05
R1404 1202 1203 1.632 0.8 13.056 37
I1203 1203 0 1.29868e-05
R1405 1203 1204 1.648 0.8 13.184 37
I1204 1204 0 1.26158e-05
R1406 1204 1205 1.6 0.8 12.8 37
I1205 1205 0 1.23684e-05
R1407 1205 1206 1.6 0.8 12.8 37
I1206 1206 0 1.34816e-05
R1408 1206 1207 1.728 0.8 13.824 37
I1207 1207 0 1.23684e-05
R1409 1207 1208 1.744 0.8 13.952 37
I1208 1208 0 1.31105e-05
R1410 1208 1209 1.712 0.8 13.696 37
I1209 1209 0 1.26158e-05
R1411 1209 1210 1.616 0.8 12.928 37
I1210 1210 0 1.28631e-05
R1412 1210 1211 1.664 0.8 13.312 37
I1211 1211 0 1.33579e-05
R1413 1211 1212 1.664 0.8 13.312 37
I1212 1212 0 1.34816e-05
R1414 1212 1213 1.728 0.8 13.824 37
I1213 1213 0 1.28631e-05
R1415 1213 1214 1.664 0.8 13.312 37
I1214 1214 0 1.24921e-05
R1416 1214 1215 1.744 0.8 13.952 37
I1215 1215 0 1.31105e-05
R1417 1215 1216 1.728 0.8 13.824 37
I1216 1216 0 1.23684e-05
R1418 1216 1217 1.744 0.8 13.952 37
I1217 1217 0 1.27395e-05
R1419 1217 1218 1.696 0.8 13.568 37
I1218 1218 0 1.27395e-05
R1420 1218 1219 1.728 0.8 13.824 37
I1219 1219 0 1.34816e-05
R1421 1219 1220 1.68 0.8 13.44 37
I1220 1220 0 1.23684e-05
R1422 1220 1221 1.616 0.8 12.928 37
I1221 1221 0 1.32342e-05
R1423 1221 1222 1.616 0.8 12.928 37
I1222 1222 0 1.34816e-05
R1424 1222 1223 1.728 0.8 13.824 37
I1223 1223 0 1.26158e-05
R1425 1223 1224 1.696 0.8 13.568 37
I1224 1224 0 1.32342e-05
R1426 1224 1225 1.68 0.8 13.44 37
I1225 1225 0 1.34816e-05
R1427 1225 1226 1.648 0.8 13.184 37
I1226 1226 0 1.34816e-05
R1428 1226 1227 1.744 0.8 13.952 37
I1227 1227 0 1.32342e-05
R1429 1227 1228 1.744 0.8 13.952 37
I1228 1228 0 1.32342e-05
R1430 1228 1229 1.648 0.8 13.184 37
I1229 1229 0 1.29868e-05
R1431 1229 1230 1.6 0.8 12.8 37
I1230 1230 0 1.28631e-05
R1432 1230 1231 1.616 0.8 12.928 37
I1231 1231 0 1.34816e-05
R1433 1231 1232 1.664 0.8 13.312 37
I1232 1232 0 1.24921e-05
R1434 1232 1233 1.664 0.8 13.312 37
I1233 1233 0 1.27395e-05
R1435 1233 1234 1.696 0.8 13.568 37
I1234 1234 0 1.28631e-05
R1436 1234 1235 1.632 0.8 13.056 37
I1235 1235 0 1.26158e-05
R1437 1235 1236 1.712 0.8 13.696 37
I1236 1236 0 1.31105e-05
R1438 1236 1237 1.616 0.8 12.928 37
I1237 1237 0 1.33579e-05
R1439 1237 1238 1.68 0.8 13.44 37
I1238 1238 0 1.24921e-05
R1440 1238 1239 1.616 0.8 12.928 37
I1239 1239 0 1.27395e-05
R1441 1239 1240 1.6 0.8 12.8 37
I1240 1240 0 1.31105e-05
R1442 1240 1241 1.664 0.8 13.312 37
I1241 1241 0 1.28631e-05
R1443 1241 1242 1.712 0.8 13.696 37
I1242 1242 0 1.29868e-05
R1444 1242 1243 1.648 0.8 13.184 37
I1243 1243 0 1.33579e-05
R1445 1243 1244 1.632 0.8 13.056 37
I1244 1244 0 1.32342e-05
R1446 1244 1245 1.648 0.8 13.184 37
I1245 1245 0 1.29868e-05
R1447 1245 1246 1.648 0.8 13.184 37
I1246 1246 0 1.32342e-05
R1448 1246 1247 1.664 0.8 13.312 37
I1247 1247 0 1.33579e-05
R1449 1247 1248 1.6 0.8 12.8 37
I1248 1248 0 1.23684e-05
R1450 1248 1249 1.616 0.8 12.928 37
I1249 1249 0 1.31105e-05
R1451 1249 1250 1.664 0.8 13.312 37
I1250 1250 0 1.29868e-05
R1452 1250 1251 1.728 0.8 13.824 37
I1251 1251 0 1.27395e-05
R1453 1251 1252 1.616 0.8 12.928 37
I1252 1252 0 1.26158e-05
R1454 1252 1253 1.632 0.8 13.056 37
I1253 1253 0 1.34816e-05
R1455 1253 1254 1.68 0.8 13.44 37
I1254 1254 0 1.29868e-05
R1456 1254 1255 1.664 0.8 13.312 37
I1255 1255 0 1.31105e-05
R1457 1255 1256 1.648 0.8 13.184 37
I1256 1256 0 1.24921e-05
R1458 1256 1257 1.632 0.8 13.056 37
I1257 1257 0 1.23684e-05
R1459 1257 1258 1.696 0.8 13.568 37
I1258 1258 0 1.29868e-05
R1460 1258 1259 1.616 0.8 12.928 37
I1259 1259 0 1.34816e-05
R1461 1259 1260 1.664 0.8 13.312 37
I1260 1260 0 1.28631e-05
R1462 1260 1261 1.696 0.8 13.568 37
I1261 1261 0 1.33579e-05
R1463 1261 1262 1.616 0.8 12.928 37
I1262 1262 0 1.23684e-05
R1464 1262 1263 1.728 0.8 13.824 37
I1263 1263 0 1.24921e-05
R1465 1263 1264 1.632 0.8 13.056 37
I1264 1264 0 1.34816e-05
R1466 1264 1265 1.728 0.8 13.824 37
I1265 1265 0 1.33579e-05
R1467 1265 1266 1.696 0.8 13.568 37
I1266 1266 0 1.33579e-05
R1468 1266 1267 1.632 0.8 13.056 37
I1267 1267 0 1.23684e-05
R1469 1267 1268 1.632 0.8 13.056 37
I1268 1268 0 1.28631e-05
R1470 1268 1269 1.744 0.8 13.952 37
I1269 1269 0 1.33579e-05
R1471 1269 1270 1.616 0.8 12.928 37
I1270 1270 0 1.29868e-05
R1472 1270 1271 1.696 0.8 13.568 37
I1271 1271 0 1.28631e-05
R1473 1271 1272 1.696 0.8 13.568 37
I1272 1272 0 1.33579e-05
R1474 1272 1273 1.696 0.8 13.568 37
I1273 1273 0 1.27395e-05
R1475 1273 1274 1.68 0.8 13.44 37
I1274 1274 0 1.32342e-05
R1476 1274 1275 1.664 0.8 13.312 37
I1275 1275 0 1.26158e-05
R1477 1275 1276 1.664 0.8 13.312 37
I1276 1276 0 1.23684e-05
R1478 1276 1277 1.632 0.8 13.056 37
I1277 1277 0 1.32342e-05
R1479 1277 1278 1.632 0.8 13.056 37
I1278 1278 0 1.23684e-05
R1480 1278 1279 1.616 0.8 12.928 37
I1279 1279 0 1.31105e-05
R1481 1279 1280 1.616 0.8 12.928 37
I1280 1280 0 1.34816e-05
R1482 1280 1281 1.664 0.8 13.312 37
I1281 1281 0 1.34816e-05
R1483 1281 1282 1.744 0.8 13.952 37
I1282 1282 0 1.31105e-05
R1484 1282 1283 1.744 0.8 13.952 37
I1283 1283 0 1.28631e-05
R1485 1283 1284 1.632 0.8 13.056 37
I1284 1284 0 1.23684e-05
R1486 1284 1285 1.632 0.8 13.056 37
I1285 1285 0 1.27395e-05
R1487 1285 1286 1.696 0.8 13.568 37
I1286 1286 0 1.33579e-05
R1488 1286 1287 1.744 0.8 13.952 37
I1287 1287 0 1.26158e-05
R1489 1287 1288 1.728 0.8 13.824 37
I1288 1288 0 1.31105e-05
R1490 1288 1289 1.712 0.8 13.696 37
I1289 1289 0 1.27395e-05
R1491 1289 1290 1.68 0.8 13.44 37
I1290 1290 0 1.27395e-05
R1492 1290 1291 1.68 0.8 13.44 37
I1291 1291 0 1.34816e-05
R1493 1291 1292 1.68 0.8 13.44 37
I1292 1292 0 1.34816e-05
R1494 1292 1293 1.712 0.8 13.696 37
I1293 1293 0 1.34816e-05
R1495 1293 1294 1.744 0.8 13.952 37
I1294 1294 0 1.23684e-05
R1496 1294 1295 1.68 0.8 13.44 37
I1295 1295 0 1.26158e-05
R1497 1295 1296 1.616 0.8 12.928 37
I1296 1296 0 1.23684e-05
R1498 1296 1297 1.632 0.8 13.056 37
I1297 1297 0 1.23684e-05
R1499 1297 1298 1.696 0.8 13.568 37
I1298 1298 0 1.27395e-05
R1500 1298 1299 1.696 0.8 13.568 37
I1299 1299 0 1.34816e-05
R1501 1299 1300 1.664 0.8 13.312 37
I1300 1300 0 1.33579e-05
R1502 1300 1301 1.664 0.8 13.312 37
I1301 1301 0 1.23684e-05
R1503 1301 1302 1.728 0.8 13.824 37
I1302 1302 0 1.28631e-05
R1504 1302 1303 1.664 0.8 13.312 37
I1303 1303 0 1.33579e-05
R1505 1303 1304 1.632 0.8 13.056 37
I1304 1304 0 1.28631e-05
R1506 1304 1305 1.632 0.8 13.056 37
I1305 1305 0 1.32342e-05
R1507 1305 1306 1.712 0.8 13.696 37
I1306 1306 0 1.34816e-05
R1508 1306 1307 1.744 0.8 13.952 37
I1307 1307 0 1.27395e-05
R1509 1307 1308 1.744 0.8 13.952 37
I1308 1308 0 1.33579e-05
R1510 1308 1309 1.664 0.8 13.312 37
I1309 1309 0 1.23684e-05
R1511 1309 1310 1.728 0.8 13.824 37
I1310 1310 0 1.23684e-05
R1512 1310 1311 1.68 0.8 13.44 37
I1311 1311 0 1.34816e-05
R1513 1311 1312 1.6 0.8 12.8 37
I1312 1312 0 1.34816e-05
R1514 1312 1313 1.616 0.8 12.928 37
I1313 1313 0 1.33579e-05
R1515 1313 1314 1.632 0.8 13.056 37
I1314 1314 0 1.33579e-05
R1516 1314 1315 1.712 0.8 13.696 37
I1315 1315 0 1.31105e-05
R1517 1315 1316 1.728 0.8 13.824 37
I1316 1316 0 1.28631e-05
R1518 1316 1317 1.728 0.8 13.824 37
I1317 1317 0 1.34816e-05
R1519 1317 1318 1.728 0.8 13.824 37
I1318 1318 0 1.27395e-05
R1520 1318 1319 1.712 0.8 13.696 37
I1319 1319 0 1.23684e-05
R1521 1319 1320 1.712 0.8 13.696 37
I1320 1320 0 1.24921e-05
R1522 1320 1321 1.744 0.8 13.952 37
I1321 1321 0 1.31105e-05
R1523 1321 1322 1.648 0.8 13.184 37
I1322 1322 0 1.23684e-05
R1524 1322 1323 1.616 0.8 12.928 37
I1323 1323 0 1.28631e-05
R1525 1323 1324 1.728 0.8 13.824 37
I1324 1324 0 1.31105e-05
R1526 1324 1325 1.696 0.8 13.568 37
I1325 1325 0 1.31105e-05
R1527 1325 1326 1.696 0.8 13.568 37
I1326 1326 0 1.24921e-05
R1528 1326 1327 1.712 0.8 13.696 37
I1327 1327 0 1.33579e-05
R1529 1327 1328 1.632 0.8 13.056 37
I1328 1328 0 1.34816e-05
R1530 1328 1329 1.696 0.8 13.568 37
I1329 1329 0 1.29868e-05
R1531 1329 1330 1.744 0.8 13.952 37
I1330 1330 0 1.28631e-05
R1532 1330 1331 1.648 0.8 13.184 37
I1331 1331 0 1.32342e-05
R1533 1331 1332 1.728 0.8 13.824 37
I1332 1332 0 1.26158e-05
R1534 1332 1333 1.728 0.8 13.824 37
I1333 1333 0 1.33579e-05
R1535 1333 1334 1.712 0.8 13.696 37
I1334 1334 0 1.31105e-05
R1536 1334 1335 1.6 0.8 12.8 37
I1335 1335 0 1.28631e-05
R1537 1335 1336 1.744 0.8 13.952 37
I1336 1336 0 1.24921e-05
R1538 1336 1337 1.632 0.8 13.056 37
I1337 1337 0 1.26158e-05
R1539 1337 1338 1.632 0.8 13.056 37
I1338 1338 0 1.28631e-05
R1540 1338 1339 1.696 0.8 13.568 37
I1339 1339 0 1.23684e-05
R1541 1339 1340 1.632 0.8 13.056 37
I1340 1340 0 1.27395e-05
R1542 1340 1341 1.744 0.8 13.952 37
I1341 1341 0 1.33579e-05
R1543 1341 1342 1.696 0.8 13.568 37
I1342 1342 0 1.33579e-05
R1544 1342 1343 1.696 0.8 13.568 37
I1343 1343 0 1.34816e-05
R1545 1343 1344 1.712 0.8 13.696 37
I1344 1344 0 1.26158e-05
R1546 1344 1345 1.696 0.8 13.568 37
I1345 1345 0 1.33579e-05
R1547 1345 1346 1.728 0.8 13.824 37
I1346 1346 0 1.34816e-05
R1548 1346 1347 1.728 0.8 13.824 37
I1347 1347 0 1.33579e-05
R1549 1347 1348 1.616 0.8 12.928 37
I1348 1348 0 1.31105e-05
R1550 1348 1349 1.728 0.8 13.824 37
I1349 1349 0 1.23684e-05
R1551 1349 1350 1.664 0.8 13.312 37
I1350 1350 0 1.33579e-05
R1552 1350 1351 1.664 0.8 13.312 37
I1351 1351 0 1.28631e-05
R1553 1351 1352 1.632 0.8 13.056 37
I1352 1352 0 1.34816e-05
R1554 1352 1353 1.696 0.8 13.568 37
I1353 1353 0 1.28631e-05
R1555 1353 1354 1.68 0.8 13.44 37
I1354 1354 0 1.29868e-05
R1556 1354 1355 1.664 0.8 13.312 37
I1355 1355 0 1.32342e-05
R1557 1355 1356 1.6 0.8 12.8 37
I1356 1356 0 1.29868e-05
R1558 1356 1357 1.712 0.8 13.696 37
I1357 1357 0 1.31105e-05
R1559 1357 1358 1.664 0.8 13.312 37
I1358 1358 0 1.27395e-05
R1560 1358 1359 1.68 0.8 13.44 37
I1359 1359 0 1.27395e-05
R1561 1359 1360 1.712 0.8 13.696 37
I1360 1360 0 1.27395e-05
R1562 1360 1361 1.632 0.8 13.056 37
I1361 1361 0 1.33579e-05
R1563 1361 1362 1.648 0.8 13.184 37
I1362 1362 0 1.23684e-05
R1564 1362 1363 1.728 0.8 13.824 37
I1363 1363 0 1.31105e-05
R1565 1363 1364 1.696 0.8 13.568 37
I1364 1364 0 1.34816e-05
R1566 1364 1365 1.712 0.8 13.696 37
I1365 1365 0 1.24921e-05
R1567 1365 1366 1.744 0.8 13.952 37
I1366 1366 0 1.27395e-05
R1568 1366 1367 1.712 0.8 13.696 37
I1367 1367 0 1.24921e-05
R1569 1367 1368 1.632 0.8 13.056 37
I1368 1368 0 1.27395e-05
R1570 1368 1369 1.68 0.8 13.44 37
I1369 1369 0 1.32342e-05
R1571 1369 1370 1.6 0.8 12.8 37
I1370 1370 0 1.26158e-05
R1572 1370 1371 1.696 0.8 13.568 37
I1371 1371 0 1.23684e-05
R1573 1371 1372 1.712 0.8 13.696 37
I1372 1372 0 1.27395e-05
R1574 1372 1373 1.712 0.8 13.696 37
I1373 1373 0 1.24921e-05
R1575 1373 1374 1.728 0.8 13.824 37
I1374 1374 0 1.28631e-05
R1576 1374 1375 1.712 0.8 13.696 37
I1375 1375 0 1.31105e-05
R1577 1375 1376 1.728 0.8 13.824 37
I1376 1376 0 1.34816e-05
R1578 1376 1377 1.696 0.8 13.568 37
I1377 1377 0 1.27395e-05
R1579 1377 1378 1.744 0.8 13.952 37
I1378 1378 0 1.31105e-05
R1580 1378 1379 1.744 0.8 13.952 37
I1379 1379 0 1.32342e-05
R1581 1379 1380 1.68 0.8 13.44 37
I1380 1380 0 1.31105e-05
R1582 1380 1381 1.6 0.8 12.8 37
I1381 1381 0 1.29868e-05
R1583 1381 1382 1.632 0.8 13.056 37
I1382 1382 0 1.32342e-05
R1584 1382 1383 1.696 0.8 13.568 37
I1383 1383 0 1.31105e-05
R1585 1383 1384 1.648 0.8 13.184 37
I1384 1384 0 1.26158e-05
R1586 1384 1385 1.664 0.8 13.312 37
I1385 1385 0 1.27395e-05
R1587 1385 1386 1.696 0.8 13.568 37
I1386 1386 0 1.23684e-05
R1588 1386 1387 1.664 0.8 13.312 37
I1387 1387 0 1.27395e-05
R1589 1387 1388 1.696 0.8 13.568 37
I1388 1388 0 1.27395e-05
R1590 1388 1389 1.712 0.8 13.696 37
I1389 1389 0 1.28631e-05
R1591 1389 1390 1.744 0.8 13.952 37
I1390 1390 0 1.28631e-05
R1592 1390 1391 1.632 0.8 13.056 37
I1391 1391 0 1.34816e-05
R1593 1391 1392 1.648 0.8 13.184 37
I1392 1392 0 1.33579e-05
R1594 1392 1393 1.632 0.8 13.056 37
I1393 1393 0 1.28631e-05
R1595 1393 1394 1.68 0.8 13.44 37
I1394 1394 0 1.28631e-05
R1596 1394 1395 1.648 0.8 13.184 37
I1395 1395 0 1.26158e-05
R1597 1395 1396 1.632 0.8 13.056 37
I1396 1396 0 1.28631e-05
R1598 1396 1397 1.712 0.8 13.696 37
I1397 1397 0 1.28631e-05
R1599 1397 1398 1.616 0.8 12.928 37
I1398 1398 0 1.31105e-05
R1600 1398 1399 1.616 0.8 12.928 37
I1399 1399 0 1.31105e-05
R1601 1399 1400 1.728 0.8 13.824 37
I1400 1400 0 1.32342e-05
R1602 1400 1401 1.6 0.8 12.8 37
I1401 1401 0 1.28631e-05
R1603 1401 1402 1.744 0.8 13.952 37
I1402 1402 0 1.31105e-05
R1604 1402 1403 1.744 0.8 13.952 37
I1403 1403 0 1.29868e-05
R1605 1403 1404 1.616 0.8 12.928 37
I1404 1404 0 1.31105e-05
R1606 1404 1405 1.6 0.8 12.8 37
I1405 1405 0 1.26158e-05
R1607 1405 1406 1.632 0.8 13.056 37
I1406 1406 0 1.26158e-05
R1608 1406 1407 1.632 0.8 13.056 37
I1407 1407 0 1.32342e-05
R1609 1407 1408 1.648 0.8 13.184 37
I1408 1408 0 1.31105e-05
R1610 1408 1409 1.616 0.8 12.928 37
I1409 1409 0 1.23684e-05
R1611 1409 1410 1.6 0.8 12.8 37
I1410 1410 0 1.32342e-05
R1612 1410 1411 1.632 0.8 13.056 37
I1411 1411 0 1.27395e-05
R1613 1411 1412 1.616 0.8 12.928 37
I1412 1412 0 1.23684e-05
R1614 1412 1413 1.712 0.8 13.696 37
I1413 1413 0 1.28631e-05
R1615 1413 1414 1.728 0.8 13.824 37
I1414 1414 0 1.23684e-05
R1616 1414 1415 1.616 0.8 12.928 37
I1415 1415 0 1.33579e-05
R1617 1415 1416 1.712 0.8 13.696 37
I1416 1416 0 1.27395e-05
R1618 1416 1417 1.664 0.8 13.312 37
I1417 1417 0 1.32342e-05
R1619 1417 1418 1.616 0.8 12.928 37
I1418 1418 0 1.27395e-05
R1620 1418 1419 1.664 0.8 13.312 37
I1419 1419 0 1.28631e-05
R1621 1419 1420 1.632 0.8 13.056 37
I1420 1420 0 1.28631e-05
R1622 1420 1421 1.696 0.8 13.568 37
I1421 1421 0 1.28631e-05
R1623 1421 1422 1.744 0.8 13.952 37
I1422 1422 0 1.33579e-05
R1624 1422 1423 1.664 0.8 13.312 37
I1423 1423 0 1.26158e-05
R1625 1423 1424 1.68 0.8 13.44 37
I1424 1424 0 1.32342e-05
R1626 1424 1425 1.632 0.8 13.056 37
I1425 1425 0 1.32342e-05
R1627 1425 1426 1.664 0.8 13.312 37
I1426 1426 0 1.28631e-05
R1628 1426 1427 1.6 0.8 12.8 37
I1427 1427 0 1.29868e-05
R1629 1427 1428 1.696 0.8 13.568 37
I1428 1428 0 1.23684e-05
R1630 1428 1429 1.6 0.8 12.8 37
I1429 1429 0 1.28631e-05
R1631 1429 1430 1.6 0.8 12.8 37
I1430 1430 0 1.27395e-05
R1632 1430 1431 1.632 0.8 13.056 37
I1431 1431 0 1.23684e-05
R1633 1431 1432 1.728 0.8 13.824 37
I1432 1432 0 1.31105e-05
R1634 1432 1433 1.744 0.8 13.952 37
I1433 1433 0 1.34816e-05
R1635 1433 1434 1.632 0.8 13.056 37
I1434 1434 0 1.27395e-05
R1636 1434 1435 1.68 0.8 13.44 37
I1435 1435 0 1.28631e-05
R1637 1435 1436 1.728 0.8 13.824 37
I1436 1436 0 1.24921e-05
R1638 1436 1437 1.6 0.8 12.8 37
I1437 1437 0 1.32342e-05
R1639 1437 1438 1.632 0.8 13.056 37
I1438 1438 0 1.28631e-05
R1640 1438 1439 1.744 0.8 13.952 37
I1439 1439 0 1.34816e-05
R1641 1439 1440 1.632 0.8 13.056 37
I1440 1440 0 1.27395e-05
R1642 1440 1441 1.696 0.8 13.568 37
I1441 1441 0 1.31105e-05
R1643 1441 1442 1.712 0.8 13.696 37
I1442 1442 0 1.32342e-05
R1644 1442 1443 1.664 0.8 13.312 37
I1443 1443 0 1.31105e-05
R1645 1443 1444 1.744 0.8 13.952 37
I1444 1444 0 1.31105e-05
R1646 1444 1445 1.6 0.8 12.8 37
I1445 1445 0 1.34816e-05
R1647 1445 1446 1.744 0.8 13.952 37
I1446 1446 0 1.29868e-05
R1648 1446 1447 1.616 0.8 12.928 37
I1447 1447 0 1.32342e-05
R1649 1447 1448 1.648 0.8 13.184 37
I1448 1448 0 1.23684e-05
R1650 1448 1449 1.728 0.8 13.824 37
I1449 1449 0 1.29868e-05
R1651 1449 1450 1.664 0.8 13.312 37
I1450 1450 0 1.27395e-05
R1652 1450 1451 1.744 0.8 13.952 37
I1451 1451 0 1.28631e-05
R1653 1451 1452 1.696 0.8 13.568 37
I1452 1452 0 1.26158e-05
R1654 1452 1453 1.648 0.8 13.184 37
I1453 1453 0 1.33579e-05
R1655 1453 1454 1.696 0.8 13.568 37
I1454 1454 0 1.26158e-05
R1656 1454 1455 1.712 0.8 13.696 37
I1455 1455 0 1.23684e-05
R1657 1455 1456 1.712 0.8 13.696 37
I1456 1456 0 1.31105e-05
R1658 1456 1457 1.712 0.8 13.696 37
I1457 1457 0 1.28631e-05
R1659 1457 1458 1.648 0.8 13.184 37
I1458 1458 0 1.24921e-05
R1660 1458 1459 1.632 0.8 13.056 37
I1459 1459 0 1.28631e-05
R1661 1459 1460 1.712 0.8 13.696 37
I1460 1460 0 1.29868e-05
R1662 1460 1461 1.68 0.8 13.44 37
I1461 1461 0 1.33579e-05
R1663 1461 1462 1.6 0.8 12.8 37
I1462 1462 0 1.32342e-05
R1664 1462 1463 1.712 0.8 13.696 37
I1463 1463 0 1.27395e-05
R1665 1463 1464 1.712 0.8 13.696 37
I1464 1464 0 1.32342e-05
R1666 1464 1465 1.744 0.8 13.952 37
I1465 1465 0 1.27395e-05
R1667 1465 1466 1.632 0.8 13.056 37
I1466 1466 0 1.23684e-05
R1668 1466 1467 1.712 0.8 13.696 37
I1467 1467 0 1.33579e-05
R1669 1467 1468 1.632 0.8 13.056 37
I1468 1468 0 1.23684e-05
R1670 1468 1469 1.712 0.8 13.696 37
I1469 1469 0 1.24921e-05
R1671 1469 1470 1.664 0.8 13.312 37
I1470 1470 0 1.31105e-05
R1672 1470 1471 1.616 0.8 12.928 37
I1471 1471 0 1.24921e-05
R1673 1471 1472 1.632 0.8 13.056 37
I1472 1472 0 1.33579e-05
R1674 1472 1473 1.728 0.8 13.824 37
I1473 1473 0 1.32342e-05
R1675 1473 1474 1.616 0.8 12.928 37
I1474 1474 0 1.23684e-05
R1676 1474 1475 1.616 0.8 12.928 37
I1475 1475 0 1.23684e-05
R1677 1475 1476 1.712 0.8 13.696 37
I1476 1476 0 1.34816e-05
R1678 1476 1477 1.6 0.8 12.8 37
I1477 1477 0 1.32342e-05
R1679 1477 1478 1.696 0.8 13.568 37
I1478 1478 0 1.34816e-05
R1680 1478 1479 1.648 0.8 13.184 37
I1479 1479 0 1.27395e-05
R1681 1479 1480 1.696 0.8 13.568 37
I1480 1480 0 1.28631e-05
R1682 1480 1481 1.744 0.8 13.952 37
I1481 1481 0 1.33579e-05
R1683 1481 1482 1.664 0.8 13.312 37
I1482 1482 0 1.31105e-05
R1684 1482 1483 1.744 0.8 13.952 37
I1483 1483 0 1.34816e-05
R1685 1483 1484 1.712 0.8 13.696 37
I1484 1484 0 1.33579e-05
R1686 1484 1485 1.6 0.8 12.8 37
I1485 1485 0 1.24921e-05
R1687 1485 1486 1.664 0.8 13.312 37
I1486 1486 0 1.27395e-05
R1688 1486 1487 1.68 0.8 13.44 37
I1487 1487 0 1.34816e-05
R1689 1487 1488 1.664 0.8 13.312 37
I1488 1488 0 1.27395e-05
R1690 1488 1489 1.728 0.8 13.824 37
I1489 1489 0 1.29868e-05
R1691 1489 1490 1.68 0.8 13.44 37
I1490 1490 0 1.26158e-05
R1692 1490 1491 1.728 0.8 13.824 37
I1491 1491 0 1.27395e-05
R1693 1491 1492 1.616 0.8 12.928 37
I1492 1492 0 1.33579e-05
R1694 1492 1493 1.632 0.8 13.056 37
I1493 1493 0 1.32342e-05
R1695 1493 1494 1.6 0.8 12.8 37
I1494 1494 0 1.29868e-05
R1696 1494 1495 1.632 0.8 13.056 37
I1495 1495 0 1.31105e-05
R1697 1495 1496 1.616 0.8 12.928 37
I1496 1496 0 1.24921e-05
R1698 1496 1497 1.712 0.8 13.696 37
I1497 1497 0 1.33579e-05
R1699 1497 1498 1.728 0.8 13.824 37
I1498 1498 0 1.31105e-05
R1700 1498 1499 1.712 0.8 13.696 37
I1499 1499 0 1.32342e-05
R1701 1499 1500 1.664 0.8 13.312 37
I1500 1500 0 1.34816e-05
R1702 1500 1501 1.6 0.8 12.8 37
I1501 1501 0 1.23684e-05
R1703 1501 1502 1.632 0.8 13.056 37
I1502 1502 0 1.32342e-05
R1704 1502 1503 1.616 0.8 12.928 37
I1503 1503 0 1.31105e-05
R1705 1503 1504 1.632 0.8 13.056 37
I1504 1504 0 1.23684e-05
R1706 1504 1505 1.664 0.8 13.312 37
I1505 1505 0 1.33579e-05
R1707 1505 1506 1.632 0.8 13.056 37
I1506 1506 0 1.26158e-05
R1708 1506 1507 1.648 0.8 13.184 37
I1507 1507 0 1.27395e-05
R1709 1507 1508 1.632 0.8 13.056 37
I1508 1508 0 1.32342e-05
R1710 1508 1509 1.632 0.8 13.056 37
I1509 1509 0 1.28631e-05
R1711 1509 1510 1.68 0.8 13.44 37
I1510 1510 0 1.28631e-05
R1712 1510 1511 1.616 0.8 12.928 37
I1511 1511 0 1.31105e-05
R1713 1511 1512 1.728 0.8 13.824 37
I1512 1512 0 1.23684e-05
R1714 1512 1513 1.664 0.8 13.312 37
I1513 1513 0 1.33579e-05
R1715 1513 1514 1.728 0.8 13.824 37
I1514 1514 0 1.27395e-05
R1716 1514 1515 1.68 0.8 13.44 37
I1515 1515 0 1.26158e-05
R1717 1515 1516 1.664 0.8 13.312 37
I1516 1516 0 1.32342e-05
R1718 1516 1517 1.664 0.8 13.312 37
I1517 1517 0 1.32342e-05
R1719 1517 1518 1.68 0.8 13.44 37
I1518 1518 0 1.31105e-05
R1720 1518 1519 1.68 0.8 13.44 37
I1519 1519 0 1.32342e-05
R1721 1519 1520 1.696 0.8 13.568 37
I1520 1520 0 1.34816e-05
R1722 1520 1521 1.712 0.8 13.696 37
I1521 1521 0 1.23684e-05
R1723 1521 1522 1.648 0.8 13.184 37
I1522 1522 0 1.26158e-05
R1724 1522 1523 1.648 0.8 13.184 37
I1523 1523 0 1.33579e-05
R1725 1523 1524 1.6 0.8 12.8 37
I1524 1524 0 1.29868e-05
R1726 1524 1525 1.632 0.8 13.056 37
I1525 1525 0 1.29868e-05
R1727 1525 1526 1.616 0.8 12.928 37
I1526 1526 0 1.29868e-05
R1728 1526 1527 1.616 0.8 12.928 37
I1527 1527 0 1.24921e-05
R1729 1527 1528 1.68 0.8 13.44 37
I1528 1528 0 1.33579e-05
R1730 1528 1529 1.744 0.8 13.952 37
I1529 1529 0 1.27395e-05
R1731 1529 1530 1.648 0.8 13.184 37
I1530 1530 0 1.31105e-05
R1732 1530 1531 1.712 0.8 13.696 37
I1531 1531 0 1.33579e-05
R1733 1531 1532 1.696 0.8 13.568 37
I1532 1532 0 1.26158e-05
R1734 1532 1533 1.68 0.8 13.44 37
I1533 1533 0 1.24921e-05
R1735 1533 1534 1.6 0.8 12.8 37
I1534 1534 0 1.23684e-05
R1736 1534 1535 1.6 0.8 12.8 37
I1535 1535 0 1.33579e-05
R1737 1535 1536 1.632 0.8 13.056 37
I1536 1536 0 1.33579e-05
R1738 1536 1537 1.728 0.8 13.824 37
I1537 1537 0 1.32342e-05
R1739 1537 1538 1.6 0.8 12.8 37
I1538 1538 0 1.24921e-05
R1740 1538 1539 1.68 0.8 13.44 37
I1539 1539 0 1.23684e-05
R1741 1539 1540 1.728 0.8 13.824 37
I1540 1540 0 1.23684e-05
R1742 1540 1541 1.712 0.8 13.696 37
I1541 1541 0 1.24921e-05
R1743 1541 1542 1.68 0.8 13.44 37
I1542 1542 0 1.24921e-05
R1744 1542 1543 1.648 0.8 13.184 37
I1543 1543 0 1.27395e-05
R1745 1543 1544 1.744 0.8 13.952 37
I1544 1544 0 1.28631e-05
R1746 1544 1545 1.728 0.8 13.824 37
I1545 1545 0 1.26158e-05
R1747 1545 1546 1.648 0.8 13.184 37
I1546 1546 0 1.31105e-05
R1748 1546 1547 1.6 0.8 12.8 37
I1547 1547 0 1.34816e-05
R1749 1547 1548 1.6 0.8 12.8 37
I1548 1548 0 1.32342e-05
R1750 1548 1549 1.6 0.8 12.8 37
I1549 1549 0 1.26158e-05
R1751 1549 1550 1.6 0.8 12.8 37
I1550 1550 0 1.23684e-05
R1752 1550 1551 1.6 0.8 12.8 37
I1551 1551 0 1.28631e-05
R1753 1551 1552 1.6 0.8 12.8 37
I1552 1552 0 1.33579e-05
R1754 1552 1553 1.616 0.8 12.928 37
I1553 1553 0 1.24921e-05
R1755 1553 1554 1.744 0.8 13.952 37
I1554 1554 0 1.34816e-05
R1756 1554 1555 1.648 0.8 13.184 37
I1555 1555 0 1.34816e-05
R1757 1555 1556 1.744 0.8 13.952 37
I1556 1556 0 1.24921e-05
R1758 1556 1557 1.632 0.8 13.056 37
I1557 1557 0 1.31105e-05
R1759 1557 1558 1.664 0.8 13.312 37
I1558 1558 0 1.32342e-05
R1760 1558 1559 1.744 0.8 13.952 37
I1559 1559 0 1.27395e-05
R1761 1559 1560 1.632 0.8 13.056 37
I1560 1560 0 1.33579e-05
R1762 1560 1561 1.712 0.8 13.696 37
I1561 1561 0 1.29868e-05
R1763 1561 1562 1.696 0.8 13.568 37
I1562 1562 0 1.23684e-05
R1764 1562 1563 1.664 0.8 13.312 37
I1563 1563 0 1.31105e-05
R1765 1563 1564 1.744 0.8 13.952 37
I1564 1564 0 1.31105e-05
R1766 1564 1565 1.728 0.8 13.824 37
I1565 1565 0 1.34816e-05
R1767 1565 1566 1.696 0.8 13.568 37
I1566 1566 0 1.33579e-05
R1768 1566 1567 1.68 0.8 13.44 37
I1567 1567 0 1.34816e-05
R1769 1567 1568 1.728 0.8 13.824 37
I1568 1568 0 1.32342e-05
R1770 1568 1569 1.6 0.8 12.8 37
I1569 1569 0 1.32342e-05
R1771 1569 1570 1.728 0.8 13.824 37
I1570 1570 0 1.29868e-05
R1772 1570 1571 1.728 0.8 13.824 37
I1571 1571 0 1.32342e-05
R1773 1571 1572 1.728 0.8 13.824 37
I1572 1572 0 1.23684e-05
R1774 1572 1573 1.68 0.8 13.44 37
I1573 1573 0 1.26158e-05
R1775 1573 1574 1.728 0.8 13.824 37
I1574 1574 0 1.29868e-05
R1776 1574 1575 1.712 0.8 13.696 37
I1575 1575 0 1.26158e-05
R1777 1575 1576 1.68 0.8 13.44 37
I1576 1576 0 1.32342e-05
R1778 1576 1577 1.744 0.8 13.952 37
I1577 1577 0 1.24921e-05
R1779 1577 1578 1.712 0.8 13.696 37
I1578 1578 0 1.27395e-05
R1780 1578 1579 1.744 0.8 13.952 37
I1579 1579 0 1.31105e-05
R1781 1579 1580 1.744 0.8 13.952 37
I1580 1580 0 1.34816e-05
R1782 1580 1581 1.728 0.8 13.824 37
I1581 1581 0 1.32342e-05
R1783 1581 1582 1.712 0.8 13.696 37
I1582 1582 0 1.27395e-05
R1784 1582 1583 1.696 0.8 13.568 37
I1583 1583 0 1.29868e-05
R1785 1583 1584 1.632 0.8 13.056 37
I1584 1584 0 1.33579e-05
R1786 1584 1585 1.664 0.8 13.312 37
I1585 1585 0 1.23684e-05
R1787 1585 1586 1.696 0.8 13.568 37
I1586 1586 0 1.28631e-05
R1788 1586 1587 1.744 0.8 13.952 37
I1587 1587 0 1.31105e-05
R1789 1587 1588 1.696 0.8 13.568 37
I1588 1588 0 1.29868e-05
R1790 1588 1589 1.744 0.8 13.952 37
I1589 1589 0 1.31105e-05
R1791 1589 1590 1.632 0.8 13.056 37
I1590 1590 0 1.33579e-05
R1792 1590 1591 1.728 0.8 13.824 37
I1591 1591 0 1.32342e-05
R1793 1591 1592 1.68 0.8 13.44 37
I1592 1592 0 1.32342e-05
R1794 1592 1593 1.6 0.8 12.8 37
I1593 1593 0 1.26158e-05
R1795 1593 1594 1.632 0.8 13.056 37
I1594 1594 0 1.34816e-05
R1796 1594 1595 1.616 0.8 12.928 37
I1595 1595 0 1.27395e-05
R1797 1595 1596 1.728 0.8 13.824 37
I1596 1596 0 1.24921e-05
R1798 1596 1597 1.648 0.8 13.184 37
I1597 1597 0 1.32342e-05
R1799 1597 1598 1.696 0.8 13.568 37
I1598 1598 0 1.24921e-05
R1800 1598 1599 1.664 0.8 13.312 37
I1599 1599 0 1.34816e-05
R1801 1599 1600 1.632 0.8 13.056 37
I1600 1600 0 1.23684e-05
R1802 1600 1601 1.616 0.8 12.928 37
I1601 1601 0 1.33579e-05
R1803 1601 1602 1.696 0.8 13.568 37
I1602 1602 0 1.27395e-05
R1804 1602 1603 1.664 0.8 13.312 37
I1603 1603 0 1.26158e-05
R1805 1603 1604 1.6 0.8 12.8 37
I1604 1604 0 1.29868e-05
R1806 1604 1605 1.744 0.8 13.952 37
I1605 1605 0 1.28631e-05
R1807 1605 1606 1.664 0.8 13.312 37
I1606 1606 0 1.34816e-05
R1808 1606 1607 1.616 0.8 12.928 37
I1607 1607 0 1.34816e-05
R1809 1607 1608 1.744 0.8 13.952 37
I1608 1608 0 1.27395e-05
R1810 1608 1609 1.664 0.8 13.312 37
I1609 1609 0 1.24921e-05
R1811 1609 1610 1.632 0.8 13.056 37
I1610 1610 0 1.29868e-05
R1812 1610 1611 1.712 0.8 13.696 37
I1611 1611 0 1.26158e-05
R1813 1611 1612 1.696 0.8 13.568 37
I1612 1612 0 1.23684e-05
R1814 1612 1613 1.616 0.8 12.928 37
I1613 1613 0 1.28631e-05
R1815 1613 1614 1.616 0.8 12.928 37
I1614 1614 0 1.29868e-05
R1816 1614 1615 1.648 0.8 13.184 37
I1615 1615 0 1.29868e-05
R1817 1615 1616 1.712 0.8 13.696 37
I1616 1616 0 1.32342e-05
R1818 1616 1617 1.648 0.8 13.184 37
I1617 1617 0 1.27395e-05
R1819 1617 1618 1.632 0.8 13.056 37
I1618 1618 0 1.23684e-05
R1820 1618 1619 1.712 0.8 13.696 37
I1619 1619 0 1.28631e-05
R1821 1619 1620 1.712 0.8 13.696 37
I1620 1620 0 1.31105e-05
R1822 1620 1621 1.728 0.8 13.824 37
I1621 1621 0 1.24921e-05
R1823 1621 1622 1.728 0.8 13.824 37
I1622 1622 0 1.34816e-05
R1824 1622 1623 1.648 0.8 13.184 37
I1623 1623 0 1.32342e-05
R1825 1623 1624 1.632 0.8 13.056 37
I1624 1624 0 1.32342e-05
R1826 1624 1625 1.6 0.8 12.8 37
I1625 1625 0 1.31105e-05
R1827 1625 1626 1.664 0.8 13.312 37
I1626 1626 0 1.32342e-05
R1828 1626 1627 1.6 0.8 12.8 37
I1627 1627 0 1.26158e-05
R1829 1627 1628 1.744 0.8 13.952 37
I1628 1628 0 1.24921e-05
R1830 1628 1629 1.696 0.8 13.568 37
I1629 1629 0 1.27395e-05
R1831 1629 1630 1.728 0.8 13.824 37
I1630 1630 0 1.26158e-05
R1832 1630 1631 1.728 0.8 13.824 37
I1631 1631 0 1.29868e-05
R1833 1631 1632 1.744 0.8 13.952 37
I1632 1632 0 1.26158e-05
R1834 1632 1633 1.6 0.8 12.8 37
I1633 1633 0 1.27395e-05
R1835 1633 1634 1.664 0.8 13.312 37
I1634 1634 0 1.32342e-05
R1836 1634 1635 1.712 0.8 13.696 37
I1635 1635 0 1.24921e-05
R1837 1635 1636 1.696 0.8 13.568 37
I1636 1636 0 1.29868e-05
R1838 1636 1637 1.68 0.8 13.44 37
I1637 1637 0 1.28631e-05
R1839 1637 1638 1.696 0.8 13.568 37
I1638 1638 0 1.33579e-05
R1840 1638 1639 1.616 0.8 12.928 37
I1639 1639 0 1.23684e-05
R1841 1639 1640 1.68 0.8 13.44 37
I1640 1640 0 1.24921e-05
R1842 1640 1641 1.728 0.8 13.824 37
I1641 1641 0 1.34816e-05
R1843 1641 1642 1.616 0.8 12.928 37
I1642 1642 0 1.33579e-05
R1844 1642 1643 1.616 0.8 12.928 37
I1643 1643 0 1.23684e-05
R1845 1643 1644 1.744 0.8 13.952 37
I1644 1644 0 1.32342e-05
R1846 1644 1645 1.648 0.8 13.184 37
I1645 1645 0 1.34816e-05
R1847 1645 1646 1.616 0.8 12.928 37
I1646 1646 0 1.26158e-05
R1848 1646 1647 1.696 0.8 13.568 37
I1647 1647 0 1.26158e-05
R1849 1647 1648 1.696 0.8 13.568 37
I1648 1648 0 1.31105e-05
R1850 1648 1649 1.68 0.8 13.44 37
I1649 1649 0 1.23684e-05
R1851 1649 1650 1.68 0.8 13.44 37
I1650 1650 0 1.28631e-05
R1852 1650 1651 1.648 0.8 13.184 37
I1651 1651 0 1.24921e-05
R1853 1651 1652 1.744 0.8 13.952 37
I1652 1652 0 1.33579e-05
R1854 1652 1653 1.712 0.8 13.696 37
I1653 1653 0 1.32342e-05
R1855 1653 1654 1.696 0.8 13.568 37
I1654 1654 0 1.33579e-05
R1856 1654 1655 1.712 0.8 13.696 37
I1655 1655 0 1.27395e-05
R1857 1655 1656 1.632 0.8 13.056 37
I1656 1656 0 1.29868e-05
R1858 1656 1657 1.664 0.8 13.312 37
I1657 1657 0 1.27395e-05
R1859 1657 1658 1.68 0.8 13.44 37
I1658 1658 0 1.32342e-05
R1860 1658 1659 1.68 0.8 13.44 37
I1659 1659 0 1.31105e-05
R1861 1659 1660 1.68 0.8 13.44 37
I1660 1660 0 1.34816e-05
R1862 1660 1661 1.68 0.8 13.44 37
I1661 1661 0 1.33579e-05
R1863 1661 1662 1.648 0.8 13.184 37
I1662 1662 0 1.27395e-05
R1864 1662 1663 1.616 0.8 12.928 37
I1663 1663 0 1.34816e-05
R1865 1663 1664 1.744 0.8 13.952 37
I1664 1664 0 1.31105e-05
R1866 1664 1665 1.616 0.8 12.928 37
I1665 1665 0 1.32342e-05
R1867 1665 1666 1.616 0.8 12.928 37
I1666 1666 0 1.28631e-05
R1868 1666 1667 1.6 0.8 12.8 37
I1667 1667 0 1.26158e-05
R1869 1667 1668 1.68 0.8 13.44 37
I1668 1668 0 1.33579e-05
R1870 1668 1669 1.6 0.8 12.8 37
I1669 1669 0 1.24921e-05
R1871 1669 1670 1.696 0.8 13.568 37
I1670 1670 0 1.34816e-05
R1872 1670 1671 1.712 0.8 13.696 37
I1671 1671 0 1.23684e-05
R1873 1671 1672 1.68 0.8 13.44 37
I1672 1672 0 1.24921e-05
R1874 1672 1673 1.648 0.8 13.184 37
I1673 1673 0 1.26158e-05
R1875 1673 1674 1.744 0.8 13.952 37
I1674 1674 0 1.34816e-05
R1876 1674 1675 1.744 0.8 13.952 37
I1675 1675 0 1.31105e-05
R1877 1675 1676 1.6 0.8 12.8 37
I1676 1676 0 1.31105e-05
R1878 1676 1677 1.664 0.8 13.312 37
I1677 1677 0 1.27395e-05
R1879 1677 1678 1.6 0.8 12.8 37
I1678 1678 0 1.29868e-05
R1880 1678 1679 1.664 0.8 13.312 37
I1679 1679 0 1.24921e-05
R1881 1679 1680 1.664 0.8 13.312 37
I1680 1680 0 1.29868e-05
R1882 1680 1681 1.728 0.8 13.824 37
I1681 1681 0 1.29868e-05
R1883 1681 1682 1.616 0.8 12.928 37
I1682 1682 0 1.34816e-05
R1884 1682 1683 1.744 0.8 13.952 37
I1683 1683 0 1.31105e-05
R1885 1683 1684 1.712 0.8 13.696 37
I1684 1684 0 1.34816e-05
R1886 1684 1685 1.6 0.8 12.8 37
I1685 1685 0 1.29868e-05
R1887 1685 1686 1.744 0.8 13.952 37
I1686 1686 0 1.32342e-05
R1888 1686 1687 1.696 0.8 13.568 37
I1687 1687 0 1.31105e-05
R1889 1687 1688 1.728 0.8 13.824 37
I1688 1688 0 1.24921e-05
R1890 1688 1689 1.728 0.8 13.824 37
I1689 1689 0 1.34816e-05
R1891 1689 1690 1.632 0.8 13.056 37
I1690 1690 0 1.34816e-05
R1892 1690 1691 1.68 0.8 13.44 37
I1691 1691 0 1.28631e-05
R1893 1691 1692 1.696 0.8 13.568 37
I1692 1692 0 1.26158e-05
R1894 1692 1693 1.712 0.8 13.696 37
I1693 1693 0 1.31105e-05
R1895 1693 1694 1.712 0.8 13.696 37
I1694 1694 0 1.24921e-05
R1896 1694 1695 1.712 0.8 13.696 37
I1695 1695 0 1.24921e-05
R1897 1695 1696 1.728 0.8 13.824 37
I1696 1696 0 1.31105e-05
R1898 1696 1697 1.728 0.8 13.824 37
I1697 1697 0 1.23684e-05
R1899 1697 1698 1.712 0.8 13.696 37
I1698 1698 0 1.33579e-05
R1900 1698 1699 1.696 0.8 13.568 37
I1699 1699 0 1.31105e-05
R1901 1699 1700 1.744 0.8 13.952 37
I1700 1700 0 1.31105e-05
R1902 1700 1701 1.616 0.8 12.928 37
I1701 1701 0 1.33579e-05
R1903 1701 1702 1.68 0.8 13.44 37
I1702 1702 0 1.34816e-05
R1904 1702 1703 1.696 0.8 13.568 37
I1703 1703 0 1.31105e-05
R1905 1703 1704 1.616 0.8 12.928 37
I1704 1704 0 1.32342e-05
R1906 1704 1705 1.68 0.8 13.44 37
I1705 1705 0 1.29868e-05
R1907 1705 1706 1.696 0.8 13.568 37
I1706 1706 0 1.27395e-05
R1908 1706 1707 1.6 0.8 12.8 37
I1707 1707 0 1.26158e-05
R1909 1707 1708 1.68 0.8 13.44 37
I1708 1708 0 1.34816e-05
R1910 1708 1709 1.728 0.8 13.824 37
I1709 1709 0 1.26158e-05
R1911 1709 1710 1.648 0.8 13.184 37
I1710 1710 0 1.33579e-05
R1912 1710 1711 1.696 0.8 13.568 37
I1711 1711 0 1.24921e-05
R1913 1711 1712 1.696 0.8 13.568 37
I1712 1712 0 1.31105e-05
R1914 1712 1713 1.616 0.8 12.928 37
I1713 1713 0 1.27395e-05
R1915 1713 1714 1.664 0.8 13.312 37
I1714 1714 0 1.23684e-05
R1916 1714 1715 1.744 0.8 13.952 37
I1715 1715 0 1.31105e-05
R1917 1715 1716 1.728 0.8 13.824 37
I1716 1716 0 1.26158e-05
R1918 1716 1717 1.696 0.8 13.568 37
I1717 1717 0 1.28631e-05
R1919 1717 1718 1.632 0.8 13.056 37
I1718 1718 0 1.27395e-05
R1920 1718 1719 1.6 0.8 12.8 37
I1719 1719 0 1.29868e-05
R1921 1719 1720 1.6 0.8 12.8 37
I1720 1720 0 1.32342e-05
R1922 1720 1721 1.632 0.8 13.056 37
I1721 1721 0 1.33579e-05
R1923 1721 1722 1.6 0.8 12.8 37
I1722 1722 0 1.26158e-05
R1924 1722 1723 1.648 0.8 13.184 37
I1723 1723 0 1.29868e-05
R1925 1723 1724 1.664 0.8 13.312 37
I1724 1724 0 1.27395e-05
R1926 1724 1725 1.6 0.8 12.8 37
I1725 1725 0 1.32342e-05
R1927 1725 1726 1.616 0.8 12.928 37
I1726 1726 0 1.33579e-05
R1928 1726 1727 1.728 0.8 13.824 37
I1727 1727 0 1.32342e-05
R1929 1727 1728 1.664 0.8 13.312 37
I1728 1728 0 1.26158e-05
R1930 1728 1729 1.632 0.8 13.056 37
I1729 1729 0 1.24921e-05
R1931 1729 1730 1.632 0.8 13.056 37
I1730 1730 0 1.24921e-05
R1932 1730 1731 1.712 0.8 13.696 37
I1731 1731 0 1.26158e-05
R1933 1731 1732 1.696 0.8 13.568 37
I1732 1732 0 1.27395e-05
R1934 1732 1733 1.696 0.8 13.568 37
I1733 1733 0 1.23684e-05
R1935 1733 1734 1.728 0.8 13.824 37
I1734 1734 0 1.33579e-05
R1936 1734 1735 1.712 0.8 13.696 37
I1735 1735 0 1.23684e-05
R1937 1735 1736 1.728 0.8 13.824 37
I1736 1736 0 1.34816e-05
R1938 1736 1737 1.744 0.8 13.952 37
I1737 1737 0 1.33579e-05
R1939 1737 1738 1.664 0.8 13.312 37
I1738 1738 0 1.26158e-05
R1940 1738 1739 1.696 0.8 13.568 37
I1739 1739 0 1.33579e-05
R1941 1739 1740 1.712 0.8 13.696 37
I1740 1740 0 1.33579e-05
R1942 1740 1741 1.68 0.8 13.44 37
I1741 1741 0 1.34816e-05
R1943 1741 1742 1.728 0.8 13.824 37
I1742 1742 0 1.27395e-05
R1944 1742 1743 1.696 0.8 13.568 37
I1743 1743 0 1.28631e-05
R1945 1743 1744 1.712 0.8 13.696 37
I1744 1744 0 1.24921e-05
R1946 1744 1745 1.68 0.8 13.44 37
I1745 1745 0 1.34816e-05
R1947 1745 1746 1.664 0.8 13.312 37
I1746 1746 0 1.28631e-05
R1948 1746 1747 1.632 0.8 13.056 37
I1747 1747 0 1.23684e-05
R1949 1747 1748 1.6 0.8 12.8 37
I1748 1748 0 1.23684e-05
R1950 1748 1749 1.6 0.8 12.8 37
I1749 1749 0 1.33579e-05
R1951 1749 1750 1.616 0.8 12.928 37
I1750 1750 0 1.32342e-05
R1952 1750 1751 1.616 0.8 12.928 37
I1751 1751 0 1.34816e-05
R1953 1751 1752 1.744 0.8 13.952 37
I1752 1752 0 1.23684e-05
R1954 1752 1753 1.744 0.8 13.952 37
I1753 1753 0 1.27395e-05
R1955 1753 1754 1.664 0.8 13.312 37
I1754 1754 0 1.32342e-05
R1956 1754 1755 1.648 0.8 13.184 37
I1755 1755 0 1.24921e-05
R1957 1755 1756 1.712 0.8 13.696 37
I1756 1756 0 1.33579e-05
R1958 1756 1757 1.632 0.8 13.056 37
I1757 1757 0 1.29868e-05
R1959 1757 1758 1.648 0.8 13.184 37
I1758 1758 0 1.24921e-05
R1960 1758 1759 1.632 0.8 13.056 37
I1759 1759 0 1.24921e-05
R1961 1759 1760 1.632 0.8 13.056 37
I1760 1760 0 1.34816e-05
R1962 1760 1761 1.632 0.8 13.056 37
I1761 1761 0 1.31105e-05
R1963 1761 1762 1.664 0.8 13.312 37
I1762 1762 0 1.31105e-05
R1964 1762 1763 1.744 0.8 13.952 37
I1763 1763 0 1.31105e-05
R1965 1763 1764 1.744 0.8 13.952 37
I1764 1764 0 1.34816e-05
R1966 1764 1765 1.664 0.8 13.312 37
I1765 1765 0 1.23684e-05
R1967 1765 1766 1.744 0.8 13.952 37
I1766 1766 0 1.29868e-05
R1968 1766 1767 1.616 0.8 12.928 37
I1767 1767 0 1.23684e-05
R1969 1767 1768 1.712 0.8 13.696 37
I1768 1768 0 1.26158e-05
R1970 1768 1769 1.648 0.8 13.184 37
I1769 1769 0 1.27395e-05
R1971 1769 1770 1.632 0.8 13.056 37
I1770 1770 0 1.33579e-05
R1972 1770 1771 1.712 0.8 13.696 37
I1771 1771 0 1.24921e-05
R1973 1771 1772 1.696 0.8 13.568 37
I1772 1772 0 1.24921e-05
R1974 1772 1773 1.744 0.8 13.952 37
I1773 1773 0 1.24921e-05
R1975 1773 1774 1.632 0.8 13.056 37
I1774 1774 0 1.24921e-05
R1976 1774 1775 1.664 0.8 13.312 37
I1775 1775 0 1.31105e-05
R1977 1775 1776 1.6 0.8 12.8 37
I1776 1776 0 1.32342e-05
R1978 1776 1777 1.648 0.8 13.184 37
I1777 1777 0 1.31105e-05
R1979 1777 1778 1.68 0.8 13.44 37
I1778 1778 0 1.26158e-05
R1980 1778 1779 1.632 0.8 13.056 37
I1779 1779 0 1.28631e-05
R1981 1779 1780 1.648 0.8 13.184 37
I1780 1780 0 1.34816e-05
R1982 1780 1781 1.696 0.8 13.568 37
I1781 1781 0 1.28631e-05
R1983 1781 1782 1.696 0.8 13.568 37
I1782 1782 0 1.32342e-05
R1984 1782 1783 1.664 0.8 13.312 37
I1783 1783 0 1.31105e-05
R1985 1783 1784 1.632 0.8 13.056 37
I1784 1784 0 1.34816e-05
R1986 1784 1785 1.744 0.8 13.952 37
I1785 1785 0 1.31105e-05
R1987 1785 1786 1.712 0.8 13.696 37
I1786 1786 0 1.33579e-05
R1988 1786 1787 1.712 0.8 13.696 37
I1787 1787 0 1.29868e-05
R1989 1787 1788 1.632 0.8 13.056 37
I1788 1788 0 1.31105e-05
R1990 1788 1789 1.712 0.8 13.696 37
I1789 1789 0 1.28631e-05
R1991 1789 1790 1.712 0.8 13.696 37
I1790 1790 0 1.24921e-05
R1992 1790 1791 1.616 0.8 12.928 37
I1791 1791 0 1.33579e-05
R1993 1791 1792 1.6 0.8 12.8 37
I1792 1792 0 1.31105e-05
R1994 1792 1793 1.696 0.8 13.568 37
I1793 1793 0 1.31105e-05
R1995 1793 1794 1.6 0.8 12.8 37
I1794 1794 0 1.34816e-05
R1996 1794 1795 1.6 0.8 12.8 37
I1795 1795 0 1.29868e-05
R1997 1795 1796 1.728 0.8 13.824 37
I1796 1796 0 1.32342e-05
R1998 1796 1797 1.6 0.8 12.8 37
I1797 1797 0 1.28631e-05
R1999 1797 1798 1.696 0.8 13.568 37
I1798 1798 0 1.31105e-05
R2000 1798 1799 1.6 0.8 12.8 37
I1799 1799 0 1.23684e-05
R2001 1799 1800 1.696 0.8 13.568 37
I1800 1800 0 1.26158e-05
R2002 1800 1801 1.696 0.8 13.568 37
I1801 1801 0 1.29868e-05
R2003 1801 1802 1.632 0.8 13.056 37
I1802 1802 0 1.28631e-05
R2004 1802 1803 1.616 0.8 12.928 37
I1803 1803 0 1.28631e-05
R2005 1803 1804 1.632 0.8 13.056 37
I1804 1804 0 1.23684e-05
R2006 1804 1805 1.616 0.8 12.928 37
I1805 1805 0 1.23684e-05
R2007 1805 1806 1.648 0.8 13.184 37
I1806 1806 0 1.28631e-05
R2008 1806 1807 1.6 0.8 12.8 37
I1807 1807 0 1.28631e-05
R2009 1807 1808 1.6 0.8 12.8 37
I1808 1808 0 1.31105e-05
R2010 1808 1809 1.632 0.8 13.056 37
I1809 1809 0 1.26158e-05
R2011 1809 1810 1.712 0.8 13.696 37
I1810 1810 0 1.26158e-05
R2012 1810 1811 1.712 0.8 13.696 37
I1811 1811 0 1.29868e-05
R2013 1811 1812 1.616 0.8 12.928 37
I1812 1812 0 1.34816e-05
R2014 1812 1813 1.6 0.8 12.8 37
I1813 1813 0 1.23684e-05
R2015 1813 1814 1.696 0.8 13.568 37
I1814 1814 0 1.26158e-05
R2016 1814 1815 1.6 0.8 12.8 37
I1815 1815 0 1.26158e-05
R2017 1815 1816 1.664 0.8 13.312 37
I1816 1816 0 1.34816e-05
R2018 1816 1817 1.744 0.8 13.952 37
I1817 1817 0 1.34816e-05
R2019 1817 1818 1.68 0.8 13.44 37
I1818 1818 0 1.23684e-05
R2020 1818 1819 1.648 0.8 13.184 37
I1819 1819 0 1.32342e-05
R2021 1819 1820 1.6 0.8 12.8 37
I1820 1820 0 1.28631e-05
R2022 1820 1821 1.744 0.8 13.952 37
I1821 1821 0 1.28631e-05
R2023 1821 1822 1.728 0.8 13.824 37
I1822 1822 0 1.34816e-05
R2024 1822 1823 1.6 0.8 12.8 37
I1823 1823 0 1.23684e-05
R2025 1823 1824 1.728 0.8 13.824 37
I1824 1824 0 1.26158e-05
R2026 1824 1825 1.632 0.8 13.056 37
I1825 1825 0 1.29868e-05
R2027 1825 1826 1.696 0.8 13.568 37
I1826 1826 0 1.26158e-05
R2028 1826 1827 1.616 0.8 12.928 37
I1827 1827 0 1.33579e-05
R2029 1827 1828 1.616 0.8 12.928 37
I1828 1828 0 1.27395e-05
R2030 1828 1829 1.6 0.8 12.8 37
I1829 1829 0 1.32342e-05
R2031 1829 1830 1.712 0.8 13.696 37
I1830 1830 0 1.26158e-05
R2032 1830 1831 1.616 0.8 12.928 37
I1831 1831 0 1.28631e-05
R2033 1831 1832 1.616 0.8 12.928 37
I1832 1832 0 1.24921e-05
R2034 1832 1833 1.648 0.8 13.184 37
I1833 1833 0 1.31105e-05
R2035 1833 1834 1.648 0.8 13.184 37
I1834 1834 0 1.33579e-05
R2036 1834 1835 1.696 0.8 13.568 37
I1835 1835 0 1.31105e-05
R2037 1835 1836 1.648 0.8 13.184 37
I1836 1836 0 1.29868e-05
R2038 1836 1837 1.632 0.8 13.056 37
I1837 1837 0 1.27395e-05
R2039 1837 1838 1.712 0.8 13.696 37
I1838 1838 0 1.26158e-05
R2040 1838 1839 1.696 0.8 13.568 37
I1839 1839 0 1.29868e-05
R2041 1839 1840 1.696 0.8 13.568 37
I1840 1840 0 1.33579e-05
R2042 1840 1841 1.6 0.8 12.8 37
I1841 1841 0 1.26158e-05
R2043 1841 1842 1.632 0.8 13.056 37
I1842 1842 0 1.27395e-05
R2044 1842 1843 1.632 0.8 13.056 37
I1843 1843 0 1.28631e-05
R2045 1843 1844 1.728 0.8 13.824 37
I1844 1844 0 1.26158e-05
R2046 1844 1845 1.648 0.8 13.184 37
I1845 1845 0 1.33579e-05
R2047 1845 1846 1.68 0.8 13.44 37
I1846 1846 0 1.32342e-05
R2048 1846 1847 1.632 0.8 13.056 37
I1847 1847 0 1.33579e-05
R2049 1847 1848 1.728 0.8 13.824 37
I1848 1848 0 1.32342e-05
R2050 1848 1849 1.712 0.8 13.696 37
I1849 1849 0 1.27395e-05
R2051 1849 1850 1.68 0.8 13.44 37
I1850 1850 0 1.27395e-05
R2052 1850 1851 1.744 0.8 13.952 37
I1851 1851 0 1.23684e-05
R2053 1851 1852 1.728 0.8 13.824 37
I1852 1852 0 1.24921e-05
R2054 1852 1853 1.696 0.8 13.568 37
I1853 1853 0 1.29868e-05
R2055 1853 1854 1.68 0.8 13.44 37
I1854 1854 0 1.26158e-05
R2056 1854 1855 1.632 0.8 13.056 37
I1855 1855 0 1.24921e-05
R2057 1855 1856 1.632 0.8 13.056 37
I1856 1856 0 1.29868e-05
R2058 1856 1857 1.696 0.8 13.568 37
I1857 1857 0 1.29868e-05
R2059 1857 1858 1.728 0.8 13.824 37
I1858 1858 0 1.33579e-05
R2060 1858 1859 1.744 0.8 13.952 37
I1859 1859 0 1.34816e-05
R2061 1859 1860 1.648 0.8 13.184 37
I1860 1860 0 1.28631e-05
R2062 1860 1861 1.712 0.8 13.696 37
I1861 1861 0 1.23684e-05
R2063 1861 1862 1.616 0.8 12.928 37
I1862 1862 0 1.24921e-05
R2064 1862 1863 1.6 0.8 12.8 37
I1863 1863 0 1.24921e-05
R2065 1863 1864 1.728 0.8 13.824 37
I1864 1864 0 1.32342e-05
R2066 1864 1865 1.68 0.8 13.44 37
I1865 1865 0 1.27395e-05
R2067 1865 1866 1.6 0.8 12.8 37
I1866 1866 0 1.31105e-05
R2068 1866 1867 1.696 0.8 13.568 37
I1867 1867 0 1.24921e-05
R2069 1867 1868 1.728 0.8 13.824 37
I1868 1868 0 1.26158e-05
R2070 1868 1869 1.728 0.8 13.824 37
I1869 1869 0 1.29868e-05
R2071 1869 1870 1.664 0.8 13.312 37
I1870 1870 0 1.27395e-05
R2072 1870 1871 1.744 0.8 13.952 37
I1871 1871 0 1.31105e-05
R2073 1871 1872 1.728 0.8 13.824 37
I1872 1872 0 1.29868e-05
R2074 1872 1873 1.616 0.8 12.928 37
I1873 1873 0 1.33579e-05
R2075 1873 1874 1.68 0.8 13.44 37
I1874 1874 0 1.26158e-05
R2076 1874 1875 1.744 0.8 13.952 37
I1875 1875 0 1.23684e-05
R2077 1875 1876 1.712 0.8 13.696 37
I1876 1876 0 1.31105e-05
R2078 1876 1877 1.6 0.8 12.8 37
I1877 1877 0 1.23684e-05
R2079 1877 1878 1.712 0.8 13.696 37
I1878 1878 0 1.27395e-05
R2080 1878 1879 1.632 0.8 13.056 37
I1879 1879 0 1.32342e-05
R2081 1879 1880 1.6 0.8 12.8 37
I1880 1880 0 1.32342e-05
R2082 1880 1881 1.616 0.8 12.928 37
I1881 1881 0 1.27395e-05
R2083 1881 1882 1.648 0.8 13.184 37
I1882 1882 0 1.32342e-05
R2084 1882 1883 1.696 0.8 13.568 37
I1883 1883 0 1.27395e-05
R2085 1883 1884 1.744 0.8 13.952 37
I1884 1884 0 1.31105e-05
R2086 1884 1885 1.744 0.8 13.952 37
I1885 1885 0 1.29868e-05
R2087 1885 1886 1.744 0.8 13.952 37
I1886 1886 0 1.33579e-05
R2088 1886 1887 1.616 0.8 12.928 37
I1887 1887 0 1.32342e-05
R2089 1887 1888 1.68 0.8 13.44 37
I1888 1888 0 1.27395e-05
R2090 1888 1889 1.728 0.8 13.824 37
I1889 1889 0 1.23684e-05
R2091 1889 1890 1.712 0.8 13.696 37
I1890 1890 0 1.32342e-05
R2092 1890 1891 1.648 0.8 13.184 37
I1891 1891 0 1.28631e-05
R2093 1891 1892 1.696 0.8 13.568 37
I1892 1892 0 1.29868e-05
R2094 1892 1893 1.68 0.8 13.44 37
I1893 1893 0 1.29868e-05
R2095 1893 1894 1.728 0.8 13.824 37
I1894 1894 0 1.34816e-05
R2096 1894 1895 1.648 0.8 13.184 37
I1895 1895 0 1.34816e-05
R2097 1895 1896 1.696 0.8 13.568 37
I1896 1896 0 1.31105e-05
R2098 1896 1897 1.664 0.8 13.312 37
I1897 1897 0 1.24921e-05
R2099 1897 1898 1.68 0.8 13.44 37
I1898 1898 0 1.23684e-05
R2100 1898 1899 1.712 0.8 13.696 37
I1899 1899 0 1.31105e-05
R2101 1899 1900 1.696 0.8 13.568 37
I1900 1900 0 1.33579e-05
R2102 1900 1901 1.616 0.8 12.928 37
I1901 1901 0 1.31105e-05
R2103 1901 1902 1.728 0.8 13.824 37
I1902 1902 0 1.26158e-05
R2104 1902 1903 1.68 0.8 13.44 37
I1903 1903 0 1.27395e-05
R2105 1903 1904 1.712 0.8 13.696 37
I1904 1904 0 1.27395e-05
R2106 1904 1905 1.68 0.8 13.44 37
I1905 1905 0 1.29868e-05
R2107 1905 1906 1.616 0.8 12.928 37
I1906 1906 0 1.33579e-05
R2108 1906 1907 1.616 0.8 12.928 37
I1907 1907 0 1.32342e-05
R2109 1907 1908 1.696 0.8 13.568 37
I1908 1908 0 1.33579e-05
R2110 1908 1909 1.632 0.8 13.056 37
I1909 1909 0 1.28631e-05
R2111 1909 1910 1.712 0.8 13.696 37
I1910 1910 0 1.32342e-05
R2112 1910 1911 1.648 0.8 13.184 37
I1911 1911 0 1.27395e-05
R2113 1911 1912 1.648 0.8 13.184 37
I1912 1912 0 1.32342e-05
R2114 1912 1913 1.712 0.8 13.696 37
I1913 1913 0 1.33579e-05
R2115 1913 1914 1.744 0.8 13.952 37
I1914 1914 0 1.31105e-05
R2116 1914 1915 1.664 0.8 13.312 37
I1915 1915 0 1.31105e-05
R2117 1915 1916 1.664 0.8 13.312 37
I1916 1916 0 1.29868e-05
R2118 1916 1917 1.664 0.8 13.312 37
I1917 1917 0 1.26158e-05
R2119 1917 1918 1.6 0.8 12.8 37
I1918 1918 0 1.34816e-05
R2120 1918 1919 1.712 0.8 13.696 37
I1919 1919 0 1.32342e-05
R2121 1919 1920 1.68 0.8 13.44 37
I1920 1920 0 1.28631e-05
R2122 1920 1921 1.664 0.8 13.312 37
I1921 1921 0 1.31105e-05
R2123 1921 1922 1.68 0.8 13.44 37
I1922 1922 0 1.31105e-05
R2124 1922 1923 1.68 0.8 13.44 37
I1923 1923 0 1.24921e-05
R2125 1923 1924 1.664 0.8 13.312 37
I1924 1924 0 1.34816e-05
R2126 1924 1925 1.68 0.8 13.44 37
I1925 1925 0 1.26158e-05
R2127 1925 1926 1.712 0.8 13.696 37
I1926 1926 0 1.24921e-05
R2128 1926 1927 1.712 0.8 13.696 37
I1927 1927 0 1.23684e-05
R2129 1927 1928 1.6 0.8 12.8 37
I1928 1928 0 1.31105e-05
R2130 1928 1929 1.616 0.8 12.928 37
I1929 1929 0 1.23684e-05
R2131 1929 1930 1.632 0.8 13.056 37
I1930 1930 0 1.29868e-05
R2132 1930 1931 1.728 0.8 13.824 37
I1931 1931 0 1.31105e-05
R2133 1931 1932 1.648 0.8 13.184 37
I1932 1932 0 1.26158e-05
R2134 1932 1933 1.6 0.8 12.8 37
I1933 1933 0 1.27395e-05
R2135 1933 1934 1.616 0.8 12.928 37
I1934 1934 0 1.34816e-05
R2136 1934 1935 1.632 0.8 13.056 37
I1935 1935 0 1.31105e-05
R2137 1935 1936 1.696 0.8 13.568 37
I1936 1936 0 1.32342e-05
R2138 1936 1937 1.664 0.8 13.312 37
I1937 1937 0 1.24921e-05
R2139 1937 1938 1.648 0.8 13.184 37
I1938 1938 0 1.24921e-05
R2140 1938 1939 1.664 0.8 13.312 37
I1939 1939 0 1.34816e-05
R2141 1939 1940 1.616 0.8 12.928 37
I1940 1940 0 1.24921e-05
R2142 1940 1941 1.616 0.8 12.928 37
I1941 1941 0 1.23684e-05
R2143 1941 1942 1.632 0.8 13.056 37
I1942 1942 0 1.24921e-05
R2144 1942 1943 1.632 0.8 13.056 37
I1943 1943 0 1.29868e-05
R2145 1943 1944 1.712 0.8 13.696 37
I1944 1944 0 1.27395e-05
R2146 1944 1945 1.68 0.8 13.44 37
I1945 1945 0 1.23684e-05
R2147 1945 1946 1.616 0.8 12.928 37
I1946 1946 0 1.29868e-05
R2148 1946 1947 1.728 0.8 13.824 37
I1947 1947 0 1.31105e-05
R2149 1947 1948 1.712 0.8 13.696 37
I1948 1948 0 1.24921e-05
R2150 1948 1949 1.744 0.8 13.952 37
I1949 1949 0 1.23684e-05
R2151 1949 1950 1.632 0.8 13.056 37
I1950 1950 0 1.27395e-05
R2152 1950 1951 1.744 0.8 13.952 37
I1951 1951 0 1.33579e-05
R2153 1951 1952 1.6 0.8 12.8 37
I1952 1952 0 1.27395e-05
R2154 1952 1953 1.616 0.8 12.928 37
I1953 1953 0 1.29868e-05
R2155 1953 1954 1.712 0.8 13.696 37
I1954 1954 0 1.32342e-05
R2156 1954 1955 1.712 0.8 13.696 37
I1955 1955 0 1.23684e-05
R2157 1955 1956 1.744 0.8 13.952 37
I1956 1956 0 1.33579e-05
R2158 1956 1957 1.6 0.8 12.8 37
I1957 1957 0 1.27395e-05
R2159 1957 1958 1.616 0.8 12.928 37
I1958 1958 0 1.28631e-05
R2160 1958 1959 1.728 0.8 13.824 37
I1959 1959 0 1.34816e-05
R2161 1959 1960 1.6 0.8 12.8 37
I1960 1960 0 1.29868e-05
R2162 1960 1961 1.616 0.8 12.928 37
I1961 1961 0 1.27395e-05
R2163 1961 1962 1.6 0.8 12.8 37
I1962 1962 0 1.24921e-05
R2164 1962 1963 1.744 0.8 13.952 37
I1963 1963 0 1.34816e-05
R2165 1963 1964 1.632 0.8 13.056 37
I1964 1964 0 1.23684e-05
R2166 1964 1965 1.6 0.8 12.8 37
I1965 1965 0 1.32342e-05
R2167 1965 1966 1.648 0.8 13.184 37
I1966 1966 0 1.34816e-05
R2168 1966 1967 1.712 0.8 13.696 37
I1967 1967 0 1.31105e-05
R2169 1967 1968 1.664 0.8 13.312 37
I1968 1968 0 1.34816e-05
R2170 1968 1969 1.648 0.8 13.184 37
I1969 1969 0 1.27395e-05
R2171 1969 1970 1.728 0.8 13.824 37
I1970 1970 0 1.23684e-05
R2172 1970 1971 1.648 0.8 13.184 37
I1971 1971 0 1.32342e-05
R2173 1971 1972 1.616 0.8 12.928 37
I1972 1972 0 1.29868e-05
R2174 1972 1973 1.616 0.8 12.928 37
I1973 1973 0 1.26158e-05
R2175 1973 1974 1.632 0.8 13.056 37
I1974 1974 0 1.24921e-05
R2176 1974 1975 1.648 0.8 13.184 37
I1975 1975 0 1.26158e-05
R2177 1975 1976 1.712 0.8 13.696 37
I1976 1976 0 1.28631e-05
R2178 1976 1977 1.68 0.8 13.44 37
I1977 1977 0 1.34816e-05
R2179 1977 1978 1.696 0.8 13.568 37
I1978 1978 0 1.28631e-05
R2180 1978 1979 1.744 0.8 13.952 37
I1979 1979 0 1.23684e-05
R2181 1979 1980 1.664 0.8 13.312 37
I1980 1980 0 1.24921e-05
R2182 1980 1981 1.712 0.8 13.696 37
I1981 1981 0 1.34816e-05
R2183 1981 1982 1.6 0.8 12.8 37
I1982 1982 0 1.29868e-05
R2184 1982 1983 1.68 0.8 13.44 37
I1983 1983 0 1.31105e-05
R2185 1983 1984 1.696 0.8 13.568 37
I1984 1984 0 1.24921e-05
R2186 1984 1985 1.6 0.8 12.8 37
I1985 1985 0 1.28631e-05
R2187 1985 1986 1.616 0.8 12.928 37
I1986 1986 0 1.29868e-05
R2188 1986 1987 1.632 0.8 13.056 37
I1987 1987 0 1.28631e-05
R2189 1987 1988 1.648 0.8 13.184 37
I1988 1988 0 1.29868e-05
R2190 1988 1989 1.712 0.8 13.696 37
I1989 1989 0 1.29868e-05
R2191 1989 1990 1.696 0.8 13.568 37
I1990 1990 0 1.26158e-05
R2192 1990 1991 1.712 0.8 13.696 37
I1991 1991 0 1.29868e-05
R2193 1991 1992 1.712 0.8 13.696 37
I1992 1992 0 1.28631e-05
R2194 1992 1993 1.68 0.8 13.44 37
I1993 1993 0 1.27395e-05
R2195 1993 1994 1.728 0.8 13.824 37
I1994 1994 0 1.31105e-05
R2196 1994 1995 1.648 0.8 13.184 37
I1995 1995 0 1.28631e-05
R2197 1995 1996 1.712 0.8 13.696 37
I1996 1996 0 1.24921e-05
R2198 1996 1997 1.648 0.8 13.184 37
I1997 1997 0 1.34816e-05
R2199 1997 1998 1.728 0.8 13.824 37
I1998 1998 0 1.24921e-05
R2200 1998 1999 1.712 0.8 13.696 37
I1999 1999 0 1.28631e-05
R2201 1999 2000 1.632 0.8 13.056 37
I2000 2000 0 1.23684e-05
R2202 2000 10001 0.5 10 50 37
*seg: 3
* inter-segment connection
R2203 2010 3010 6.16 0.8 49.28 37
R2204 2020 3020 6.16 0.8 49.28 37
R2205 2030 3030 6.16 0.8 49.28 37
R2206 2040 3040 6.16 0.8 49.28 37
R2207 2050 3050 6.16 0.8 49.28 37
R2208 2060 3060 6.16 0.8 49.28 37
R2209 2070 3070 6.16 0.8 49.28 37
R2210 2080 3080 6.16 0.8 49.28 37
R2211 2090 3090 6.16 0.8 49.28 37
R2212 2100 3100 6.16 0.8 49.28 37
R2213 2110 3110 6.16 0.8 49.28 37
R2214 2120 3120 6.16 0.8 49.28 37
R2215 2130 3130 6.16 0.8 49.28 37
R2216 2140 3140 6.16 0.8 49.28 37
R2217 2150 3150 6.16 0.8 49.28 37
R2218 2160 3160 6.16 0.8 49.28 37
R2219 2170 3170 6.16 0.8 49.28 37
R2220 2180 3180 6.16 0.8 49.28 37
R2221 2190 3190 6.16 0.8 49.28 37
R2222 2200 3200 6.16 0.8 49.28 37
R2223 2210 3210 6.16 0.8 49.28 37
R2224 2220 3220 6.16 0.8 49.28 37
R2225 2230 3230 6.16 0.8 49.28 37
R2226 2240 3240 6.16 0.8 49.28 37
R2227 2250 3250 6.16 0.8 49.28 37
R2228 2260 3260 6.16 0.8 49.28 37
R2229 2270 3270 6.16 0.8 49.28 37
R2230 2280 3280 6.16 0.8 49.28 37
R2231 2290 3290 6.16 0.8 49.28 37
R2232 2300 3300 6.16 0.8 49.28 37
R2233 2310 3310 6.16 0.8 49.28 37
R2234 2320 3320 6.16 0.8 49.28 37
R2235 2330 3330 6.16 0.8 49.28 37
R2236 2340 3340 6.16 0.8 49.28 37
R2237 2350 3350 6.16 0.8 49.28 37
R2238 2360 3360 6.16 0.8 49.28 37
R2239 2370 3370 6.16 0.8 49.28 37
R2240 2380 3380 6.16 0.8 49.28 37
R2241 2390 3390 6.16 0.8 49.28 37
R2242 2400 3400 6.16 0.8 49.28 37
R2243 2410 3410 6.16 0.8 49.28 37
R2244 2420 3420 6.16 0.8 49.28 37
R2245 2430 3430 6.16 0.8 49.28 37
R2246 2440 3440 6.16 0.8 49.28 37
R2247 2450 3450 6.16 0.8 49.28 37
R2248 2460 3460 6.16 0.8 49.28 37
R2249 2470 3470 6.16 0.8 49.28 37
R2250 2480 3480 6.16 0.8 49.28 37
R2251 2490 3490 6.16 0.8 49.28 37
R2252 2500 3500 6.16 0.8 49.28 37
R2253 2510 3510 6.16 0.8 49.28 37
R2254 2520 3520 6.16 0.8 49.28 37
R2255 2530 3530 6.16 0.8 49.28 37
R2256 2540 3540 6.16 0.8 49.28 37
R2257 2550 3550 6.16 0.8 49.28 37
R2258 2560 3560 6.16 0.8 49.28 37
R2259 2570 3570 6.16 0.8 49.28 37
R2260 2580 3580 6.16 0.8 49.28 37
R2261 2590 3590 6.16 0.8 49.28 37
R2262 2600 3600 6.16 0.8 49.28 37
R2263 2610 3610 6.16 0.8 49.28 37
R2264 2620 3620 6.16 0.8 49.28 37
R2265 2630 3630 6.16 0.8 49.28 37
R2266 2640 3640 6.16 0.8 49.28 37
R2267 2650 3650 6.16 0.8 49.28 37
R2268 2660 3660 6.16 0.8 49.28 37
R2269 2670 3670 6.16 0.8 49.28 37
R2270 2680 3680 6.16 0.8 49.28 37
R2271 2690 3690 6.16 0.8 49.28 37
R2272 2700 3700 6.16 0.8 49.28 37
R2273 2710 3710 6.16 0.8 49.28 37
R2274 2720 3720 6.16 0.8 49.28 37
R2275 2730 3730 6.16 0.8 49.28 37
R2276 2740 3740 6.16 0.8 49.28 37
R2277 2750 3750 6.16 0.8 49.28 37
R2278 2760 3760 6.16 0.8 49.28 37
R2279 2770 3770 6.16 0.8 49.28 37
R2280 2780 3780 6.16 0.8 49.28 37
R2281 2790 3790 6.16 0.8 49.28 37
R2282 2800 3800 6.16 0.8 49.28 37
R2283 2810 3810 6.16 0.8 49.28 37
R2284 2820 3820 6.16 0.8 49.28 37
R2285 2830 3830 6.16 0.8 49.28 37
R2286 2840 3840 6.16 0.8 49.28 37
R2287 2850 3850 6.16 0.8 49.28 37
R2288 2860 3860 6.16 0.8 49.28 37
R2289 2870 3870 6.16 0.8 49.28 37
R2290 2880 3880 6.16 0.8 49.28 37
R2291 2890 3890 6.16 0.8 49.28 37
R2292 2900 3900 6.16 0.8 49.28 37
R2293 2910 3910 6.16 0.8 49.28 37
R2294 2920 3920 6.16 0.8 49.28 37
R2295 2930 3930 6.16 0.8 49.28 37
R2296 2940 3940 6.16 0.8 49.28 37
R2297 2950 3950 6.16 0.8 49.28 37
R2298 2960 3960 6.16 0.8 49.28 37
R2299 2970 3970 6.16 0.8 49.28 37
R2300 2980 3980 6.16 0.8 49.28 37
R2301 2990 3990 6.16 0.8 49.28 37
R2302 3000 4000 6.16 0.8 49.28 37
R2303 10001 2001 0.4 20 80 37
I2001 2001 0 1.34816e-05
R2304 2001 2002 1.728 0.8 13.824 37
I2002 2002 0 1.29868e-05
R2305 2002 2003 1.68 0.8 13.44 37
I2003 2003 0 1.26158e-05
R2306 2003 2004 1.632 0.8 13.056 37
I2004 2004 0 1.23684e-05
R2307 2004 2005 1.712 0.8 13.696 37
I2005 2005 0 1.24921e-05
R2308 2005 2006 1.68 0.8 13.44 37
I2006 2006 0 1.31105e-05
R2309 2006 2007 1.648 0.8 13.184 37
I2007 2007 0 1.26158e-05
R2310 2007 2008 1.616 0.8 12.928 37
I2008 2008 0 1.23684e-05
R2311 2008 2009 1.728 0.8 13.824 37
I2009 2009 0 1.33579e-05
R2312 2009 2010 1.68 0.8 13.44 37
I2010 2010 0 1.31105e-05
R2313 2010 2011 1.664 0.8 13.312 37
I2011 2011 0 1.34816e-05
R2314 2011 2012 1.632 0.8 13.056 37
I2012 2012 0 1.27395e-05
R2315 2012 2013 1.632 0.8 13.056 37
I2013 2013 0 1.32342e-05
R2316 2013 2014 1.632 0.8 13.056 37
I2014 2014 0 1.26158e-05
R2317 2014 2015 1.728 0.8 13.824 37
I2015 2015 0 1.26158e-05
R2318 2015 2016 1.696 0.8 13.568 37
I2016 2016 0 1.26158e-05
R2319 2016 2017 1.616 0.8 12.928 37
I2017 2017 0 1.31105e-05
R2320 2017 2018 1.6 0.8 12.8 37
I2018 2018 0 1.33579e-05
R2321 2018 2019 1.744 0.8 13.952 37
I2019 2019 0 1.26158e-05
R2322 2019 2020 1.728 0.8 13.824 37
I2020 2020 0 1.33579e-05
R2323 2020 2021 1.68 0.8 13.44 37
I2021 2021 0 1.29868e-05
R2324 2021 2022 1.664 0.8 13.312 37
I2022 2022 0 1.33579e-05
R2325 2022 2023 1.744 0.8 13.952 37
I2023 2023 0 1.33579e-05
R2326 2023 2024 1.744 0.8 13.952 37
I2024 2024 0 1.32342e-05
R2327 2024 2025 1.696 0.8 13.568 37
I2025 2025 0 1.28631e-05
R2328 2025 2026 1.68 0.8 13.44 37
I2026 2026 0 1.27395e-05
R2329 2026 2027 1.68 0.8 13.44 37
I2027 2027 0 1.32342e-05
R2330 2027 2028 1.696 0.8 13.568 37
I2028 2028 0 1.34816e-05
R2331 2028 2029 1.68 0.8 13.44 37
I2029 2029 0 1.24921e-05
R2332 2029 2030 1.616 0.8 12.928 37
I2030 2030 0 1.29868e-05
R2333 2030 2031 1.68 0.8 13.44 37
I2031 2031 0 1.34816e-05
R2334 2031 2032 1.6 0.8 12.8 37
I2032 2032 0 1.31105e-05
R2335 2032 2033 1.696 0.8 13.568 37
I2033 2033 0 1.26158e-05
R2336 2033 2034 1.712 0.8 13.696 37
I2034 2034 0 1.32342e-05
R2337 2034 2035 1.696 0.8 13.568 37
I2035 2035 0 1.32342e-05
R2338 2035 2036 1.68 0.8 13.44 37
I2036 2036 0 1.24921e-05
R2339 2036 2037 1.648 0.8 13.184 37
I2037 2037 0 1.26158e-05
R2340 2037 2038 1.744 0.8 13.952 37
I2038 2038 0 1.26158e-05
R2341 2038 2039 1.6 0.8 12.8 37
I2039 2039 0 1.23684e-05
R2342 2039 2040 1.6 0.8 12.8 37
I2040 2040 0 1.33579e-05
R2343 2040 2041 1.712 0.8 13.696 37
I2041 2041 0 1.29868e-05
R2344 2041 2042 1.616 0.8 12.928 37
I2042 2042 0 1.28631e-05
R2345 2042 2043 1.68 0.8 13.44 37
I2043 2043 0 1.23684e-05
R2346 2043 2044 1.664 0.8 13.312 37
I2044 2044 0 1.23684e-05
R2347 2044 2045 1.648 0.8 13.184 37
I2045 2045 0 1.32342e-05
R2348 2045 2046 1.712 0.8 13.696 37
I2046 2046 0 1.33579e-05
R2349 2046 2047 1.712 0.8 13.696 37
I2047 2047 0 1.32342e-05
R2350 2047 2048 1.664 0.8 13.312 37
I2048 2048 0 1.27395e-05
R2351 2048 2049 1.616 0.8 12.928 37
I2049 2049 0 1.27395e-05
R2352 2049 2050 1.6 0.8 12.8 37
I2050 2050 0 1.32342e-05
R2353 2050 2051 1.616 0.8 12.928 37
I2051 2051 0 1.32342e-05
R2354 2051 2052 1.728 0.8 13.824 37
I2052 2052 0 1.31105e-05
R2355 2052 2053 1.616 0.8 12.928 37
I2053 2053 0 1.23684e-05
R2356 2053 2054 1.728 0.8 13.824 37
I2054 2054 0 1.27395e-05
R2357 2054 2055 1.6 0.8 12.8 37
I2055 2055 0 1.23684e-05
R2358 2055 2056 1.632 0.8 13.056 37
I2056 2056 0 1.34816e-05
R2359 2056 2057 1.696 0.8 13.568 37
I2057 2057 0 1.29868e-05
R2360 2057 2058 1.664 0.8 13.312 37
I2058 2058 0 1.27395e-05
R2361 2058 2059 1.712 0.8 13.696 37
I2059 2059 0 1.23684e-05
R2362 2059 2060 1.68 0.8 13.44 37
I2060 2060 0 1.23684e-05
R2363 2060 2061 1.712 0.8 13.696 37
I2061 2061 0 1.26158e-05
R2364 2061 2062 1.728 0.8 13.824 37
I2062 2062 0 1.28631e-05
R2365 2062 2063 1.632 0.8 13.056 37
I2063 2063 0 1.29868e-05
R2366 2063 2064 1.712 0.8 13.696 37
I2064 2064 0 1.27395e-05
R2367 2064 2065 1.728 0.8 13.824 37
I2065 2065 0 1.34816e-05
R2368 2065 2066 1.616 0.8 12.928 37
I2066 2066 0 1.24921e-05
R2369 2066 2067 1.744 0.8 13.952 37
I2067 2067 0 1.34816e-05
R2370 2067 2068 1.712 0.8 13.696 37
I2068 2068 0 1.23684e-05
R2371 2068 2069 1.744 0.8 13.952 37
I2069 2069 0 1.31105e-05
R2372 2069 2070 1.696 0.8 13.568 37
I2070 2070 0 1.26158e-05
R2373 2070 2071 1.728 0.8 13.824 37
I2071 2071 0 1.33579e-05
R2374 2071 2072 1.616 0.8 12.928 37
I2072 2072 0 1.31105e-05
R2375 2072 2073 1.68 0.8 13.44 37
I2073 2073 0 1.32342e-05
R2376 2073 2074 1.744 0.8 13.952 37
I2074 2074 0 1.27395e-05
R2377 2074 2075 1.712 0.8 13.696 37
I2075 2075 0 1.28631e-05
R2378 2075 2076 1.68 0.8 13.44 37
I2076 2076 0 1.29868e-05
R2379 2076 2077 1.712 0.8 13.696 37
I2077 2077 0 1.28631e-05
R2380 2077 2078 1.744 0.8 13.952 37
I2078 2078 0 1.24921e-05
R2381 2078 2079 1.744 0.8 13.952 37
I2079 2079 0 1.34816e-05
R2382 2079 2080 1.664 0.8 13.312 37
I2080 2080 0 1.34816e-05
R2383 2080 2081 1.6 0.8 12.8 37
I2081 2081 0 1.29868e-05
R2384 2081 2082 1.616 0.8 12.928 37
I2082 2082 0 1.24921e-05
R2385 2082 2083 1.712 0.8 13.696 37
I2083 2083 0 1.33579e-05
R2386 2083 2084 1.632 0.8 13.056 37
I2084 2084 0 1.33579e-05
R2387 2084 2085 1.696 0.8 13.568 37
I2085 2085 0 1.33579e-05
R2388 2085 2086 1.6 0.8 12.8 37
I2086 2086 0 1.29868e-05
R2389 2086 2087 1.728 0.8 13.824 37
I2087 2087 0 1.28631e-05
R2390 2087 2088 1.616 0.8 12.928 37
I2088 2088 0 1.29868e-05
R2391 2088 2089 1.616 0.8 12.928 37
I2089 2089 0 1.24921e-05
R2392 2089 2090 1.6 0.8 12.8 37
I2090 2090 0 1.34816e-05
R2393 2090 2091 1.68 0.8 13.44 37
I2091 2091 0 1.31105e-05
R2394 2091 2092 1.696 0.8 13.568 37
I2092 2092 0 1.28631e-05
R2395 2092 2093 1.632 0.8 13.056 37
I2093 2093 0 1.29868e-05
R2396 2093 2094 1.68 0.8 13.44 37
I2094 2094 0 1.24921e-05
R2397 2094 2095 1.696 0.8 13.568 37
I2095 2095 0 1.23684e-05
R2398 2095 2096 1.6 0.8 12.8 37
I2096 2096 0 1.34816e-05
R2399 2096 2097 1.712 0.8 13.696 37
I2097 2097 0 1.27395e-05
R2400 2097 2098 1.6 0.8 12.8 37
I2098 2098 0 1.31105e-05
R2401 2098 2099 1.632 0.8 13.056 37
I2099 2099 0 1.28631e-05
R2402 2099 2100 1.68 0.8 13.44 37
I2100 2100 0 1.23684e-05
R2403 2100 2101 1.632 0.8 13.056 37
I2101 2101 0 1.32342e-05
R2404 2101 2102 1.68 0.8 13.44 37
I2102 2102 0 1.26158e-05
R2405 2102 2103 1.648 0.8 13.184 37
I2103 2103 0 1.34816e-05
R2406 2103 2104 1.6 0.8 12.8 37
I2104 2104 0 1.32342e-05
R2407 2104 2105 1.6 0.8 12.8 37
I2105 2105 0 1.23684e-05
R2408 2105 2106 1.696 0.8 13.568 37
I2106 2106 0 1.32342e-05
R2409 2106 2107 1.728 0.8 13.824 37
I2107 2107 0 1.28631e-05
R2410 2107 2108 1.664 0.8 13.312 37
I2108 2108 0 1.23684e-05
R2411 2108 2109 1.616 0.8 12.928 37
I2109 2109 0 1.34816e-05
R2412 2109 2110 1.616 0.8 12.928 37
I2110 2110 0 1.33579e-05
R2413 2110 2111 1.616 0.8 12.928 37
I2111 2111 0 1.28631e-05
R2414 2111 2112 1.744 0.8 13.952 37
I2112 2112 0 1.24921e-05
R2415 2112 2113 1.712 0.8 13.696 37
I2113 2113 0 1.34816e-05
R2416 2113 2114 1.712 0.8 13.696 37
I2114 2114 0 1.24921e-05
R2417 2114 2115 1.664 0.8 13.312 37
I2115 2115 0 1.28631e-05
R2418 2115 2116 1.632 0.8 13.056 37
I2116 2116 0 1.33579e-05
R2419 2116 2117 1.664 0.8 13.312 37
I2117 2117 0 1.34816e-05
R2420 2117 2118 1.648 0.8 13.184 37
I2118 2118 0 1.34816e-05
R2421 2118 2119 1.728 0.8 13.824 37
I2119 2119 0 1.27395e-05
R2422 2119 2120 1.696 0.8 13.568 37
I2120 2120 0 1.23684e-05
R2423 2120 2121 1.68 0.8 13.44 37
I2121 2121 0 1.28631e-05
R2424 2121 2122 1.6 0.8 12.8 37
I2122 2122 0 1.28631e-05
R2425 2122 2123 1.728 0.8 13.824 37
I2123 2123 0 1.28631e-05
R2426 2123 2124 1.664 0.8 13.312 37
I2124 2124 0 1.23684e-05
R2427 2124 2125 1.648 0.8 13.184 37
I2125 2125 0 1.33579e-05
R2428 2125 2126 1.6 0.8 12.8 37
I2126 2126 0 1.32342e-05
R2429 2126 2127 1.664 0.8 13.312 37
I2127 2127 0 1.34816e-05
R2430 2127 2128 1.728 0.8 13.824 37
I2128 2128 0 1.27395e-05
R2431 2128 2129 1.728 0.8 13.824 37
I2129 2129 0 1.32342e-05
R2432 2129 2130 1.68 0.8 13.44 37
I2130 2130 0 1.28631e-05
R2433 2130 2131 1.664 0.8 13.312 37
I2131 2131 0 1.34816e-05
R2434 2131 2132 1.648 0.8 13.184 37
I2132 2132 0 1.33579e-05
R2435 2132 2133 1.728 0.8 13.824 37
I2133 2133 0 1.33579e-05
R2436 2133 2134 1.712 0.8 13.696 37
I2134 2134 0 1.34816e-05
R2437 2134 2135 1.616 0.8 12.928 37
I2135 2135 0 1.31105e-05
R2438 2135 2136 1.744 0.8 13.952 37
I2136 2136 0 1.33579e-05
R2439 2136 2137 1.6 0.8 12.8 37
I2137 2137 0 1.34816e-05
R2440 2137 2138 1.632 0.8 13.056 37
I2138 2138 0 1.34816e-05
R2441 2138 2139 1.648 0.8 13.184 37
I2139 2139 0 1.34816e-05
R2442 2139 2140 1.744 0.8 13.952 37
I2140 2140 0 1.34816e-05
R2443 2140 2141 1.712 0.8 13.696 37
I2141 2141 0 1.34816e-05
R2444 2141 2142 1.696 0.8 13.568 37
I2142 2142 0 1.27395e-05
R2445 2142 2143 1.6 0.8 12.8 37
I2143 2143 0 1.31105e-05
R2446 2143 2144 1.696 0.8 13.568 37
I2144 2144 0 1.33579e-05
R2447 2144 2145 1.648 0.8 13.184 37
I2145 2145 0 1.27395e-05
R2448 2145 2146 1.68 0.8 13.44 37
I2146 2146 0 1.32342e-05
R2449 2146 2147 1.632 0.8 13.056 37
I2147 2147 0 1.23684e-05
R2450 2147 2148 1.712 0.8 13.696 37
I2148 2148 0 1.27395e-05
R2451 2148 2149 1.728 0.8 13.824 37
I2149 2149 0 1.32342e-05
R2452 2149 2150 1.632 0.8 13.056 37
I2150 2150 0 1.24921e-05
R2453 2150 2151 1.648 0.8 13.184 37
I2151 2151 0 1.27395e-05
R2454 2151 2152 1.744 0.8 13.952 37
I2152 2152 0 1.29868e-05
R2455 2152 2153 1.648 0.8 13.184 37
I2153 2153 0 1.26158e-05
R2456 2153 2154 1.664 0.8 13.312 37
I2154 2154 0 1.33579e-05
R2457 2154 2155 1.648 0.8 13.184 37
I2155 2155 0 1.29868e-05
R2458 2155 2156 1.744 0.8 13.952 37
I2156 2156 0 1.26158e-05
R2459 2156 2157 1.696 0.8 13.568 37
I2157 2157 0 1.32342e-05
R2460 2157 2158 1.68 0.8 13.44 37
I2158 2158 0 1.31105e-05
R2461 2158 2159 1.648 0.8 13.184 37
I2159 2159 0 1.24921e-05
R2462 2159 2160 1.712 0.8 13.696 37
I2160 2160 0 1.34816e-05
R2463 2160 2161 1.68 0.8 13.44 37
I2161 2161 0 1.26158e-05
R2464 2161 2162 1.728 0.8 13.824 37
I2162 2162 0 1.34816e-05
R2465 2162 2163 1.632 0.8 13.056 37
I2163 2163 0 1.33579e-05
R2466 2163 2164 1.632 0.8 13.056 37
I2164 2164 0 1.23684e-05
R2467 2164 2165 1.68 0.8 13.44 37
I2165 2165 0 1.28631e-05
R2468 2165 2166 1.616 0.8 12.928 37
I2166 2166 0 1.23684e-05
R2469 2166 2167 1.6 0.8 12.8 37
I2167 2167 0 1.26158e-05
R2470 2167 2168 1.68 0.8 13.44 37
I2168 2168 0 1.27395e-05
R2471 2168 2169 1.696 0.8 13.568 37
I2169 2169 0 1.26158e-05
R2472 2169 2170 1.648 0.8 13.184 37
I2170 2170 0 1.34816e-05
R2473 2170 2171 1.712 0.8 13.696 37
I2171 2171 0 1.29868e-05
R2474 2171 2172 1.616 0.8 12.928 37
I2172 2172 0 1.28631e-05
R2475 2172 2173 1.632 0.8 13.056 37
I2173 2173 0 1.33579e-05
R2476 2173 2174 1.632 0.8 13.056 37
I2174 2174 0 1.33579e-05
R2477 2174 2175 1.632 0.8 13.056 37
I2175 2175 0 1.34816e-05
R2478 2175 2176 1.744 0.8 13.952 37
I2176 2176 0 1.34816e-05
R2479 2176 2177 1.616 0.8 12.928 37
I2177 2177 0 1.34816e-05
R2480 2177 2178 1.728 0.8 13.824 37
I2178 2178 0 1.29868e-05
R2481 2178 2179 1.712 0.8 13.696 37
I2179 2179 0 1.27395e-05
R2482 2179 2180 1.68 0.8 13.44 37
I2180 2180 0 1.28631e-05
R2483 2180 2181 1.744 0.8 13.952 37
I2181 2181 0 1.33579e-05
R2484 2181 2182 1.664 0.8 13.312 37
I2182 2182 0 1.34816e-05
R2485 2182 2183 1.648 0.8 13.184 37
I2183 2183 0 1.26158e-05
R2486 2183 2184 1.664 0.8 13.312 37
I2184 2184 0 1.34816e-05
R2487 2184 2185 1.664 0.8 13.312 37
I2185 2185 0 1.33579e-05
R2488 2185 2186 1.744 0.8 13.952 37
I2186 2186 0 1.27395e-05
R2489 2186 2187 1.648 0.8 13.184 37
I2187 2187 0 1.26158e-05
R2490 2187 2188 1.744 0.8 13.952 37
I2188 2188 0 1.32342e-05
R2491 2188 2189 1.648 0.8 13.184 37
I2189 2189 0 1.26158e-05
R2492 2189 2190 1.68 0.8 13.44 37
I2190 2190 0 1.29868e-05
R2493 2190 2191 1.648 0.8 13.184 37
I2191 2191 0 1.31105e-05
R2494 2191 2192 1.664 0.8 13.312 37
I2192 2192 0 1.32342e-05
R2495 2192 2193 1.696 0.8 13.568 37
I2193 2193 0 1.28631e-05
R2496 2193 2194 1.632 0.8 13.056 37
I2194 2194 0 1.27395e-05
R2497 2194 2195 1.712 0.8 13.696 37
I2195 2195 0 1.23684e-05
R2498 2195 2196 1.6 0.8 12.8 37
I2196 2196 0 1.32342e-05
R2499 2196 2197 1.6 0.8 12.8 37
I2197 2197 0 1.31105e-05
R2500 2197 2198 1.696 0.8 13.568 37
I2198 2198 0 1.27395e-05
R2501 2198 2199 1.728 0.8 13.824 37
I2199 2199 0 1.24921e-05
R2502 2199 2200 1.648 0.8 13.184 37
I2200 2200 0 1.28631e-05
R2503 2200 2201 1.616 0.8 12.928 37
I2201 2201 0 1.28631e-05
R2504 2201 2202 1.728 0.8 13.824 37
I2202 2202 0 1.31105e-05
R2505 2202 2203 1.728 0.8 13.824 37
I2203 2203 0 1.32342e-05
R2506 2203 2204 1.68 0.8 13.44 37
I2204 2204 0 1.24921e-05
R2507 2204 2205 1.744 0.8 13.952 37
I2205 2205 0 1.27395e-05
R2508 2205 2206 1.728 0.8 13.824 37
I2206 2206 0 1.27395e-05
R2509 2206 2207 1.744 0.8 13.952 37
I2207 2207 0 1.28631e-05
R2510 2207 2208 1.632 0.8 13.056 37
I2208 2208 0 1.29868e-05
R2511 2208 2209 1.744 0.8 13.952 37
I2209 2209 0 1.28631e-05
R2512 2209 2210 1.616 0.8 12.928 37
I2210 2210 0 1.33579e-05
R2513 2210 2211 1.664 0.8 13.312 37
I2211 2211 0 1.24921e-05
R2514 2211 2212 1.712 0.8 13.696 37
I2212 2212 0 1.32342e-05
R2515 2212 2213 1.744 0.8 13.952 37
I2213 2213 0 1.28631e-05
R2516 2213 2214 1.6 0.8 12.8 37
I2214 2214 0 1.33579e-05
R2517 2214 2215 1.712 0.8 13.696 37
I2215 2215 0 1.29868e-05
R2518 2215 2216 1.664 0.8 13.312 37
I2216 2216 0 1.23684e-05
R2519 2216 2217 1.744 0.8 13.952 37
I2217 2217 0 1.26158e-05
R2520 2217 2218 1.728 0.8 13.824 37
I2218 2218 0 1.23684e-05
R2521 2218 2219 1.6 0.8 12.8 37
I2219 2219 0 1.27395e-05
R2522 2219 2220 1.616 0.8 12.928 37
I2220 2220 0 1.24921e-05
R2523 2220 2221 1.696 0.8 13.568 37
I2221 2221 0 1.26158e-05
R2524 2221 2222 1.696 0.8 13.568 37
I2222 2222 0 1.31105e-05
R2525 2222 2223 1.696 0.8 13.568 37
I2223 2223 0 1.33579e-05
R2526 2223 2224 1.648 0.8 13.184 37
I2224 2224 0 1.32342e-05
R2527 2224 2225 1.68 0.8 13.44 37
I2225 2225 0 1.28631e-05
R2528 2225 2226 1.696 0.8 13.568 37
I2226 2226 0 1.24921e-05
R2529 2226 2227 1.712 0.8 13.696 37
I2227 2227 0 1.27395e-05
R2530 2227 2228 1.728 0.8 13.824 37
I2228 2228 0 1.34816e-05
R2531 2228 2229 1.744 0.8 13.952 37
I2229 2229 0 1.34816e-05
R2532 2229 2230 1.744 0.8 13.952 37
I2230 2230 0 1.33579e-05
R2533 2230 2231 1.696 0.8 13.568 37
I2231 2231 0 1.27395e-05
R2534 2231 2232 1.728 0.8 13.824 37
I2232 2232 0 1.33579e-05
R2535 2232 2233 1.696 0.8 13.568 37
I2233 2233 0 1.31105e-05
R2536 2233 2234 1.728 0.8 13.824 37
I2234 2234 0 1.33579e-05
R2537 2234 2235 1.632 0.8 13.056 37
I2235 2235 0 1.24921e-05
R2538 2235 2236 1.616 0.8 12.928 37
I2236 2236 0 1.33579e-05
R2539 2236 2237 1.648 0.8 13.184 37
I2237 2237 0 1.33579e-05
R2540 2237 2238 1.696 0.8 13.568 37
I2238 2238 0 1.23684e-05
R2541 2238 2239 1.728 0.8 13.824 37
I2239 2239 0 1.23684e-05
R2542 2239 2240 1.712 0.8 13.696 37
I2240 2240 0 1.27395e-05
R2543 2240 2241 1.696 0.8 13.568 37
I2241 2241 0 1.29868e-05
R2544 2241 2242 1.68 0.8 13.44 37
I2242 2242 0 1.31105e-05
R2545 2242 2243 1.744 0.8 13.952 37
I2243 2243 0 1.27395e-05
R2546 2243 2244 1.68 0.8 13.44 37
I2244 2244 0 1.23684e-05
R2547 2244 2245 1.664 0.8 13.312 37
I2245 2245 0 1.28631e-05
R2548 2245 2246 1.744 0.8 13.952 37
I2246 2246 0 1.27395e-05
R2549 2246 2247 1.712 0.8 13.696 37
I2247 2247 0 1.32342e-05
R2550 2247 2248 1.616 0.8 12.928 37
I2248 2248 0 1.29868e-05
R2551 2248 2249 1.696 0.8 13.568 37
I2249 2249 0 1.34816e-05
R2552 2249 2250 1.648 0.8 13.184 37
I2250 2250 0 1.33579e-05
R2553 2250 2251 1.6 0.8 12.8 37
I2251 2251 0 1.32342e-05
R2554 2251 2252 1.728 0.8 13.824 37
I2252 2252 0 1.31105e-05
R2555 2252 2253 1.68 0.8 13.44 37
I2253 2253 0 1.29868e-05
R2556 2253 2254 1.728 0.8 13.824 37
I2254 2254 0 1.27395e-05
R2557 2254 2255 1.68 0.8 13.44 37
I2255 2255 0 1.32342e-05
R2558 2255 2256 1.744 0.8 13.952 37
I2256 2256 0 1.24921e-05
R2559 2256 2257 1.648 0.8 13.184 37
I2257 2257 0 1.28631e-05
R2560 2257 2258 1.712 0.8 13.696 37
I2258 2258 0 1.28631e-05
R2561 2258 2259 1.744 0.8 13.952 37
I2259 2259 0 1.28631e-05
R2562 2259 2260 1.664 0.8 13.312 37
I2260 2260 0 1.31105e-05
R2563 2260 2261 1.728 0.8 13.824 37
I2261 2261 0 1.29868e-05
R2564 2261 2262 1.744 0.8 13.952 37
I2262 2262 0 1.33579e-05
R2565 2262 2263 1.68 0.8 13.44 37
I2263 2263 0 1.26158e-05
R2566 2263 2264 1.648 0.8 13.184 37
I2264 2264 0 1.24921e-05
R2567 2264 2265 1.616 0.8 12.928 37
I2265 2265 0 1.34816e-05
R2568 2265 2266 1.616 0.8 12.928 37
I2266 2266 0 1.27395e-05
R2569 2266 2267 1.696 0.8 13.568 37
I2267 2267 0 1.34816e-05
R2570 2267 2268 1.616 0.8 12.928 37
I2268 2268 0 1.27395e-05
R2571 2268 2269 1.664 0.8 13.312 37
I2269 2269 0 1.34816e-05
R2572 2269 2270 1.728 0.8 13.824 37
I2270 2270 0 1.24921e-05
R2573 2270 2271 1.712 0.8 13.696 37
I2271 2271 0 1.34816e-05
R2574 2271 2272 1.648 0.8 13.184 37
I2272 2272 0 1.23684e-05
R2575 2272 2273 1.648 0.8 13.184 37
I2273 2273 0 1.26158e-05
R2576 2273 2274 1.696 0.8 13.568 37
I2274 2274 0 1.29868e-05
R2577 2274 2275 1.744 0.8 13.952 37
I2275 2275 0 1.26158e-05
R2578 2275 2276 1.648 0.8 13.184 37
I2276 2276 0 1.32342e-05
R2579 2276 2277 1.728 0.8 13.824 37
I2277 2277 0 1.28631e-05
R2580 2277 2278 1.712 0.8 13.696 37
I2278 2278 0 1.27395e-05
R2581 2278 2279 1.696 0.8 13.568 37
I2279 2279 0 1.27395e-05
R2582 2279 2280 1.696 0.8 13.568 37
I2280 2280 0 1.34816e-05
R2583 2280 2281 1.632 0.8 13.056 37
I2281 2281 0 1.32342e-05
R2584 2281 2282 1.632 0.8 13.056 37
I2282 2282 0 1.23684e-05
R2585 2282 2283 1.728 0.8 13.824 37
I2283 2283 0 1.28631e-05
R2586 2283 2284 1.68 0.8 13.44 37
I2284 2284 0 1.27395e-05
R2587 2284 2285 1.68 0.8 13.44 37
I2285 2285 0 1.29868e-05
R2588 2285 2286 1.664 0.8 13.312 37
I2286 2286 0 1.26158e-05
R2589 2286 2287 1.68 0.8 13.44 37
I2287 2287 0 1.34816e-05
R2590 2287 2288 1.664 0.8 13.312 37
I2288 2288 0 1.23684e-05
R2591 2288 2289 1.664 0.8 13.312 37
I2289 2289 0 1.23684e-05
R2592 2289 2290 1.68 0.8 13.44 37
I2290 2290 0 1.27395e-05
R2593 2290 2291 1.68 0.8 13.44 37
I2291 2291 0 1.23684e-05
R2594 2291 2292 1.632 0.8 13.056 37
I2292 2292 0 1.27395e-05
R2595 2292 2293 1.664 0.8 13.312 37
I2293 2293 0 1.23684e-05
R2596 2293 2294 1.696 0.8 13.568 37
I2294 2294 0 1.26158e-05
R2597 2294 2295 1.648 0.8 13.184 37
I2295 2295 0 1.26158e-05
R2598 2295 2296 1.616 0.8 12.928 37
I2296 2296 0 1.32342e-05
R2599 2296 2297 1.616 0.8 12.928 37
I2297 2297 0 1.28631e-05
R2600 2297 2298 1.744 0.8 13.952 37
I2298 2298 0 1.34816e-05
R2601 2298 2299 1.6 0.8 12.8 37
I2299 2299 0 1.31105e-05
R2602 2299 2300 1.664 0.8 13.312 37
I2300 2300 0 1.29868e-05
R2603 2300 2301 1.616 0.8 12.928 37
I2301 2301 0 1.24921e-05
R2604 2301 2302 1.6 0.8 12.8 37
I2302 2302 0 1.31105e-05
R2605 2302 2303 1.632 0.8 13.056 37
I2303 2303 0 1.31105e-05
R2606 2303 2304 1.712 0.8 13.696 37
I2304 2304 0 1.31105e-05
R2607 2304 2305 1.744 0.8 13.952 37
I2305 2305 0 1.28631e-05
R2608 2305 2306 1.616 0.8 12.928 37
I2306 2306 0 1.28631e-05
R2609 2306 2307 1.68 0.8 13.44 37
I2307 2307 0 1.31105e-05
R2610 2307 2308 1.712 0.8 13.696 37
I2308 2308 0 1.24921e-05
R2611 2308 2309 1.696 0.8 13.568 37
I2309 2309 0 1.29868e-05
R2612 2309 2310 1.664 0.8 13.312 37
I2310 2310 0 1.24921e-05
R2613 2310 2311 1.744 0.8 13.952 37
I2311 2311 0 1.32342e-05
R2614 2311 2312 1.6 0.8 12.8 37
I2312 2312 0 1.23684e-05
R2615 2312 2313 1.616 0.8 12.928 37
I2313 2313 0 1.24921e-05
R2616 2313 2314 1.616 0.8 12.928 37
I2314 2314 0 1.27395e-05
R2617 2314 2315 1.712 0.8 13.696 37
I2315 2315 0 1.31105e-05
R2618 2315 2316 1.616 0.8 12.928 37
I2316 2316 0 1.33579e-05
R2619 2316 2317 1.712 0.8 13.696 37
I2317 2317 0 1.27395e-05
R2620 2317 2318 1.712 0.8 13.696 37
I2318 2318 0 1.24921e-05
R2621 2318 2319 1.744 0.8 13.952 37
I2319 2319 0 1.28631e-05
R2622 2319 2320 1.6 0.8 12.8 37
I2320 2320 0 1.33579e-05
R2623 2320 2321 1.6 0.8 12.8 37
I2321 2321 0 1.24921e-05
R2624 2321 2322 1.664 0.8 13.312 37
I2322 2322 0 1.32342e-05
R2625 2322 2323 1.712 0.8 13.696 37
I2323 2323 0 1.27395e-05
R2626 2323 2324 1.744 0.8 13.952 37
I2324 2324 0 1.29868e-05
R2627 2324 2325 1.728 0.8 13.824 37
I2325 2325 0 1.29868e-05
R2628 2325 2326 1.728 0.8 13.824 37
I2326 2326 0 1.32342e-05
R2629 2326 2327 1.632 0.8 13.056 37
I2327 2327 0 1.33579e-05
R2630 2327 2328 1.744 0.8 13.952 37
I2328 2328 0 1.31105e-05
R2631 2328 2329 1.744 0.8 13.952 37
I2329 2329 0 1.24921e-05
R2632 2329 2330 1.616 0.8 12.928 37
I2330 2330 0 1.33579e-05
R2633 2330 2331 1.744 0.8 13.952 37
I2331 2331 0 1.28631e-05
R2634 2331 2332 1.712 0.8 13.696 37
I2332 2332 0 1.33579e-05
R2635 2332 2333 1.712 0.8 13.696 37
I2333 2333 0 1.28631e-05
R2636 2333 2334 1.744 0.8 13.952 37
I2334 2334 0 1.34816e-05
R2637 2334 2335 1.6 0.8 12.8 37
I2335 2335 0 1.34816e-05
R2638 2335 2336 1.744 0.8 13.952 37
I2336 2336 0 1.23684e-05
R2639 2336 2337 1.648 0.8 13.184 37
I2337 2337 0 1.28631e-05
R2640 2337 2338 1.728 0.8 13.824 37
I2338 2338 0 1.26158e-05
R2641 2338 2339 1.712 0.8 13.696 37
I2339 2339 0 1.34816e-05
R2642 2339 2340 1.6 0.8 12.8 37
I2340 2340 0 1.31105e-05
R2643 2340 2341 1.696 0.8 13.568 37
I2341 2341 0 1.33579e-05
R2644 2341 2342 1.68 0.8 13.44 37
I2342 2342 0 1.23684e-05
R2645 2342 2343 1.744 0.8 13.952 37
I2343 2343 0 1.32342e-05
R2646 2343 2344 1.696 0.8 13.568 37
I2344 2344 0 1.23684e-05
R2647 2344 2345 1.728 0.8 13.824 37
I2345 2345 0 1.23684e-05
R2648 2345 2346 1.744 0.8 13.952 37
I2346 2346 0 1.34816e-05
R2649 2346 2347 1.664 0.8 13.312 37
I2347 2347 0 1.33579e-05
R2650 2347 2348 1.712 0.8 13.696 37
I2348 2348 0 1.26158e-05
R2651 2348 2349 1.664 0.8 13.312 37
I2349 2349 0 1.33579e-05
R2652 2349 2350 1.616 0.8 12.928 37
I2350 2350 0 1.28631e-05
R2653 2350 2351 1.728 0.8 13.824 37
I2351 2351 0 1.23684e-05
R2654 2351 2352 1.696 0.8 13.568 37
I2352 2352 0 1.27395e-05
R2655 2352 2353 1.696 0.8 13.568 37
I2353 2353 0 1.31105e-05
R2656 2353 2354 1.68 0.8 13.44 37
I2354 2354 0 1.28631e-05
R2657 2354 2355 1.712 0.8 13.696 37
I2355 2355 0 1.32342e-05
R2658 2355 2356 1.632 0.8 13.056 37
I2356 2356 0 1.29868e-05
R2659 2356 2357 1.696 0.8 13.568 37
I2357 2357 0 1.34816e-05
R2660 2357 2358 1.696 0.8 13.568 37
I2358 2358 0 1.32342e-05
R2661 2358 2359 1.696 0.8 13.568 37
I2359 2359 0 1.28631e-05
R2662 2359 2360 1.712 0.8 13.696 37
I2360 2360 0 1.28631e-05
R2663 2360 2361 1.664 0.8 13.312 37
I2361 2361 0 1.31105e-05
R2664 2361 2362 1.648 0.8 13.184 37
I2362 2362 0 1.34816e-05
R2665 2362 2363 1.696 0.8 13.568 37
I2363 2363 0 1.26158e-05
R2666 2363 2364 1.648 0.8 13.184 37
I2364 2364 0 1.23684e-05
R2667 2364 2365 1.616 0.8 12.928 37
I2365 2365 0 1.31105e-05
R2668 2365 2366 1.696 0.8 13.568 37
I2366 2366 0 1.24921e-05
R2669 2366 2367 1.728 0.8 13.824 37
I2367 2367 0 1.29868e-05
R2670 2367 2368 1.664 0.8 13.312 37
I2368 2368 0 1.29868e-05
R2671 2368 2369 1.616 0.8 12.928 37
I2369 2369 0 1.24921e-05
R2672 2369 2370 1.616 0.8 12.928 37
I2370 2370 0 1.24921e-05
R2673 2370 2371 1.744 0.8 13.952 37
I2371 2371 0 1.27395e-05
R2674 2371 2372 1.696 0.8 13.568 37
I2372 2372 0 1.32342e-05
R2675 2372 2373 1.632 0.8 13.056 37
I2373 2373 0 1.28631e-05
R2676 2373 2374 1.664 0.8 13.312 37
I2374 2374 0 1.24921e-05
R2677 2374 2375 1.744 0.8 13.952 37
I2375 2375 0 1.24921e-05
R2678 2375 2376 1.68 0.8 13.44 37
I2376 2376 0 1.29868e-05
R2679 2376 2377 1.6 0.8 12.8 37
I2377 2377 0 1.24921e-05
R2680 2377 2378 1.696 0.8 13.568 37
I2378 2378 0 1.31105e-05
R2681 2378 2379 1.68 0.8 13.44 37
I2379 2379 0 1.34816e-05
R2682 2379 2380 1.712 0.8 13.696 37
I2380 2380 0 1.31105e-05
R2683 2380 2381 1.712 0.8 13.696 37
I2381 2381 0 1.27395e-05
R2684 2381 2382 1.744 0.8 13.952 37
I2382 2382 0 1.31105e-05
R2685 2382 2383 1.728 0.8 13.824 37
I2383 2383 0 1.29868e-05
R2686 2383 2384 1.648 0.8 13.184 37
I2384 2384 0 1.26158e-05
R2687 2384 2385 1.712 0.8 13.696 37
I2385 2385 0 1.31105e-05
R2688 2385 2386 1.68 0.8 13.44 37
I2386 2386 0 1.33579e-05
R2689 2386 2387 1.616 0.8 12.928 37
I2387 2387 0 1.27395e-05
R2690 2387 2388 1.68 0.8 13.44 37
I2388 2388 0 1.27395e-05
R2691 2388 2389 1.728 0.8 13.824 37
I2389 2389 0 1.34816e-05
R2692 2389 2390 1.696 0.8 13.568 37
I2390 2390 0 1.34816e-05
R2693 2390 2391 1.632 0.8 13.056 37
I2391 2391 0 1.26158e-05
R2694 2391 2392 1.664 0.8 13.312 37
I2392 2392 0 1.26158e-05
R2695 2392 2393 1.68 0.8 13.44 37
I2393 2393 0 1.24921e-05
R2696 2393 2394 1.744 0.8 13.952 37
I2394 2394 0 1.26158e-05
R2697 2394 2395 1.632 0.8 13.056 37
I2395 2395 0 1.31105e-05
R2698 2395 2396 1.616 0.8 12.928 37
I2396 2396 0 1.23684e-05
R2699 2396 2397 1.616 0.8 12.928 37
I2397 2397 0 1.23684e-05
R2700 2397 2398 1.728 0.8 13.824 37
I2398 2398 0 1.26158e-05
R2701 2398 2399 1.696 0.8 13.568 37
I2399 2399 0 1.27395e-05
R2702 2399 2400 1.696 0.8 13.568 37
I2400 2400 0 1.29868e-05
R2703 2400 2401 1.744 0.8 13.952 37
I2401 2401 0 1.27395e-05
R2704 2401 2402 1.648 0.8 13.184 37
I2402 2402 0 1.23684e-05
R2705 2402 2403 1.696 0.8 13.568 37
I2403 2403 0 1.33579e-05
R2706 2403 2404 1.68 0.8 13.44 37
I2404 2404 0 1.31105e-05
R2707 2404 2405 1.744 0.8 13.952 37
I2405 2405 0 1.26158e-05
R2708 2405 2406 1.68 0.8 13.44 37
I2406 2406 0 1.24921e-05
R2709 2406 2407 1.696 0.8 13.568 37
I2407 2407 0 1.23684e-05
R2710 2407 2408 1.664 0.8 13.312 37
I2408 2408 0 1.27395e-05
R2711 2408 2409 1.616 0.8 12.928 37
I2409 2409 0 1.29868e-05
R2712 2409 2410 1.68 0.8 13.44 37
I2410 2410 0 1.27395e-05
R2713 2410 2411 1.648 0.8 13.184 37
I2411 2411 0 1.31105e-05
R2714 2411 2412 1.68 0.8 13.44 37
I2412 2412 0 1.28631e-05
R2715 2412 2413 1.744 0.8 13.952 37
I2413 2413 0 1.27395e-05
R2716 2413 2414 1.728 0.8 13.824 37
I2414 2414 0 1.29868e-05
R2717 2414 2415 1.728 0.8 13.824 37
I2415 2415 0 1.31105e-05
R2718 2415 2416 1.6 0.8 12.8 37
I2416 2416 0 1.32342e-05
R2719 2416 2417 1.744 0.8 13.952 37
I2417 2417 0 1.29868e-05
R2720 2417 2418 1.712 0.8 13.696 37
I2418 2418 0 1.31105e-05
R2721 2418 2419 1.648 0.8 13.184 37
I2419 2419 0 1.27395e-05
R2722 2419 2420 1.632 0.8 13.056 37
I2420 2420 0 1.28631e-05
R2723 2420 2421 1.712 0.8 13.696 37
I2421 2421 0 1.33579e-05
R2724 2421 2422 1.68 0.8 13.44 37
I2422 2422 0 1.27395e-05
R2725 2422 2423 1.6 0.8 12.8 37
I2423 2423 0 1.34816e-05
R2726 2423 2424 1.696 0.8 13.568 37
I2424 2424 0 1.27395e-05
R2727 2424 2425 1.664 0.8 13.312 37
I2425 2425 0 1.24921e-05
R2728 2425 2426 1.728 0.8 13.824 37
I2426 2426 0 1.34816e-05
R2729 2426 2427 1.6 0.8 12.8 37
I2427 2427 0 1.28631e-05
R2730 2427 2428 1.664 0.8 13.312 37
I2428 2428 0 1.34816e-05
R2731 2428 2429 1.744 0.8 13.952 37
I2429 2429 0 1.28631e-05
R2732 2429 2430 1.664 0.8 13.312 37
I2430 2430 0 1.33579e-05
R2733 2430 2431 1.616 0.8 12.928 37
I2431 2431 0 1.31105e-05
R2734 2431 2432 1.68 0.8 13.44 37
I2432 2432 0 1.23684e-05
R2735 2432 2433 1.616 0.8 12.928 37
I2433 2433 0 1.29868e-05
R2736 2433 2434 1.728 0.8 13.824 37
I2434 2434 0 1.31105e-05
R2737 2434 2435 1.6 0.8 12.8 37
I2435 2435 0 1.24921e-05
R2738 2435 2436 1.6 0.8 12.8 37
I2436 2436 0 1.32342e-05
R2739 2436 2437 1.616 0.8 12.928 37
I2437 2437 0 1.32342e-05
R2740 2437 2438 1.6 0.8 12.8 37
I2438 2438 0 1.27395e-05
R2741 2438 2439 1.744 0.8 13.952 37
I2439 2439 0 1.33579e-05
R2742 2439 2440 1.696 0.8 13.568 37
I2440 2440 0 1.29868e-05
R2743 2440 2441 1.616 0.8 12.928 37
I2441 2441 0 1.28631e-05
R2744 2441 2442 1.68 0.8 13.44 37
I2442 2442 0 1.24921e-05
R2745 2442 2443 1.6 0.8 12.8 37
I2443 2443 0 1.34816e-05
R2746 2443 2444 1.6 0.8 12.8 37
I2444 2444 0 1.23684e-05
R2747 2444 2445 1.68 0.8 13.44 37
I2445 2445 0 1.31105e-05
R2748 2445 2446 1.6 0.8 12.8 37
I2446 2446 0 1.31105e-05
R2749 2446 2447 1.664 0.8 13.312 37
I2447 2447 0 1.29868e-05
R2750 2447 2448 1.712 0.8 13.696 37
I2448 2448 0 1.32342e-05
R2751 2448 2449 1.632 0.8 13.056 37
I2449 2449 0 1.32342e-05
R2752 2449 2450 1.648 0.8 13.184 37
I2450 2450 0 1.26158e-05
R2753 2450 2451 1.728 0.8 13.824 37
I2451 2451 0 1.29868e-05
R2754 2451 2452 1.744 0.8 13.952 37
I2452 2452 0 1.24921e-05
R2755 2452 2453 1.648 0.8 13.184 37
I2453 2453 0 1.24921e-05
R2756 2453 2454 1.664 0.8 13.312 37
I2454 2454 0 1.26158e-05
R2757 2454 2455 1.744 0.8 13.952 37
I2455 2455 0 1.23684e-05
R2758 2455 2456 1.744 0.8 13.952 37
I2456 2456 0 1.24921e-05
R2759 2456 2457 1.712 0.8 13.696 37
I2457 2457 0 1.28631e-05
R2760 2457 2458 1.632 0.8 13.056 37
I2458 2458 0 1.32342e-05
R2761 2458 2459 1.68 0.8 13.44 37
I2459 2459 0 1.29868e-05
R2762 2459 2460 1.712 0.8 13.696 37
I2460 2460 0 1.24921e-05
R2763 2460 2461 1.648 0.8 13.184 37
I2461 2461 0 1.32342e-05
R2764 2461 2462 1.712 0.8 13.696 37
I2462 2462 0 1.33579e-05
R2765 2462 2463 1.68 0.8 13.44 37
I2463 2463 0 1.31105e-05
R2766 2463 2464 1.68 0.8 13.44 37
I2464 2464 0 1.32342e-05
R2767 2464 2465 1.664 0.8 13.312 37
I2465 2465 0 1.24921e-05
R2768 2465 2466 1.632 0.8 13.056 37
I2466 2466 0 1.28631e-05
R2769 2466 2467 1.696 0.8 13.568 37
I2467 2467 0 1.24921e-05
R2770 2467 2468 1.728 0.8 13.824 37
I2468 2468 0 1.24921e-05
R2771 2468 2469 1.68 0.8 13.44 37
I2469 2469 0 1.26158e-05
R2772 2469 2470 1.68 0.8 13.44 37
I2470 2470 0 1.28631e-05
R2773 2470 2471 1.68 0.8 13.44 37
I2471 2471 0 1.29868e-05
R2774 2471 2472 1.712 0.8 13.696 37
I2472 2472 0 1.26158e-05
R2775 2472 2473 1.744 0.8 13.952 37
I2473 2473 0 1.26158e-05
R2776 2473 2474 1.744 0.8 13.952 37
I2474 2474 0 1.29868e-05
R2777 2474 2475 1.712 0.8 13.696 37
I2475 2475 0 1.34816e-05
R2778 2475 2476 1.696 0.8 13.568 37
I2476 2476 0 1.23684e-05
R2779 2476 2477 1.728 0.8 13.824 37
I2477 2477 0 1.29868e-05
R2780 2477 2478 1.6 0.8 12.8 37
I2478 2478 0 1.29868e-05
R2781 2478 2479 1.664 0.8 13.312 37
I2479 2479 0 1.31105e-05
R2782 2479 2480 1.68 0.8 13.44 37
I2480 2480 0 1.23684e-05
R2783 2480 2481 1.712 0.8 13.696 37
I2481 2481 0 1.32342e-05
R2784 2481 2482 1.664 0.8 13.312 37
I2482 2482 0 1.29868e-05
R2785 2482 2483 1.6 0.8 12.8 37
I2483 2483 0 1.26158e-05
R2786 2483 2484 1.744 0.8 13.952 37
I2484 2484 0 1.29868e-05
R2787 2484 2485 1.712 0.8 13.696 37
I2485 2485 0 1.28631e-05
R2788 2485 2486 1.632 0.8 13.056 37
I2486 2486 0 1.26158e-05
R2789 2486 2487 1.616 0.8 12.928 37
I2487 2487 0 1.34816e-05
R2790 2487 2488 1.696 0.8 13.568 37
I2488 2488 0 1.24921e-05
R2791 2488 2489 1.616 0.8 12.928 37
I2489 2489 0 1.32342e-05
R2792 2489 2490 1.728 0.8 13.824 37
I2490 2490 0 1.23684e-05
R2793 2490 2491 1.696 0.8 13.568 37
I2491 2491 0 1.31105e-05
R2794 2491 2492 1.648 0.8 13.184 37
I2492 2492 0 1.32342e-05
R2795 2492 2493 1.616 0.8 12.928 37
I2493 2493 0 1.27395e-05
R2796 2493 2494 1.632 0.8 13.056 37
I2494 2494 0 1.32342e-05
R2797 2494 2495 1.616 0.8 12.928 37
I2495 2495 0 1.34816e-05
R2798 2495 2496 1.712 0.8 13.696 37
I2496 2496 0 1.23684e-05
R2799 2496 2497 1.696 0.8 13.568 37
I2497 2497 0 1.26158e-05
R2800 2497 2498 1.696 0.8 13.568 37
I2498 2498 0 1.32342e-05
R2801 2498 2499 1.696 0.8 13.568 37
I2499 2499 0 1.32342e-05
R2802 2499 2500 1.664 0.8 13.312 37
I2500 2500 0 1.27395e-05
R2803 2500 2501 1.616 0.8 12.928 37
I2501 2501 0 1.31105e-05
R2804 2501 2502 1.712 0.8 13.696 37
I2502 2502 0 1.29868e-05
R2805 2502 2503 1.728 0.8 13.824 37
I2503 2503 0 1.27395e-05
R2806 2503 2504 1.728 0.8 13.824 37
I2504 2504 0 1.24921e-05
R2807 2504 2505 1.616 0.8 12.928 37
I2505 2505 0 1.31105e-05
R2808 2505 2506 1.664 0.8 13.312 37
I2506 2506 0 1.34816e-05
R2809 2506 2507 1.632 0.8 13.056 37
I2507 2507 0 1.32342e-05
R2810 2507 2508 1.696 0.8 13.568 37
I2508 2508 0 1.29868e-05
R2811 2508 2509 1.632 0.8 13.056 37
I2509 2509 0 1.24921e-05
R2812 2509 2510 1.68 0.8 13.44 37
I2510 2510 0 1.28631e-05
R2813 2510 2511 1.6 0.8 12.8 37
I2511 2511 0 1.26158e-05
R2814 2511 2512 1.664 0.8 13.312 37
I2512 2512 0 1.32342e-05
R2815 2512 2513 1.664 0.8 13.312 37
I2513 2513 0 1.26158e-05
R2816 2513 2514 1.696 0.8 13.568 37
I2514 2514 0 1.27395e-05
R2817 2514 2515 1.744 0.8 13.952 37
I2515 2515 0 1.23684e-05
R2818 2515 2516 1.696 0.8 13.568 37
I2516 2516 0 1.27395e-05
R2819 2516 2517 1.744 0.8 13.952 37
I2517 2517 0 1.31105e-05
R2820 2517 2518 1.728 0.8 13.824 37
I2518 2518 0 1.32342e-05
R2821 2518 2519 1.744 0.8 13.952 37
I2519 2519 0 1.31105e-05
R2822 2519 2520 1.728 0.8 13.824 37
I2520 2520 0 1.23684e-05
R2823 2520 2521 1.664 0.8 13.312 37
I2521 2521 0 1.26158e-05
R2824 2521 2522 1.6 0.8 12.8 37
I2522 2522 0 1.33579e-05
R2825 2522 2523 1.616 0.8 12.928 37
I2523 2523 0 1.33579e-05
R2826 2523 2524 1.68 0.8 13.44 37
I2524 2524 0 1.28631e-05
R2827 2524 2525 1.744 0.8 13.952 37
I2525 2525 0 1.23684e-05
R2828 2525 2526 1.6 0.8 12.8 37
I2526 2526 0 1.26158e-05
R2829 2526 2527 1.648 0.8 13.184 37
I2527 2527 0 1.31105e-05
R2830 2527 2528 1.744 0.8 13.952 37
I2528 2528 0 1.34816e-05
R2831 2528 2529 1.616 0.8 12.928 37
I2529 2529 0 1.32342e-05
R2832 2529 2530 1.632 0.8 13.056 37
I2530 2530 0 1.23684e-05
R2833 2530 2531 1.744 0.8 13.952 37
I2531 2531 0 1.24921e-05
R2834 2531 2532 1.68 0.8 13.44 37
I2532 2532 0 1.33579e-05
R2835 2532 2533 1.712 0.8 13.696 37
I2533 2533 0 1.27395e-05
R2836 2533 2534 1.68 0.8 13.44 37
I2534 2534 0 1.33579e-05
R2837 2534 2535 1.616 0.8 12.928 37
I2535 2535 0 1.31105e-05
R2838 2535 2536 1.616 0.8 12.928 37
I2536 2536 0 1.29868e-05
R2839 2536 2537 1.6 0.8 12.8 37
I2537 2537 0 1.27395e-05
R2840 2537 2538 1.648 0.8 13.184 37
I2538 2538 0 1.26158e-05
R2841 2538 2539 1.616 0.8 12.928 37
I2539 2539 0 1.34816e-05
R2842 2539 2540 1.728 0.8 13.824 37
I2540 2540 0 1.27395e-05
R2843 2540 2541 1.744 0.8 13.952 37
I2541 2541 0 1.23684e-05
R2844 2541 2542 1.68 0.8 13.44 37
I2542 2542 0 1.26158e-05
R2845 2542 2543 1.696 0.8 13.568 37
I2543 2543 0 1.31105e-05
R2846 2543 2544 1.664 0.8 13.312 37
I2544 2544 0 1.32342e-05
R2847 2544 2545 1.648 0.8 13.184 37
I2545 2545 0 1.31105e-05
R2848 2545 2546 1.6 0.8 12.8 37
I2546 2546 0 1.28631e-05
R2849 2546 2547 1.744 0.8 13.952 37
I2547 2547 0 1.29868e-05
R2850 2547 2548 1.648 0.8 13.184 37
I2548 2548 0 1.33579e-05
R2851 2548 2549 1.616 0.8 12.928 37
I2549 2549 0 1.23684e-05
R2852 2549 2550 1.712 0.8 13.696 37
I2550 2550 0 1.26158e-05
R2853 2550 2551 1.728 0.8 13.824 37
I2551 2551 0 1.33579e-05
R2854 2551 2552 1.728 0.8 13.824 37
I2552 2552 0 1.34816e-05
R2855 2552 2553 1.616 0.8 12.928 37
I2553 2553 0 1.27395e-05
R2856 2553 2554 1.648 0.8 13.184 37
I2554 2554 0 1.28631e-05
R2857 2554 2555 1.664 0.8 13.312 37
I2555 2555 0 1.24921e-05
R2858 2555 2556 1.744 0.8 13.952 37
I2556 2556 0 1.28631e-05
R2859 2556 2557 1.648 0.8 13.184 37
I2557 2557 0 1.28631e-05
R2860 2557 2558 1.728 0.8 13.824 37
I2558 2558 0 1.34816e-05
R2861 2558 2559 1.632 0.8 13.056 37
I2559 2559 0 1.26158e-05
R2862 2559 2560 1.744 0.8 13.952 37
I2560 2560 0 1.32342e-05
R2863 2560 2561 1.616 0.8 12.928 37
I2561 2561 0 1.34816e-05
R2864 2561 2562 1.632 0.8 13.056 37
I2562 2562 0 1.26158e-05
R2865 2562 2563 1.696 0.8 13.568 37
I2563 2563 0 1.29868e-05
R2866 2563 2564 1.616 0.8 12.928 37
I2564 2564 0 1.32342e-05
R2867 2564 2565 1.712 0.8 13.696 37
I2565 2565 0 1.23684e-05
R2868 2565 2566 1.632 0.8 13.056 37
I2566 2566 0 1.31105e-05
R2869 2566 2567 1.728 0.8 13.824 37
I2567 2567 0 1.26158e-05
R2870 2567 2568 1.68 0.8 13.44 37
I2568 2568 0 1.24921e-05
R2871 2568 2569 1.68 0.8 13.44 37
I2569 2569 0 1.23684e-05
R2872 2569 2570 1.712 0.8 13.696 37
I2570 2570 0 1.23684e-05
R2873 2570 2571 1.616 0.8 12.928 37
I2571 2571 0 1.32342e-05
R2874 2571 2572 1.696 0.8 13.568 37
I2572 2572 0 1.31105e-05
R2875 2572 2573 1.648 0.8 13.184 37
I2573 2573 0 1.31105e-05
R2876 2573 2574 1.68 0.8 13.44 37
I2574 2574 0 1.31105e-05
R2877 2574 2575 1.744 0.8 13.952 37
I2575 2575 0 1.31105e-05
R2878 2575 2576 1.68 0.8 13.44 37
I2576 2576 0 1.26158e-05
R2879 2576 2577 1.712 0.8 13.696 37
I2577 2577 0 1.32342e-05
R2880 2577 2578 1.664 0.8 13.312 37
I2578 2578 0 1.31105e-05
R2881 2578 2579 1.664 0.8 13.312 37
I2579 2579 0 1.32342e-05
R2882 2579 2580 1.648 0.8 13.184 37
I2580 2580 0 1.26158e-05
R2883 2580 2581 1.712 0.8 13.696 37
I2581 2581 0 1.32342e-05
R2884 2581 2582 1.6 0.8 12.8 37
I2582 2582 0 1.32342e-05
R2885 2582 2583 1.744 0.8 13.952 37
I2583 2583 0 1.29868e-05
R2886 2583 2584 1.6 0.8 12.8 37
I2584 2584 0 1.32342e-05
R2887 2584 2585 1.68 0.8 13.44 37
I2585 2585 0 1.33579e-05
R2888 2585 2586 1.744 0.8 13.952 37
I2586 2586 0 1.33579e-05
R2889 2586 2587 1.712 0.8 13.696 37
I2587 2587 0 1.29868e-05
R2890 2587 2588 1.664 0.8 13.312 37
I2588 2588 0 1.26158e-05
R2891 2588 2589 1.616 0.8 12.928 37
I2589 2589 0 1.24921e-05
R2892 2589 2590 1.6 0.8 12.8 37
I2590 2590 0 1.26158e-05
R2893 2590 2591 1.6 0.8 12.8 37
I2591 2591 0 1.31105e-05
R2894 2591 2592 1.696 0.8 13.568 37
I2592 2592 0 1.32342e-05
R2895 2592 2593 1.68 0.8 13.44 37
I2593 2593 0 1.24921e-05
R2896 2593 2594 1.68 0.8 13.44 37
I2594 2594 0 1.23684e-05
R2897 2594 2595 1.728 0.8 13.824 37
I2595 2595 0 1.34816e-05
R2898 2595 2596 1.664 0.8 13.312 37
I2596 2596 0 1.33579e-05
R2899 2596 2597 1.728 0.8 13.824 37
I2597 2597 0 1.28631e-05
R2900 2597 2598 1.68 0.8 13.44 37
I2598 2598 0 1.33579e-05
R2901 2598 2599 1.616 0.8 12.928 37
I2599 2599 0 1.31105e-05
R2902 2599 2600 1.712 0.8 13.696 37
I2600 2600 0 1.33579e-05
R2903 2600 2601 1.696 0.8 13.568 37
I2601 2601 0 1.31105e-05
R2904 2601 2602 1.728 0.8 13.824 37
I2602 2602 0 1.29868e-05
R2905 2602 2603 1.648 0.8 13.184 37
I2603 2603 0 1.28631e-05
R2906 2603 2604 1.712 0.8 13.696 37
I2604 2604 0 1.31105e-05
R2907 2604 2605 1.712 0.8 13.696 37
I2605 2605 0 1.33579e-05
R2908 2605 2606 1.744 0.8 13.952 37
I2606 2606 0 1.32342e-05
R2909 2606 2607 1.664 0.8 13.312 37
I2607 2607 0 1.32342e-05
R2910 2607 2608 1.712 0.8 13.696 37
I2608 2608 0 1.24921e-05
R2911 2608 2609 1.728 0.8 13.824 37
I2609 2609 0 1.26158e-05
R2912 2609 2610 1.616 0.8 12.928 37
I2610 2610 0 1.34816e-05
R2913 2610 2611 1.648 0.8 13.184 37
I2611 2611 0 1.32342e-05
R2914 2611 2612 1.712 0.8 13.696 37
I2612 2612 0 1.26158e-05
R2915 2612 2613 1.648 0.8 13.184 37
I2613 2613 0 1.28631e-05
R2916 2613 2614 1.632 0.8 13.056 37
I2614 2614 0 1.28631e-05
R2917 2614 2615 1.6 0.8 12.8 37
I2615 2615 0 1.24921e-05
R2918 2615 2616 1.664 0.8 13.312 37
I2616 2616 0 1.33579e-05
R2919 2616 2617 1.712 0.8 13.696 37
I2617 2617 0 1.26158e-05
R2920 2617 2618 1.648 0.8 13.184 37
I2618 2618 0 1.26158e-05
R2921 2618 2619 1.696 0.8 13.568 37
I2619 2619 0 1.24921e-05
R2922 2619 2620 1.728 0.8 13.824 37
I2620 2620 0 1.28631e-05
R2923 2620 2621 1.616 0.8 12.928 37
I2621 2621 0 1.34816e-05
R2924 2621 2622 1.616 0.8 12.928 37
I2622 2622 0 1.32342e-05
R2925 2622 2623 1.712 0.8 13.696 37
I2623 2623 0 1.23684e-05
R2926 2623 2624 1.728 0.8 13.824 37
I2624 2624 0 1.32342e-05
R2927 2624 2625 1.648 0.8 13.184 37
I2625 2625 0 1.26158e-05
R2928 2625 2626 1.728 0.8 13.824 37
I2626 2626 0 1.33579e-05
R2929 2626 2627 1.744 0.8 13.952 37
I2627 2627 0 1.29868e-05
R2930 2627 2628 1.6 0.8 12.8 37
I2628 2628 0 1.29868e-05
R2931 2628 2629 1.632 0.8 13.056 37
I2629 2629 0 1.28631e-05
R2932 2629 2630 1.744 0.8 13.952 37
I2630 2630 0 1.28631e-05
R2933 2630 2631 1.68 0.8 13.44 37
I2631 2631 0 1.31105e-05
R2934 2631 2632 1.648 0.8 13.184 37
I2632 2632 0 1.28631e-05
R2935 2632 2633 1.728 0.8 13.824 37
I2633 2633 0 1.33579e-05
R2936 2633 2634 1.696 0.8 13.568 37
I2634 2634 0 1.29868e-05
R2937 2634 2635 1.616 0.8 12.928 37
I2635 2635 0 1.32342e-05
R2938 2635 2636 1.616 0.8 12.928 37
I2636 2636 0 1.26158e-05
R2939 2636 2637 1.728 0.8 13.824 37
I2637 2637 0 1.28631e-05
R2940 2637 2638 1.616 0.8 12.928 37
I2638 2638 0 1.29868e-05
R2941 2638 2639 1.68 0.8 13.44 37
I2639 2639 0 1.23684e-05
R2942 2639 2640 1.68 0.8 13.44 37
I2640 2640 0 1.23684e-05
R2943 2640 2641 1.632 0.8 13.056 37
I2641 2641 0 1.27395e-05
R2944 2641 2642 1.728 0.8 13.824 37
I2642 2642 0 1.27395e-05
R2945 2642 2643 1.616 0.8 12.928 37
I2643 2643 0 1.24921e-05
R2946 2643 2644 1.728 0.8 13.824 37
I2644 2644 0 1.27395e-05
R2947 2644 2645 1.712 0.8 13.696 37
I2645 2645 0 1.23684e-05
R2948 2645 2646 1.744 0.8 13.952 37
I2646 2646 0 1.27395e-05
R2949 2646 2647 1.696 0.8 13.568 37
I2647 2647 0 1.26158e-05
R2950 2647 2648 1.712 0.8 13.696 37
I2648 2648 0 1.28631e-05
R2951 2648 2649 1.616 0.8 12.928 37
I2649 2649 0 1.31105e-05
R2952 2649 2650 1.616 0.8 12.928 37
I2650 2650 0 1.28631e-05
R2953 2650 2651 1.648 0.8 13.184 37
I2651 2651 0 1.28631e-05
R2954 2651 2652 1.712 0.8 13.696 37
I2652 2652 0 1.27395e-05
R2955 2652 2653 1.744 0.8 13.952 37
I2653 2653 0 1.33579e-05
R2956 2653 2654 1.616 0.8 12.928 37
I2654 2654 0 1.31105e-05
R2957 2654 2655 1.6 0.8 12.8 37
I2655 2655 0 1.31105e-05
R2958 2655 2656 1.696 0.8 13.568 37
I2656 2656 0 1.26158e-05
R2959 2656 2657 1.616 0.8 12.928 37
I2657 2657 0 1.31105e-05
R2960 2657 2658 1.728 0.8 13.824 37
I2658 2658 0 1.28631e-05
R2961 2658 2659 1.744 0.8 13.952 37
I2659 2659 0 1.31105e-05
R2962 2659 2660 1.744 0.8 13.952 37
I2660 2660 0 1.32342e-05
R2963 2660 2661 1.696 0.8 13.568 37
I2661 2661 0 1.34816e-05
R2964 2661 2662 1.632 0.8 13.056 37
I2662 2662 0 1.28631e-05
R2965 2662 2663 1.616 0.8 12.928 37
I2663 2663 0 1.24921e-05
R2966 2663 2664 1.744 0.8 13.952 37
I2664 2664 0 1.28631e-05
R2967 2664 2665 1.712 0.8 13.696 37
I2665 2665 0 1.26158e-05
R2968 2665 2666 1.744 0.8 13.952 37
I2666 2666 0 1.26158e-05
R2969 2666 2667 1.712 0.8 13.696 37
I2667 2667 0 1.33579e-05
R2970 2667 2668 1.696 0.8 13.568 37
I2668 2668 0 1.33579e-05
R2971 2668 2669 1.728 0.8 13.824 37
I2669 2669 0 1.32342e-05
R2972 2669 2670 1.664 0.8 13.312 37
I2670 2670 0 1.34816e-05
R2973 2670 2671 1.68 0.8 13.44 37
I2671 2671 0 1.26158e-05
R2974 2671 2672 1.648 0.8 13.184 37
I2672 2672 0 1.31105e-05
R2975 2672 2673 1.6 0.8 12.8 37
I2673 2673 0 1.27395e-05
R2976 2673 2674 1.616 0.8 12.928 37
I2674 2674 0 1.23684e-05
R2977 2674 2675 1.6 0.8 12.8 37
I2675 2675 0 1.23684e-05
R2978 2675 2676 1.744 0.8 13.952 37
I2676 2676 0 1.33579e-05
R2979 2676 2677 1.744 0.8 13.952 37
I2677 2677 0 1.24921e-05
R2980 2677 2678 1.648 0.8 13.184 37
I2678 2678 0 1.27395e-05
R2981 2678 2679 1.664 0.8 13.312 37
I2679 2679 0 1.28631e-05
R2982 2679 2680 1.744 0.8 13.952 37
I2680 2680 0 1.28631e-05
R2983 2680 2681 1.728 0.8 13.824 37
I2681 2681 0 1.23684e-05
R2984 2681 2682 1.696 0.8 13.568 37
I2682 2682 0 1.32342e-05
R2985 2682 2683 1.728 0.8 13.824 37
I2683 2683 0 1.28631e-05
R2986 2683 2684 1.68 0.8 13.44 37
I2684 2684 0 1.34816e-05
R2987 2684 2685 1.648 0.8 13.184 37
I2685 2685 0 1.34816e-05
R2988 2685 2686 1.728 0.8 13.824 37
I2686 2686 0 1.23684e-05
R2989 2686 2687 1.616 0.8 12.928 37
I2687 2687 0 1.27395e-05
R2990 2687 2688 1.744 0.8 13.952 37
I2688 2688 0 1.28631e-05
R2991 2688 2689 1.712 0.8 13.696 37
I2689 2689 0 1.26158e-05
R2992 2689 2690 1.696 0.8 13.568 37
I2690 2690 0 1.34816e-05
R2993 2690 2691 1.664 0.8 13.312 37
I2691 2691 0 1.29868e-05
R2994 2691 2692 1.744 0.8 13.952 37
I2692 2692 0 1.28631e-05
R2995 2692 2693 1.728 0.8 13.824 37
I2693 2693 0 1.28631e-05
R2996 2693 2694 1.744 0.8 13.952 37
I2694 2694 0 1.26158e-05
R2997 2694 2695 1.6 0.8 12.8 37
I2695 2695 0 1.23684e-05
R2998 2695 2696 1.696 0.8 13.568 37
I2696 2696 0 1.34816e-05
R2999 2696 2697 1.616 0.8 12.928 37
I2697 2697 0 1.29868e-05
R3000 2697 2698 1.696 0.8 13.568 37
I2698 2698 0 1.34816e-05
R3001 2698 2699 1.616 0.8 12.928 37
I2699 2699 0 1.26158e-05
R3002 2699 2700 1.6 0.8 12.8 37
I2700 2700 0 1.32342e-05
R3003 2700 2701 1.648 0.8 13.184 37
I2701 2701 0 1.23684e-05
R3004 2701 2702 1.712 0.8 13.696 37
I2702 2702 0 1.32342e-05
R3005 2702 2703 1.664 0.8 13.312 37
I2703 2703 0 1.33579e-05
R3006 2703 2704 1.616 0.8 12.928 37
I2704 2704 0 1.27395e-05
R3007 2704 2705 1.6 0.8 12.8 37
I2705 2705 0 1.32342e-05
R3008 2705 2706 1.632 0.8 13.056 37
I2706 2706 0 1.29868e-05
R3009 2706 2707 1.632 0.8 13.056 37
I2707 2707 0 1.27395e-05
R3010 2707 2708 1.616 0.8 12.928 37
I2708 2708 0 1.26158e-05
R3011 2708 2709 1.728 0.8 13.824 37
I2709 2709 0 1.23684e-05
R3012 2709 2710 1.696 0.8 13.568 37
I2710 2710 0 1.33579e-05
R3013 2710 2711 1.6 0.8 12.8 37
I2711 2711 0 1.27395e-05
R3014 2711 2712 1.712 0.8 13.696 37
I2712 2712 0 1.24921e-05
R3015 2712 2713 1.6 0.8 12.8 37
I2713 2713 0 1.31105e-05
R3016 2713 2714 1.648 0.8 13.184 37
I2714 2714 0 1.27395e-05
R3017 2714 2715 1.6 0.8 12.8 37
I2715 2715 0 1.29868e-05
R3018 2715 2716 1.6 0.8 12.8 37
I2716 2716 0 1.27395e-05
R3019 2716 2717 1.696 0.8 13.568 37
I2717 2717 0 1.23684e-05
R3020 2717 2718 1.6 0.8 12.8 37
I2718 2718 0 1.26158e-05
R3021 2718 2719 1.728 0.8 13.824 37
I2719 2719 0 1.27395e-05
R3022 2719 2720 1.68 0.8 13.44 37
I2720 2720 0 1.34816e-05
R3023 2720 2721 1.6 0.8 12.8 37
I2721 2721 0 1.34816e-05
R3024 2721 2722 1.696 0.8 13.568 37
I2722 2722 0 1.28631e-05
R3025 2722 2723 1.632 0.8 13.056 37
I2723 2723 0 1.32342e-05
R3026 2723 2724 1.696 0.8 13.568 37
I2724 2724 0 1.23684e-05
R3027 2724 2725 1.712 0.8 13.696 37
I2725 2725 0 1.29868e-05
R3028 2725 2726 1.616 0.8 12.928 37
I2726 2726 0 1.34816e-05
R3029 2726 2727 1.6 0.8 12.8 37
I2727 2727 0 1.23684e-05
R3030 2727 2728 1.648 0.8 13.184 37
I2728 2728 0 1.23684e-05
R3031 2728 2729 1.696 0.8 13.568 37
I2729 2729 0 1.33579e-05
R3032 2729 2730 1.68 0.8 13.44 37
I2730 2730 0 1.31105e-05
R3033 2730 2731 1.648 0.8 13.184 37
I2731 2731 0 1.31105e-05
R3034 2731 2732 1.632 0.8 13.056 37
I2732 2732 0 1.24921e-05
R3035 2732 2733 1.728 0.8 13.824 37
I2733 2733 0 1.28631e-05
R3036 2733 2734 1.648 0.8 13.184 37
I2734 2734 0 1.33579e-05
R3037 2734 2735 1.728 0.8 13.824 37
I2735 2735 0 1.33579e-05
R3038 2735 2736 1.744 0.8 13.952 37
I2736 2736 0 1.33579e-05
R3039 2736 2737 1.744 0.8 13.952 37
I2737 2737 0 1.29868e-05
R3040 2737 2738 1.68 0.8 13.44 37
I2738 2738 0 1.28631e-05
R3041 2738 2739 1.632 0.8 13.056 37
I2739 2739 0 1.27395e-05
R3042 2739 2740 1.664 0.8 13.312 37
I2740 2740 0 1.24921e-05
R3043 2740 2741 1.728 0.8 13.824 37
I2741 2741 0 1.32342e-05
R3044 2741 2742 1.648 0.8 13.184 37
I2742 2742 0 1.33579e-05
R3045 2742 2743 1.728 0.8 13.824 37
I2743 2743 0 1.31105e-05
R3046 2743 2744 1.6 0.8 12.8 37
I2744 2744 0 1.28631e-05
R3047 2744 2745 1.696 0.8 13.568 37
I2745 2745 0 1.31105e-05
R3048 2745 2746 1.648 0.8 13.184 37
I2746 2746 0 1.24921e-05
R3049 2746 2747 1.664 0.8 13.312 37
I2747 2747 0 1.29868e-05
R3050 2747 2748 1.648 0.8 13.184 37
I2748 2748 0 1.26158e-05
R3051 2748 2749 1.744 0.8 13.952 37
I2749 2749 0 1.31105e-05
R3052 2749 2750 1.6 0.8 12.8 37
I2750 2750 0 1.32342e-05
R3053 2750 2751 1.712 0.8 13.696 37
I2751 2751 0 1.26158e-05
R3054 2751 2752 1.728 0.8 13.824 37
I2752 2752 0 1.31105e-05
R3055 2752 2753 1.712 0.8 13.696 37
I2753 2753 0 1.27395e-05
R3056 2753 2754 1.6 0.8 12.8 37
I2754 2754 0 1.23684e-05
R3057 2754 2755 1.728 0.8 13.824 37
I2755 2755 0 1.32342e-05
R3058 2755 2756 1.616 0.8 12.928 37
I2756 2756 0 1.32342e-05
R3059 2756 2757 1.664 0.8 13.312 37
I2757 2757 0 1.28631e-05
R3060 2757 2758 1.68 0.8 13.44 37
I2758 2758 0 1.28631e-05
R3061 2758 2759 1.632 0.8 13.056 37
I2759 2759 0 1.33579e-05
R3062 2759 2760 1.744 0.8 13.952 37
I2760 2760 0 1.23684e-05
R3063 2760 2761 1.664 0.8 13.312 37
I2761 2761 0 1.28631e-05
R3064 2761 2762 1.632 0.8 13.056 37
I2762 2762 0 1.33579e-05
R3065 2762 2763 1.744 0.8 13.952 37
I2763 2763 0 1.32342e-05
R3066 2763 2764 1.632 0.8 13.056 37
I2764 2764 0 1.23684e-05
R3067 2764 2765 1.648 0.8 13.184 37
I2765 2765 0 1.28631e-05
R3068 2765 2766 1.6 0.8 12.8 37
I2766 2766 0 1.26158e-05
R3069 2766 2767 1.696 0.8 13.568 37
I2767 2767 0 1.23684e-05
R3070 2767 2768 1.616 0.8 12.928 37
I2768 2768 0 1.28631e-05
R3071 2768 2769 1.68 0.8 13.44 37
I2769 2769 0 1.27395e-05
R3072 2769 2770 1.696 0.8 13.568 37
I2770 2770 0 1.27395e-05
R3073 2770 2771 1.632 0.8 13.056 37
I2771 2771 0 1.32342e-05
R3074 2771 2772 1.6 0.8 12.8 37
I2772 2772 0 1.32342e-05
R3075 2772 2773 1.664 0.8 13.312 37
I2773 2773 0 1.33579e-05
R3076 2773 2774 1.616 0.8 12.928 37
I2774 2774 0 1.33579e-05
R3077 2774 2775 1.696 0.8 13.568 37
I2775 2775 0 1.26158e-05
R3078 2775 2776 1.744 0.8 13.952 37
I2776 2776 0 1.26158e-05
R3079 2776 2777 1.696 0.8 13.568 37
I2777 2777 0 1.27395e-05
R3080 2777 2778 1.632 0.8 13.056 37
I2778 2778 0 1.32342e-05
R3081 2778 2779 1.6 0.8 12.8 37
I2779 2779 0 1.28631e-05
R3082 2779 2780 1.6 0.8 12.8 37
I2780 2780 0 1.29868e-05
R3083 2780 2781 1.728 0.8 13.824 37
I2781 2781 0 1.23684e-05
R3084 2781 2782 1.6 0.8 12.8 37
I2782 2782 0 1.32342e-05
R3085 2782 2783 1.6 0.8 12.8 37
I2783 2783 0 1.24921e-05
R3086 2783 2784 1.648 0.8 13.184 37
I2784 2784 0 1.32342e-05
R3087 2784 2785 1.664 0.8 13.312 37
I2785 2785 0 1.34816e-05
R3088 2785 2786 1.6 0.8 12.8 37
I2786 2786 0 1.32342e-05
R3089 2786 2787 1.728 0.8 13.824 37
I2787 2787 0 1.27395e-05
R3090 2787 2788 1.696 0.8 13.568 37
I2788 2788 0 1.28631e-05
R3091 2788 2789 1.648 0.8 13.184 37
I2789 2789 0 1.34816e-05
R3092 2789 2790 1.648 0.8 13.184 37
I2790 2790 0 1.24921e-05
R3093 2790 2791 1.664 0.8 13.312 37
I2791 2791 0 1.28631e-05
R3094 2791 2792 1.648 0.8 13.184 37
I2792 2792 0 1.26158e-05
R3095 2792 2793 1.744 0.8 13.952 37
I2793 2793 0 1.29868e-05
R3096 2793 2794 1.6 0.8 12.8 37
I2794 2794 0 1.24921e-05
R3097 2794 2795 1.616 0.8 12.928 37
I2795 2795 0 1.23684e-05
R3098 2795 2796 1.728 0.8 13.824 37
I2796 2796 0 1.24921e-05
R3099 2796 2797 1.632 0.8 13.056 37
I2797 2797 0 1.33579e-05
R3100 2797 2798 1.728 0.8 13.824 37
I2798 2798 0 1.28631e-05
R3101 2798 2799 1.744 0.8 13.952 37
I2799 2799 0 1.24921e-05
R3102 2799 2800 1.616 0.8 12.928 37
I2800 2800 0 1.31105e-05
R3103 2800 2801 1.632 0.8 13.056 37
I2801 2801 0 1.27395e-05
R3104 2801 2802 1.68 0.8 13.44 37
I2802 2802 0 1.24921e-05
R3105 2802 2803 1.696 0.8 13.568 37
I2803 2803 0 1.27395e-05
R3106 2803 2804 1.68 0.8 13.44 37
I2804 2804 0 1.34816e-05
R3107 2804 2805 1.664 0.8 13.312 37
I2805 2805 0 1.23684e-05
R3108 2805 2806 1.632 0.8 13.056 37
I2806 2806 0 1.33579e-05
R3109 2806 2807 1.664 0.8 13.312 37
I2807 2807 0 1.29868e-05
R3110 2807 2808 1.616 0.8 12.928 37
I2808 2808 0 1.27395e-05
R3111 2808 2809 1.632 0.8 13.056 37
I2809 2809 0 1.27395e-05
R3112 2809 2810 1.696 0.8 13.568 37
I2810 2810 0 1.27395e-05
R3113 2810 2811 1.68 0.8 13.44 37
I2811 2811 0 1.29868e-05
R3114 2811 2812 1.712 0.8 13.696 37
I2812 2812 0 1.32342e-05
R3115 2812 2813 1.648 0.8 13.184 37
I2813 2813 0 1.29868e-05
R3116 2813 2814 1.616 0.8 12.928 37
I2814 2814 0 1.29868e-05
R3117 2814 2815 1.744 0.8 13.952 37
I2815 2815 0 1.28631e-05
R3118 2815 2816 1.648 0.8 13.184 37
I2816 2816 0 1.24921e-05
R3119 2816 2817 1.712 0.8 13.696 37
I2817 2817 0 1.33579e-05
R3120 2817 2818 1.664 0.8 13.312 37
I2818 2818 0 1.31105e-05
R3121 2818 2819 1.648 0.8 13.184 37
I2819 2819 0 1.23684e-05
R3122 2819 2820 1.712 0.8 13.696 37
I2820 2820 0 1.32342e-05
R3123 2820 2821 1.6 0.8 12.8 37
I2821 2821 0 1.23684e-05
R3124 2821 2822 1.696 0.8 13.568 37
I2822 2822 0 1.32342e-05
R3125 2822 2823 1.712 0.8 13.696 37
I2823 2823 0 1.34816e-05
R3126 2823 2824 1.632 0.8 13.056 37
I2824 2824 0 1.26158e-05
R3127 2824 2825 1.664 0.8 13.312 37
I2825 2825 0 1.34816e-05
R3128 2825 2826 1.712 0.8 13.696 37
I2826 2826 0 1.34816e-05
R3129 2826 2827 1.664 0.8 13.312 37
I2827 2827 0 1.28631e-05
R3130 2827 2828 1.728 0.8 13.824 37
I2828 2828 0 1.32342e-05
R3131 2828 2829 1.632 0.8 13.056 37
I2829 2829 0 1.24921e-05
R3132 2829 2830 1.632 0.8 13.056 37
I2830 2830 0 1.24921e-05
R3133 2830 2831 1.68 0.8 13.44 37
I2831 2831 0 1.29868e-05
R3134 2831 2832 1.664 0.8 13.312 37
I2832 2832 0 1.28631e-05
R3135 2832 2833 1.68 0.8 13.44 37
I2833 2833 0 1.34816e-05
R3136 2833 2834 1.6 0.8 12.8 37
I2834 2834 0 1.33579e-05
R3137 2834 2835 1.744 0.8 13.952 37
I2835 2835 0 1.33579e-05
R3138 2835 2836 1.728 0.8 13.824 37
I2836 2836 0 1.24921e-05
R3139 2836 2837 1.6 0.8 12.8 37
I2837 2837 0 1.28631e-05
R3140 2837 2838 1.728 0.8 13.824 37
I2838 2838 0 1.32342e-05
R3141 2838 2839 1.68 0.8 13.44 37
I2839 2839 0 1.24921e-05
R3142 2839 2840 1.744 0.8 13.952 37
I2840 2840 0 1.34816e-05
R3143 2840 2841 1.632 0.8 13.056 37
I2841 2841 0 1.32342e-05
R3144 2841 2842 1.6 0.8 12.8 37
I2842 2842 0 1.31105e-05
R3145 2842 2843 1.616 0.8 12.928 37
I2843 2843 0 1.33579e-05
R3146 2843 2844 1.648 0.8 13.184 37
I2844 2844 0 1.29868e-05
R3147 2844 2845 1.744 0.8 13.952 37
I2845 2845 0 1.33579e-05
R3148 2845 2846 1.696 0.8 13.568 37
I2846 2846 0 1.28631e-05
R3149 2846 2847 1.68 0.8 13.44 37
I2847 2847 0 1.27395e-05
R3150 2847 2848 1.6 0.8 12.8 37
I2848 2848 0 1.27395e-05
R3151 2848 2849 1.632 0.8 13.056 37
I2849 2849 0 1.24921e-05
R3152 2849 2850 1.648 0.8 13.184 37
I2850 2850 0 1.27395e-05
R3153 2850 2851 1.744 0.8 13.952 37
I2851 2851 0 1.24921e-05
R3154 2851 2852 1.696 0.8 13.568 37
I2852 2852 0 1.34816e-05
R3155 2852 2853 1.712 0.8 13.696 37
I2853 2853 0 1.29868e-05
R3156 2853 2854 1.728 0.8 13.824 37
I2854 2854 0 1.26158e-05
R3157 2854 2855 1.728 0.8 13.824 37
I2855 2855 0 1.33579e-05
R3158 2855 2856 1.648 0.8 13.184 37
I2856 2856 0 1.23684e-05
R3159 2856 2857 1.712 0.8 13.696 37
I2857 2857 0 1.27395e-05
R3160 2857 2858 1.728 0.8 13.824 37
I2858 2858 0 1.23684e-05
R3161 2858 2859 1.648 0.8 13.184 37
I2859 2859 0 1.27395e-05
R3162 2859 2860 1.696 0.8 13.568 37
I2860 2860 0 1.26158e-05
R3163 2860 2861 1.616 0.8 12.928 37
I2861 2861 0 1.28631e-05
R3164 2861 2862 1.728 0.8 13.824 37
I2862 2862 0 1.34816e-05
R3165 2862 2863 1.712 0.8 13.696 37
I2863 2863 0 1.34816e-05
R3166 2863 2864 1.632 0.8 13.056 37
I2864 2864 0 1.34816e-05
R3167 2864 2865 1.632 0.8 13.056 37
I2865 2865 0 1.32342e-05
R3168 2865 2866 1.664 0.8 13.312 37
I2866 2866 0 1.24921e-05
R3169 2866 2867 1.744 0.8 13.952 37
I2867 2867 0 1.24921e-05
R3170 2867 2868 1.632 0.8 13.056 37
I2868 2868 0 1.31105e-05
R3171 2868 2869 1.728 0.8 13.824 37
I2869 2869 0 1.26158e-05
R3172 2869 2870 1.616 0.8 12.928 37
I2870 2870 0 1.33579e-05
R3173 2870 2871 1.632 0.8 13.056 37
I2871 2871 0 1.28631e-05
R3174 2871 2872 1.6 0.8 12.8 37
I2872 2872 0 1.34816e-05
R3175 2872 2873 1.6 0.8 12.8 37
I2873 2873 0 1.33579e-05
R3176 2873 2874 1.632 0.8 13.056 37
I2874 2874 0 1.29868e-05
R3177 2874 2875 1.648 0.8 13.184 37
I2875 2875 0 1.23684e-05
R3178 2875 2876 1.728 0.8 13.824 37
I2876 2876 0 1.29868e-05
R3179 2876 2877 1.664 0.8 13.312 37
I2877 2877 0 1.33579e-05
R3180 2877 2878 1.696 0.8 13.568 37
I2878 2878 0 1.26158e-05
R3181 2878 2879 1.744 0.8 13.952 37
I2879 2879 0 1.23684e-05
R3182 2879 2880 1.648 0.8 13.184 37
I2880 2880 0 1.24921e-05
R3183 2880 2881 1.712 0.8 13.696 37
I2881 2881 0 1.23684e-05
R3184 2881 2882 1.664 0.8 13.312 37
I2882 2882 0 1.31105e-05
R3185 2882 2883 1.648 0.8 13.184 37
I2883 2883 0 1.33579e-05
R3186 2883 2884 1.648 0.8 13.184 37
I2884 2884 0 1.24921e-05
R3187 2884 2885 1.616 0.8 12.928 37
I2885 2885 0 1.31105e-05
R3188 2885 2886 1.616 0.8 12.928 37
I2886 2886 0 1.27395e-05
R3189 2886 2887 1.632 0.8 13.056 37
I2887 2887 0 1.24921e-05
R3190 2887 2888 1.68 0.8 13.44 37
I2888 2888 0 1.28631e-05
R3191 2888 2889 1.616 0.8 12.928 37
I2889 2889 0 1.32342e-05
R3192 2889 2890 1.6 0.8 12.8 37
I2890 2890 0 1.28631e-05
R3193 2890 2891 1.712 0.8 13.696 37
I2891 2891 0 1.23684e-05
R3194 2891 2892 1.616 0.8 12.928 37
I2892 2892 0 1.27395e-05
R3195 2892 2893 1.728 0.8 13.824 37
I2893 2893 0 1.34816e-05
R3196 2893 2894 1.68 0.8 13.44 37
I2894 2894 0 1.33579e-05
R3197 2894 2895 1.744 0.8 13.952 37
I2895 2895 0 1.24921e-05
R3198 2895 2896 1.744 0.8 13.952 37
I2896 2896 0 1.32342e-05
R3199 2896 2897 1.648 0.8 13.184 37
I2897 2897 0 1.31105e-05
R3200 2897 2898 1.68 0.8 13.44 37
I2898 2898 0 1.31105e-05
R3201 2898 2899 1.664 0.8 13.312 37
I2899 2899 0 1.23684e-05
R3202 2899 2900 1.712 0.8 13.696 37
I2900 2900 0 1.29868e-05
R3203 2900 2901 1.696 0.8 13.568 37
I2901 2901 0 1.23684e-05
R3204 2901 2902 1.744 0.8 13.952 37
I2902 2902 0 1.34816e-05
R3205 2902 2903 1.648 0.8 13.184 37
I2903 2903 0 1.31105e-05
R3206 2903 2904 1.648 0.8 13.184 37
I2904 2904 0 1.31105e-05
R3207 2904 2905 1.648 0.8 13.184 37
I2905 2905 0 1.27395e-05
R3208 2905 2906 1.632 0.8 13.056 37
I2906 2906 0 1.26158e-05
R3209 2906 2907 1.648 0.8 13.184 37
I2907 2907 0 1.28631e-05
R3210 2907 2908 1.68 0.8 13.44 37
I2908 2908 0 1.28631e-05
R3211 2908 2909 1.648 0.8 13.184 37
I2909 2909 0 1.27395e-05
R3212 2909 2910 1.664 0.8 13.312 37
I2910 2910 0 1.29868e-05
R3213 2910 2911 1.696 0.8 13.568 37
I2911 2911 0 1.29868e-05
R3214 2911 2912 1.664 0.8 13.312 37
I2912 2912 0 1.34816e-05
R3215 2912 2913 1.616 0.8 12.928 37
I2913 2913 0 1.34816e-05
R3216 2913 2914 1.68 0.8 13.44 37
I2914 2914 0 1.31105e-05
R3217 2914 2915 1.6 0.8 12.8 37
I2915 2915 0 1.28631e-05
R3218 2915 2916 1.616 0.8 12.928 37
I2916 2916 0 1.33579e-05
R3219 2916 2917 1.664 0.8 13.312 37
I2917 2917 0 1.26158e-05
R3220 2917 2918 1.744 0.8 13.952 37
I2918 2918 0 1.34816e-05
R3221 2918 2919 1.728 0.8 13.824 37
I2919 2919 0 1.27395e-05
R3222 2919 2920 1.68 0.8 13.44 37
I2920 2920 0 1.27395e-05
R3223 2920 2921 1.728 0.8 13.824 37
I2921 2921 0 1.32342e-05
R3224 2921 2922 1.68 0.8 13.44 37
I2922 2922 0 1.28631e-05
R3225 2922 2923 1.648 0.8 13.184 37
I2923 2923 0 1.27395e-05
R3226 2923 2924 1.6 0.8 12.8 37
I2924 2924 0 1.32342e-05
R3227 2924 2925 1.728 0.8 13.824 37
I2925 2925 0 1.28631e-05
R3228 2925 2926 1.664 0.8 13.312 37
I2926 2926 0 1.28631e-05
R3229 2926 2927 1.744 0.8 13.952 37
I2927 2927 0 1.33579e-05
R3230 2927 2928 1.68 0.8 13.44 37
I2928 2928 0 1.24921e-05
R3231 2928 2929 1.712 0.8 13.696 37
I2929 2929 0 1.26158e-05
R3232 2929 2930 1.712 0.8 13.696 37
I2930 2930 0 1.34816e-05
R3233 2930 2931 1.696 0.8 13.568 37
I2931 2931 0 1.23684e-05
R3234 2931 2932 1.728 0.8 13.824 37
I2932 2932 0 1.26158e-05
R3235 2932 2933 1.648 0.8 13.184 37
I2933 2933 0 1.34816e-05
R3236 2933 2934 1.616 0.8 12.928 37
I2934 2934 0 1.24921e-05
R3237 2934 2935 1.632 0.8 13.056 37
I2935 2935 0 1.33579e-05
R3238 2935 2936 1.68 0.8 13.44 37
I2936 2936 0 1.27395e-05
R3239 2936 2937 1.68 0.8 13.44 37
I2937 2937 0 1.26158e-05
R3240 2937 2938 1.744 0.8 13.952 37
I2938 2938 0 1.34816e-05
R3241 2938 2939 1.712 0.8 13.696 37
I2939 2939 0 1.34816e-05
R3242 2939 2940 1.728 0.8 13.824 37
I2940 2940 0 1.29868e-05
R3243 2940 2941 1.68 0.8 13.44 37
I2941 2941 0 1.26158e-05
R3244 2941 2942 1.616 0.8 12.928 37
I2942 2942 0 1.28631e-05
R3245 2942 2943 1.632 0.8 13.056 37
I2943 2943 0 1.31105e-05
R3246 2943 2944 1.712 0.8 13.696 37
I2944 2944 0 1.34816e-05
R3247 2944 2945 1.728 0.8 13.824 37
I2945 2945 0 1.31105e-05
R3248 2945 2946 1.616 0.8 12.928 37
I2946 2946 0 1.31105e-05
R3249 2946 2947 1.712 0.8 13.696 37
I2947 2947 0 1.24921e-05
R3250 2947 2948 1.6 0.8 12.8 37
I2948 2948 0 1.23684e-05
R3251 2948 2949 1.6 0.8 12.8 37
I2949 2949 0 1.27395e-05
R3252 2949 2950 1.648 0.8 13.184 37
I2950 2950 0 1.29868e-05
R3253 2950 2951 1.616 0.8 12.928 37
I2951 2951 0 1.23684e-05
R3254 2951 2952 1.6 0.8 12.8 37
I2952 2952 0 1.34816e-05
R3255 2952 2953 1.68 0.8 13.44 37
I2953 2953 0 1.34816e-05
R3256 2953 2954 1.728 0.8 13.824 37
I2954 2954 0 1.26158e-05
R3257 2954 2955 1.6 0.8 12.8 37
I2955 2955 0 1.33579e-05
R3258 2955 2956 1.6 0.8 12.8 37
I2956 2956 0 1.29868e-05
R3259 2956 2957 1.6 0.8 12.8 37
I2957 2957 0 1.24921e-05
R3260 2957 2958 1.616 0.8 12.928 37
I2958 2958 0 1.26158e-05
R3261 2958 2959 1.728 0.8 13.824 37
I2959 2959 0 1.24921e-05
R3262 2959 2960 1.648 0.8 13.184 37
I2960 2960 0 1.33579e-05
R3263 2960 2961 1.712 0.8 13.696 37
I2961 2961 0 1.31105e-05
R3264 2961 2962 1.712 0.8 13.696 37
I2962 2962 0 1.28631e-05
R3265 2962 2963 1.712 0.8 13.696 37
I2963 2963 0 1.32342e-05
R3266 2963 2964 1.696 0.8 13.568 37
I2964 2964 0 1.23684e-05
R3267 2964 2965 1.616 0.8 12.928 37
I2965 2965 0 1.26158e-05
R3268 2965 2966 1.68 0.8 13.44 37
I2966 2966 0 1.28631e-05
R3269 2966 2967 1.632 0.8 13.056 37
I2967 2967 0 1.29868e-05
R3270 2967 2968 1.648 0.8 13.184 37
I2968 2968 0 1.34816e-05
R3271 2968 2969 1.696 0.8 13.568 37
I2969 2969 0 1.27395e-05
R3272 2969 2970 1.632 0.8 13.056 37
I2970 2970 0 1.33579e-05
R3273 2970 2971 1.616 0.8 12.928 37
I2971 2971 0 1.26158e-05
R3274 2971 2972 1.68 0.8 13.44 37
I2972 2972 0 1.27395e-05
R3275 2972 2973 1.68 0.8 13.44 37
I2973 2973 0 1.33579e-05
R3276 2973 2974 1.712 0.8 13.696 37
I2974 2974 0 1.27395e-05
R3277 2974 2975 1.744 0.8 13.952 37
I2975 2975 0 1.24921e-05
R3278 2975 2976 1.664 0.8 13.312 37
I2976 2976 0 1.32342e-05
R3279 2976 2977 1.712 0.8 13.696 37
I2977 2977 0 1.24921e-05
R3280 2977 2978 1.648 0.8 13.184 37
I2978 2978 0 1.32342e-05
R3281 2978 2979 1.6 0.8 12.8 37
I2979 2979 0 1.23684e-05
R3282 2979 2980 1.712 0.8 13.696 37
I2980 2980 0 1.27395e-05
R3283 2980 2981 1.632 0.8 13.056 37
I2981 2981 0 1.28631e-05
R3284 2981 2982 1.6 0.8 12.8 37
I2982 2982 0 1.31105e-05
R3285 2982 2983 1.616 0.8 12.928 37
I2983 2983 0 1.27395e-05
R3286 2983 2984 1.696 0.8 13.568 37
I2984 2984 0 1.32342e-05
R3287 2984 2985 1.712 0.8 13.696 37
I2985 2985 0 1.23684e-05
R3288 2985 2986 1.68 0.8 13.44 37
I2986 2986 0 1.23684e-05
R3289 2986 2987 1.664 0.8 13.312 37
I2987 2987 0 1.26158e-05
R3290 2987 2988 1.664 0.8 13.312 37
I2988 2988 0 1.34816e-05
R3291 2988 2989 1.6 0.8 12.8 37
I2989 2989 0 1.24921e-05
R3292 2989 2990 1.68 0.8 13.44 37
I2990 2990 0 1.23684e-05
R3293 2990 2991 1.664 0.8 13.312 37
I2991 2991 0 1.24921e-05
R3294 2991 2992 1.744 0.8 13.952 37
I2992 2992 0 1.28631e-05
R3295 2992 2993 1.664 0.8 13.312 37
I2993 2993 0 1.26158e-05
R3296 2993 2994 1.616 0.8 12.928 37
I2994 2994 0 1.28631e-05
R3297 2994 2995 1.632 0.8 13.056 37
I2995 2995 0 1.23684e-05
R3298 2995 2996 1.6 0.8 12.8 37
I2996 2996 0 1.31105e-05
R3299 2996 2997 1.664 0.8 13.312 37
I2997 2997 0 1.23684e-05
R3300 2997 2998 1.68 0.8 13.44 37
I2998 2998 0 1.29868e-05
R3301 2998 2999 1.68 0.8 13.44 37
I2999 2999 0 1.27395e-05
R3302 2999 3000 1.664 0.8 13.312 37
I3000 3000 0 1.23684e-05
R3303 3000 10001 0.5 10 50 37
*seg: 4
* inter-segment connection
R3304 3010 4010 6.16 0.8 49.28 37
R3305 3020 4020 6.16 0.8 49.28 37
R3306 3030 4030 6.16 0.8 49.28 37
R3307 3040 4040 6.16 0.8 49.28 37
R3308 3050 4050 6.16 0.8 49.28 37
R3309 3060 4060 6.16 0.8 49.28 37
R3310 3070 4070 6.16 0.8 49.28 37
R3311 3080 4080 6.16 0.8 49.28 37
R3312 3090 4090 6.16 0.8 49.28 37
R3313 3100 4100 6.16 0.8 49.28 37
R3314 3110 4110 6.16 0.8 49.28 37
R3315 3120 4120 6.16 0.8 49.28 37
R3316 3130 4130 6.16 0.8 49.28 37
R3317 3140 4140 6.16 0.8 49.28 37
R3318 3150 4150 6.16 0.8 49.28 37
R3319 3160 4160 6.16 0.8 49.28 37
R3320 3170 4170 6.16 0.8 49.28 37
R3321 3180 4180 6.16 0.8 49.28 37
R3322 3190 4190 6.16 0.8 49.28 37
R3323 3200 4200 6.16 0.8 49.28 37
R3324 3210 4210 6.16 0.8 49.28 37
R3325 3220 4220 6.16 0.8 49.28 37
R3326 3230 4230 6.16 0.8 49.28 37
R3327 3240 4240 6.16 0.8 49.28 37
R3328 3250 4250 6.16 0.8 49.28 37
R3329 3260 4260 6.16 0.8 49.28 37
R3330 3270 4270 6.16 0.8 49.28 37
R3331 3280 4280 6.16 0.8 49.28 37
R3332 3290 4290 6.16 0.8 49.28 37
R3333 3300 4300 6.16 0.8 49.28 37
R3334 3310 4310 6.16 0.8 49.28 37
R3335 3320 4320 6.16 0.8 49.28 37
R3336 3330 4330 6.16 0.8 49.28 37
R3337 3340 4340 6.16 0.8 49.28 37
R3338 3350 4350 6.16 0.8 49.28 37
R3339 3360 4360 6.16 0.8 49.28 37
R3340 3370 4370 6.16 0.8 49.28 37
R3341 3380 4380 6.16 0.8 49.28 37
R3342 3390 4390 6.16 0.8 49.28 37
R3343 3400 4400 6.16 0.8 49.28 37
R3344 3410 4410 6.16 0.8 49.28 37
R3345 3420 4420 6.16 0.8 49.28 37
R3346 3430 4430 6.16 0.8 49.28 37
R3347 3440 4440 6.16 0.8 49.28 37
R3348 3450 4450 6.16 0.8 49.28 37
R3349 3460 4460 6.16 0.8 49.28 37
R3350 3470 4470 6.16 0.8 49.28 37
R3351 3480 4480 6.16 0.8 49.28 37
R3352 3490 4490 6.16 0.8 49.28 37
R3353 3500 4500 6.16 0.8 49.28 37
R3354 3510 4510 6.16 0.8 49.28 37
R3355 3520 4520 6.16 0.8 49.28 37
R3356 3530 4530 6.16 0.8 49.28 37
R3357 3540 4540 6.16 0.8 49.28 37
R3358 3550 4550 6.16 0.8 49.28 37
R3359 3560 4560 6.16 0.8 49.28 37
R3360 3570 4570 6.16 0.8 49.28 37
R3361 3580 4580 6.16 0.8 49.28 37
R3362 3590 4590 6.16 0.8 49.28 37
R3363 3600 4600 6.16 0.8 49.28 37
R3364 3610 4610 6.16 0.8 49.28 37
R3365 3620 4620 6.16 0.8 49.28 37
R3366 3630 4630 6.16 0.8 49.28 37
R3367 3640 4640 6.16 0.8 49.28 37
R3368 3650 4650 6.16 0.8 49.28 37
R3369 3660 4660 6.16 0.8 49.28 37
R3370 3670 4670 6.16 0.8 49.28 37
R3371 3680 4680 6.16 0.8 49.28 37
R3372 3690 4690 6.16 0.8 49.28 37
R3373 3700 4700 6.16 0.8 49.28 37
R3374 3710 4710 6.16 0.8 49.28 37
R3375 3720 4720 6.16 0.8 49.28 37
R3376 3730 4730 6.16 0.8 49.28 37
R3377 3740 4740 6.16 0.8 49.28 37
R3378 3750 4750 6.16 0.8 49.28 37
R3379 3760 4760 6.16 0.8 49.28 37
R3380 3770 4770 6.16 0.8 49.28 37
R3381 3780 4780 6.16 0.8 49.28 37
R3382 3790 4790 6.16 0.8 49.28 37
R3383 3800 4800 6.16 0.8 49.28 37
R3384 3810 4810 6.16 0.8 49.28 37
R3385 3820 4820 6.16 0.8 49.28 37
R3386 3830 4830 6.16 0.8 49.28 37
R3387 3840 4840 6.16 0.8 49.28 37
R3388 3850 4850 6.16 0.8 49.28 37
R3389 3860 4860 6.16 0.8 49.28 37
R3390 3870 4870 6.16 0.8 49.28 37
R3391 3880 4880 6.16 0.8 49.28 37
R3392 3890 4890 6.16 0.8 49.28 37
R3393 3900 4900 6.16 0.8 49.28 37
R3394 3910 4910 6.16 0.8 49.28 37
R3395 3920 4920 6.16 0.8 49.28 37
R3396 3930 4930 6.16 0.8 49.28 37
R3397 3940 4940 6.16 0.8 49.28 37
R3398 3950 4950 6.16 0.8 49.28 37
R3399 3960 4960 6.16 0.8 49.28 37
R3400 3970 4970 6.16 0.8 49.28 37
R3401 3980 4980 6.16 0.8 49.28 37
R3402 3990 4990 6.16 0.8 49.28 37
R3403 4000 5000 6.16 0.8 49.28 37
R3404 10001 3001 0.4 20 80 37
I3001 3001 0 1.26158e-05
R3405 3001 3002 1.648 0.8 13.184 37
I3002 3002 0 1.24921e-05
R3406 3002 3003 1.68 0.8 13.44 37
I3003 3003 0 1.32342e-05
R3407 3003 3004 1.648 0.8 13.184 37
I3004 3004 0 1.34816e-05
R3408 3004 3005 1.728 0.8 13.824 37
I3005 3005 0 1.27395e-05
R3409 3005 3006 1.6 0.8 12.8 37
I3006 3006 0 1.27395e-05
R3410 3006 3007 1.68 0.8 13.44 37
I3007 3007 0 1.32342e-05
R3411 3007 3008 1.696 0.8 13.568 37
I3008 3008 0 1.28631e-05
R3412 3008 3009 1.616 0.8 12.928 37
I3009 3009 0 1.23684e-05
R3413 3009 3010 1.712 0.8 13.696 37
I3010 3010 0 1.26158e-05
R3414 3010 3011 1.68 0.8 13.44 37
I3011 3011 0 1.24921e-05
R3415 3011 3012 1.632 0.8 13.056 37
I3012 3012 0 1.32342e-05
R3416 3012 3013 1.6 0.8 12.8 37
I3013 3013 0 1.33579e-05
R3417 3013 3014 1.712 0.8 13.696 37
I3014 3014 0 1.29868e-05
R3418 3014 3015 1.648 0.8 13.184 37
I3015 3015 0 1.26158e-05
R3419 3015 3016 1.728 0.8 13.824 37
I3016 3016 0 1.34816e-05
R3420 3016 3017 1.712 0.8 13.696 37
I3017 3017 0 1.27395e-05
R3421 3017 3018 1.6 0.8 12.8 37
I3018 3018 0 1.26158e-05
R3422 3018 3019 1.632 0.8 13.056 37
I3019 3019 0 1.29868e-05
R3423 3019 3020 1.648 0.8 13.184 37
I3020 3020 0 1.23684e-05
R3424 3020 3021 1.728 0.8 13.824 37
I3021 3021 0 1.29868e-05
R3425 3021 3022 1.696 0.8 13.568 37
I3022 3022 0 1.31105e-05
R3426 3022 3023 1.632 0.8 13.056 37
I3023 3023 0 1.26158e-05
R3427 3023 3024 1.6 0.8 12.8 37
I3024 3024 0 1.27395e-05
R3428 3024 3025 1.648 0.8 13.184 37
I3025 3025 0 1.32342e-05
R3429 3025 3026 1.712 0.8 13.696 37
I3026 3026 0 1.23684e-05
R3430 3026 3027 1.616 0.8 12.928 37
I3027 3027 0 1.24921e-05
R3431 3027 3028 1.712 0.8 13.696 37
I3028 3028 0 1.24921e-05
R3432 3028 3029 1.744 0.8 13.952 37
I3029 3029 0 1.31105e-05
R3433 3029 3030 1.696 0.8 13.568 37
I3030 3030 0 1.28631e-05
R3434 3030 3031 1.6 0.8 12.8 37
I3031 3031 0 1.31105e-05
R3435 3031 3032 1.648 0.8 13.184 37
I3032 3032 0 1.34816e-05
R3436 3032 3033 1.744 0.8 13.952 37
I3033 3033 0 1.29868e-05
R3437 3033 3034 1.648 0.8 13.184 37
I3034 3034 0 1.24921e-05
R3438 3034 3035 1.6 0.8 12.8 37
I3035 3035 0 1.31105e-05
R3439 3035 3036 1.616 0.8 12.928 37
I3036 3036 0 1.24921e-05
R3440 3036 3037 1.664 0.8 13.312 37
I3037 3037 0 1.34816e-05
R3441 3037 3038 1.712 0.8 13.696 37
I3038 3038 0 1.31105e-05
R3442 3038 3039 1.632 0.8 13.056 37
I3039 3039 0 1.32342e-05
R3443 3039 3040 1.632 0.8 13.056 37
I3040 3040 0 1.32342e-05
R3444 3040 3041 1.712 0.8 13.696 37
I3041 3041 0 1.34816e-05
R3445 3041 3042 1.744 0.8 13.952 37
I3042 3042 0 1.33579e-05
R3446 3042 3043 1.616 0.8 12.928 37
I3043 3043 0 1.31105e-05
R3447 3043 3044 1.744 0.8 13.952 37
I3044 3044 0 1.23684e-05
R3448 3044 3045 1.664 0.8 13.312 37
I3045 3045 0 1.32342e-05
R3449 3045 3046 1.712 0.8 13.696 37
I3046 3046 0 1.28631e-05
R3450 3046 3047 1.648 0.8 13.184 37
I3047 3047 0 1.23684e-05
R3451 3047 3048 1.664 0.8 13.312 37
I3048 3048 0 1.26158e-05
R3452 3048 3049 1.728 0.8 13.824 37
I3049 3049 0 1.32342e-05
R3453 3049 3050 1.648 0.8 13.184 37
I3050 3050 0 1.33579e-05
R3454 3050 3051 1.696 0.8 13.568 37
I3051 3051 0 1.31105e-05
R3455 3051 3052 1.616 0.8 12.928 37
I3052 3052 0 1.23684e-05
R3456 3052 3053 1.696 0.8 13.568 37
I3053 3053 0 1.33579e-05
R3457 3053 3054 1.696 0.8 13.568 37
I3054 3054 0 1.23684e-05
R3458 3054 3055 1.728 0.8 13.824 37
I3055 3055 0 1.33579e-05
R3459 3055 3056 1.712 0.8 13.696 37
I3056 3056 0 1.29868e-05
R3460 3056 3057 1.6 0.8 12.8 37
I3057 3057 0 1.33579e-05
R3461 3057 3058 1.648 0.8 13.184 37
I3058 3058 0 1.24921e-05
R3462 3058 3059 1.696 0.8 13.568 37
I3059 3059 0 1.28631e-05
R3463 3059 3060 1.648 0.8 13.184 37
I3060 3060 0 1.23684e-05
R3464 3060 3061 1.616 0.8 12.928 37
I3061 3061 0 1.23684e-05
R3465 3061 3062 1.696 0.8 13.568 37
I3062 3062 0 1.28631e-05
R3466 3062 3063 1.648 0.8 13.184 37
I3063 3063 0 1.23684e-05
R3467 3063 3064 1.728 0.8 13.824 37
I3064 3064 0 1.24921e-05
R3468 3064 3065 1.6 0.8 12.8 37
I3065 3065 0 1.24921e-05
R3469 3065 3066 1.616 0.8 12.928 37
I3066 3066 0 1.33579e-05
R3470 3066 3067 1.744 0.8 13.952 37
I3067 3067 0 1.27395e-05
R3471 3067 3068 1.728 0.8 13.824 37
I3068 3068 0 1.29868e-05
R3472 3068 3069 1.616 0.8 12.928 37
I3069 3069 0 1.31105e-05
R3473 3069 3070 1.712 0.8 13.696 37
I3070 3070 0 1.34816e-05
R3474 3070 3071 1.712 0.8 13.696 37
I3071 3071 0 1.31105e-05
R3475 3071 3072 1.696 0.8 13.568 37
I3072 3072 0 1.32342e-05
R3476 3072 3073 1.664 0.8 13.312 37
I3073 3073 0 1.24921e-05
R3477 3073 3074 1.6 0.8 12.8 37
I3074 3074 0 1.23684e-05
R3478 3074 3075 1.68 0.8 13.44 37
I3075 3075 0 1.27395e-05
R3479 3075 3076 1.6 0.8 12.8 37
I3076 3076 0 1.33579e-05
R3480 3076 3077 1.664 0.8 13.312 37
I3077 3077 0 1.34816e-05
R3481 3077 3078 1.664 0.8 13.312 37
I3078 3078 0 1.34816e-05
R3482 3078 3079 1.616 0.8 12.928 37
I3079 3079 0 1.26158e-05
R3483 3079 3080 1.6 0.8 12.8 37
I3080 3080 0 1.24921e-05
R3484 3080 3081 1.68 0.8 13.44 37
I3081 3081 0 1.27395e-05
R3485 3081 3082 1.744 0.8 13.952 37
I3082 3082 0 1.29868e-05
R3486 3082 3083 1.696 0.8 13.568 37
I3083 3083 0 1.34816e-05
R3487 3083 3084 1.632 0.8 13.056 37
I3084 3084 0 1.23684e-05
R3488 3084 3085 1.696 0.8 13.568 37
I3085 3085 0 1.26158e-05
R3489 3085 3086 1.616 0.8 12.928 37
I3086 3086 0 1.27395e-05
R3490 3086 3087 1.728 0.8 13.824 37
I3087 3087 0 1.33579e-05
R3491 3087 3088 1.632 0.8 13.056 37
I3088 3088 0 1.27395e-05
R3492 3088 3089 1.616 0.8 12.928 37
I3089 3089 0 1.26158e-05
R3493 3089 3090 1.68 0.8 13.44 37
I3090 3090 0 1.32342e-05
R3494 3090 3091 1.68 0.8 13.44 37
I3091 3091 0 1.33579e-05
R3495 3091 3092 1.712 0.8 13.696 37
I3092 3092 0 1.24921e-05
R3496 3092 3093 1.712 0.8 13.696 37
I3093 3093 0 1.28631e-05
R3497 3093 3094 1.6 0.8 12.8 37
I3094 3094 0 1.33579e-05
R3498 3094 3095 1.696 0.8 13.568 37
I3095 3095 0 1.26158e-05
R3499 3095 3096 1.632 0.8 13.056 37
I3096 3096 0 1.28631e-05
R3500 3096 3097 1.696 0.8 13.568 37
I3097 3097 0 1.27395e-05
R3501 3097 3098 1.616 0.8 12.928 37
I3098 3098 0 1.28631e-05
R3502 3098 3099 1.648 0.8 13.184 37
I3099 3099 0 1.29868e-05
R3503 3099 3100 1.664 0.8 13.312 37
I3100 3100 0 1.34816e-05
R3504 3100 3101 1.712 0.8 13.696 37
I3101 3101 0 1.31105e-05
R3505 3101 3102 1.664 0.8 13.312 37
I3102 3102 0 1.31105e-05
R3506 3102 3103 1.696 0.8 13.568 37
I3103 3103 0 1.31105e-05
R3507 3103 3104 1.616 0.8 12.928 37
I3104 3104 0 1.34816e-05
R3508 3104 3105 1.728 0.8 13.824 37
I3105 3105 0 1.31105e-05
R3509 3105 3106 1.728 0.8 13.824 37
I3106 3106 0 1.27395e-05
R3510 3106 3107 1.696 0.8 13.568 37
I3107 3107 0 1.31105e-05
R3511 3107 3108 1.712 0.8 13.696 37
I3108 3108 0 1.27395e-05
R3512 3108 3109 1.6 0.8 12.8 37
I3109 3109 0 1.32342e-05
R3513 3109 3110 1.664 0.8 13.312 37
I3110 3110 0 1.33579e-05
R3514 3110 3111 1.632 0.8 13.056 37
I3111 3111 0 1.31105e-05
R3515 3111 3112 1.632 0.8 13.056 37
I3112 3112 0 1.33579e-05
R3516 3112 3113 1.744 0.8 13.952 37
I3113 3113 0 1.29868e-05
R3517 3113 3114 1.632 0.8 13.056 37
I3114 3114 0 1.26158e-05
R3518 3114 3115 1.616 0.8 12.928 37
I3115 3115 0 1.34816e-05
R3519 3115 3116 1.648 0.8 13.184 37
I3116 3116 0 1.33579e-05
R3520 3116 3117 1.712 0.8 13.696 37
I3117 3117 0 1.32342e-05
R3521 3117 3118 1.696 0.8 13.568 37
I3118 3118 0 1.29868e-05
R3522 3118 3119 1.68 0.8 13.44 37
I3119 3119 0 1.32342e-05
R3523 3119 3120 1.664 0.8 13.312 37
I3120 3120 0 1.27395e-05
R3524 3120 3121 1.696 0.8 13.568 37
I3121 3121 0 1.27395e-05
R3525 3121 3122 1.744 0.8 13.952 37
I3122 3122 0 1.26158e-05
R3526 3122 3123 1.744 0.8 13.952 37
I3123 3123 0 1.31105e-05
R3527 3123 3124 1.728 0.8 13.824 37
I3124 3124 0 1.24921e-05
R3528 3124 3125 1.68 0.8 13.44 37
I3125 3125 0 1.26158e-05
R3529 3125 3126 1.744 0.8 13.952 37
I3126 3126 0 1.34816e-05
R3530 3126 3127 1.6 0.8 12.8 37
I3127 3127 0 1.28631e-05
R3531 3127 3128 1.712 0.8 13.696 37
I3128 3128 0 1.34816e-05
R3532 3128 3129 1.744 0.8 13.952 37
I3129 3129 0 1.26158e-05
R3533 3129 3130 1.664 0.8 13.312 37
I3130 3130 0 1.23684e-05
R3534 3130 3131 1.616 0.8 12.928 37
I3131 3131 0 1.34816e-05
R3535 3131 3132 1.616 0.8 12.928 37
I3132 3132 0 1.23684e-05
R3536 3132 3133 1.744 0.8 13.952 37
I3133 3133 0 1.32342e-05
R3537 3133 3134 1.68 0.8 13.44 37
I3134 3134 0 1.28631e-05
R3538 3134 3135 1.712 0.8 13.696 37
I3135 3135 0 1.34816e-05
R3539 3135 3136 1.6 0.8 12.8 37
I3136 3136 0 1.29868e-05
R3540 3136 3137 1.632 0.8 13.056 37
I3137 3137 0 1.34816e-05
R3541 3137 3138 1.744 0.8 13.952 37
I3138 3138 0 1.27395e-05
R3542 3138 3139 1.712 0.8 13.696 37
I3139 3139 0 1.32342e-05
R3543 3139 3140 1.664 0.8 13.312 37
I3140 3140 0 1.28631e-05
R3544 3140 3141 1.616 0.8 12.928 37
I3141 3141 0 1.31105e-05
R3545 3141 3142 1.664 0.8 13.312 37
I3142 3142 0 1.24921e-05
R3546 3142 3143 1.6 0.8 12.8 37
I3143 3143 0 1.27395e-05
R3547 3143 3144 1.648 0.8 13.184 37
I3144 3144 0 1.24921e-05
R3548 3144 3145 1.68 0.8 13.44 37
I3145 3145 0 1.32342e-05
R3549 3145 3146 1.664 0.8 13.312 37
I3146 3146 0 1.33579e-05
R3550 3146 3147 1.696 0.8 13.568 37
I3147 3147 0 1.29868e-05
R3551 3147 3148 1.728 0.8 13.824 37
I3148 3148 0 1.29868e-05
R3552 3148 3149 1.664 0.8 13.312 37
I3149 3149 0 1.27395e-05
R3553 3149 3150 1.632 0.8 13.056 37
I3150 3150 0 1.24921e-05
R3554 3150 3151 1.68 0.8 13.44 37
I3151 3151 0 1.26158e-05
R3555 3151 3152 1.696 0.8 13.568 37
I3152 3152 0 1.32342e-05
R3556 3152 3153 1.616 0.8 12.928 37
I3153 3153 0 1.33579e-05
R3557 3153 3154 1.648 0.8 13.184 37
I3154 3154 0 1.23684e-05
R3558 3154 3155 1.68 0.8 13.44 37
I3155 3155 0 1.32342e-05
R3559 3155 3156 1.696 0.8 13.568 37
I3156 3156 0 1.34816e-05
R3560 3156 3157 1.68 0.8 13.44 37
I3157 3157 0 1.23684e-05
R3561 3157 3158 1.6 0.8 12.8 37
I3158 3158 0 1.29868e-05
R3562 3158 3159 1.696 0.8 13.568 37
I3159 3159 0 1.27395e-05
R3563 3159 3160 1.712 0.8 13.696 37
I3160 3160 0 1.27395e-05
R3564 3160 3161 1.632 0.8 13.056 37
I3161 3161 0 1.24921e-05
R3565 3161 3162 1.632 0.8 13.056 37
I3162 3162 0 1.34816e-05
R3566 3162 3163 1.728 0.8 13.824 37
I3163 3163 0 1.26158e-05
R3567 3163 3164 1.696 0.8 13.568 37
I3164 3164 0 1.26158e-05
R3568 3164 3165 1.728 0.8 13.824 37
I3165 3165 0 1.33579e-05
R3569 3165 3166 1.664 0.8 13.312 37
I3166 3166 0 1.27395e-05
R3570 3166 3167 1.6 0.8 12.8 37
I3167 3167 0 1.26158e-05
R3571 3167 3168 1.632 0.8 13.056 37
I3168 3168 0 1.27395e-05
R3572 3168 3169 1.632 0.8 13.056 37
I3169 3169 0 1.29868e-05
R3573 3169 3170 1.68 0.8 13.44 37
I3170 3170 0 1.33579e-05
R3574 3170 3171 1.68 0.8 13.44 37
I3171 3171 0 1.28631e-05
R3575 3171 3172 1.712 0.8 13.696 37
I3172 3172 0 1.23684e-05
R3576 3172 3173 1.696 0.8 13.568 37
I3173 3173 0 1.34816e-05
R3577 3173 3174 1.696 0.8 13.568 37
I3174 3174 0 1.26158e-05
R3578 3174 3175 1.68 0.8 13.44 37
I3175 3175 0 1.29868e-05
R3579 3175 3176 1.696 0.8 13.568 37
I3176 3176 0 1.32342e-05
R3580 3176 3177 1.728 0.8 13.824 37
I3177 3177 0 1.23684e-05
R3581 3177 3178 1.696 0.8 13.568 37
I3178 3178 0 1.31105e-05
R3582 3178 3179 1.632 0.8 13.056 37
I3179 3179 0 1.29868e-05
R3583 3179 3180 1.6 0.8 12.8 37
I3180 3180 0 1.23684e-05
R3584 3180 3181 1.68 0.8 13.44 37
I3181 3181 0 1.31105e-05
R3585 3181 3182 1.648 0.8 13.184 37
I3182 3182 0 1.33579e-05
R3586 3182 3183 1.616 0.8 12.928 37
I3183 3183 0 1.31105e-05
R3587 3183 3184 1.648 0.8 13.184 37
I3184 3184 0 1.27395e-05
R3588 3184 3185 1.616 0.8 12.928 37
I3185 3185 0 1.24921e-05
R3589 3185 3186 1.616 0.8 12.928 37
I3186 3186 0 1.33579e-05
R3590 3186 3187 1.68 0.8 13.44 37
I3187 3187 0 1.23684e-05
R3591 3187 3188 1.744 0.8 13.952 37
I3188 3188 0 1.24921e-05
R3592 3188 3189 1.632 0.8 13.056 37
I3189 3189 0 1.32342e-05
R3593 3189 3190 1.664 0.8 13.312 37
I3190 3190 0 1.32342e-05
R3594 3190 3191 1.632 0.8 13.056 37
I3191 3191 0 1.23684e-05
R3595 3191 3192 1.664 0.8 13.312 37
I3192 3192 0 1.26158e-05
R3596 3192 3193 1.6 0.8 12.8 37
I3193 3193 0 1.27395e-05
R3597 3193 3194 1.6 0.8 12.8 37
I3194 3194 0 1.28631e-05
R3598 3194 3195 1.6 0.8 12.8 37
I3195 3195 0 1.23684e-05
R3599 3195 3196 1.68 0.8 13.44 37
I3196 3196 0 1.29868e-05
R3600 3196 3197 1.712 0.8 13.696 37
I3197 3197 0 1.23684e-05
R3601 3197 3198 1.648 0.8 13.184 37
I3198 3198 0 1.33579e-05
R3602 3198 3199 1.696 0.8 13.568 37
I3199 3199 0 1.34816e-05
R3603 3199 3200 1.616 0.8 12.928 37
I3200 3200 0 1.23684e-05
R3604 3200 3201 1.6 0.8 12.8 37
I3201 3201 0 1.29868e-05
R3605 3201 3202 1.728 0.8 13.824 37
I3202 3202 0 1.29868e-05
R3606 3202 3203 1.712 0.8 13.696 37
I3203 3203 0 1.34816e-05
R3607 3203 3204 1.696 0.8 13.568 37
I3204 3204 0 1.34816e-05
R3608 3204 3205 1.696 0.8 13.568 37
I3205 3205 0 1.26158e-05
R3609 3205 3206 1.728 0.8 13.824 37
I3206 3206 0 1.33579e-05
R3610 3206 3207 1.664 0.8 13.312 37
I3207 3207 0 1.27395e-05
R3611 3207 3208 1.632 0.8 13.056 37
I3208 3208 0 1.31105e-05
R3612 3208 3209 1.728 0.8 13.824 37
I3209 3209 0 1.26158e-05
R3613 3209 3210 1.616 0.8 12.928 37
I3210 3210 0 1.33579e-05
R3614 3210 3211 1.648 0.8 13.184 37
I3211 3211 0 1.31105e-05
R3615 3211 3212 1.68 0.8 13.44 37
I3212 3212 0 1.23684e-05
R3616 3212 3213 1.728 0.8 13.824 37
I3213 3213 0 1.24921e-05
R3617 3213 3214 1.728 0.8 13.824 37
I3214 3214 0 1.29868e-05
R3618 3214 3215 1.6 0.8 12.8 37
I3215 3215 0 1.24921e-05
R3619 3215 3216 1.712 0.8 13.696 37
I3216 3216 0 1.23684e-05
R3620 3216 3217 1.696 0.8 13.568 37
I3217 3217 0 1.32342e-05
R3621 3217 3218 1.712 0.8 13.696 37
I3218 3218 0 1.31105e-05
R3622 3218 3219 1.712 0.8 13.696 37
I3219 3219 0 1.29868e-05
R3623 3219 3220 1.68 0.8 13.44 37
I3220 3220 0 1.27395e-05
R3624 3220 3221 1.728 0.8 13.824 37
I3221 3221 0 1.31105e-05
R3625 3221 3222 1.664 0.8 13.312 37
I3222 3222 0 1.26158e-05
R3626 3222 3223 1.744 0.8 13.952 37
I3223 3223 0 1.31105e-05
R3627 3223 3224 1.744 0.8 13.952 37
I3224 3224 0 1.34816e-05
R3628 3224 3225 1.744 0.8 13.952 37
I3225 3225 0 1.26158e-05
R3629 3225 3226 1.744 0.8 13.952 37
I3226 3226 0 1.26158e-05
R3630 3226 3227 1.6 0.8 12.8 37
I3227 3227 0 1.28631e-05
R3631 3227 3228 1.664 0.8 13.312 37
I3228 3228 0 1.33579e-05
R3632 3228 3229 1.68 0.8 13.44 37
I3229 3229 0 1.28631e-05
R3633 3229 3230 1.68 0.8 13.44 37
I3230 3230 0 1.32342e-05
R3634 3230 3231 1.68 0.8 13.44 37
I3231 3231 0 1.26158e-05
R3635 3231 3232 1.712 0.8 13.696 37
I3232 3232 0 1.28631e-05
R3636 3232 3233 1.632 0.8 13.056 37
I3233 3233 0 1.31105e-05
R3637 3233 3234 1.6 0.8 12.8 37
I3234 3234 0 1.34816e-05
R3638 3234 3235 1.632 0.8 13.056 37
I3235 3235 0 1.32342e-05
R3639 3235 3236 1.664 0.8 13.312 37
I3236 3236 0 1.23684e-05
R3640 3236 3237 1.648 0.8 13.184 37
I3237 3237 0 1.33579e-05
R3641 3237 3238 1.664 0.8 13.312 37
I3238 3238 0 1.28631e-05
R3642 3238 3239 1.712 0.8 13.696 37
I3239 3239 0 1.29868e-05
R3643 3239 3240 1.648 0.8 13.184 37
I3240 3240 0 1.33579e-05
R3644 3240 3241 1.712 0.8 13.696 37
I3241 3241 0 1.26158e-05
R3645 3241 3242 1.632 0.8 13.056 37
I3242 3242 0 1.32342e-05
R3646 3242 3243 1.744 0.8 13.952 37
I3243 3243 0 1.31105e-05
R3647 3243 3244 1.696 0.8 13.568 37
I3244 3244 0 1.28631e-05
R3648 3244 3245 1.632 0.8 13.056 37
I3245 3245 0 1.24921e-05
R3649 3245 3246 1.664 0.8 13.312 37
I3246 3246 0 1.32342e-05
R3650 3246 3247 1.696 0.8 13.568 37
I3247 3247 0 1.27395e-05
R3651 3247 3248 1.648 0.8 13.184 37
I3248 3248 0 1.33579e-05
R3652 3248 3249 1.6 0.8 12.8 37
I3249 3249 0 1.27395e-05
R3653 3249 3250 1.744 0.8 13.952 37
I3250 3250 0 1.26158e-05
R3654 3250 3251 1.648 0.8 13.184 37
I3251 3251 0 1.27395e-05
R3655 3251 3252 1.664 0.8 13.312 37
I3252 3252 0 1.31105e-05
R3656 3252 3253 1.664 0.8 13.312 37
I3253 3253 0 1.33579e-05
R3657 3253 3254 1.616 0.8 12.928 37
I3254 3254 0 1.24921e-05
R3658 3254 3255 1.696 0.8 13.568 37
I3255 3255 0 1.31105e-05
R3659 3255 3256 1.744 0.8 13.952 37
I3256 3256 0 1.27395e-05
R3660 3256 3257 1.616 0.8 12.928 37
I3257 3257 0 1.27395e-05
R3661 3257 3258 1.648 0.8 13.184 37
I3258 3258 0 1.23684e-05
R3662 3258 3259 1.744 0.8 13.952 37
I3259 3259 0 1.24921e-05
R3663 3259 3260 1.696 0.8 13.568 37
I3260 3260 0 1.27395e-05
R3664 3260 3261 1.664 0.8 13.312 37
I3261 3261 0 1.23684e-05
R3665 3261 3262 1.6 0.8 12.8 37
I3262 3262 0 1.23684e-05
R3666 3262 3263 1.664 0.8 13.312 37
I3263 3263 0 1.31105e-05
R3667 3263 3264 1.6 0.8 12.8 37
I3264 3264 0 1.28631e-05
R3668 3264 3265 1.616 0.8 12.928 37
I3265 3265 0 1.34816e-05
R3669 3265 3266 1.728 0.8 13.824 37
I3266 3266 0 1.28631e-05
R3670 3266 3267 1.68 0.8 13.44 37
I3267 3267 0 1.26158e-05
R3671 3267 3268 1.616 0.8 12.928 37
I3268 3268 0 1.34816e-05
R3672 3268 3269 1.632 0.8 13.056 37
I3269 3269 0 1.28631e-05
R3673 3269 3270 1.632 0.8 13.056 37
I3270 3270 0 1.33579e-05
R3674 3270 3271 1.6 0.8 12.8 37
I3271 3271 0 1.27395e-05
R3675 3271 3272 1.664 0.8 13.312 37
I3272 3272 0 1.27395e-05
R3676 3272 3273 1.696 0.8 13.568 37
I3273 3273 0 1.32342e-05
R3677 3273 3274 1.648 0.8 13.184 37
I3274 3274 0 1.32342e-05
R3678 3274 3275 1.728 0.8 13.824 37
I3275 3275 0 1.23684e-05
R3679 3275 3276 1.6 0.8 12.8 37
I3276 3276 0 1.26158e-05
R3680 3276 3277 1.632 0.8 13.056 37
I3277 3277 0 1.26158e-05
R3681 3277 3278 1.68 0.8 13.44 37
I3278 3278 0 1.31105e-05
R3682 3278 3279 1.728 0.8 13.824 37
I3279 3279 0 1.29868e-05
R3683 3279 3280 1.632 0.8 13.056 37
I3280 3280 0 1.26158e-05
R3684 3280 3281 1.712 0.8 13.696 37
I3281 3281 0 1.23684e-05
R3685 3281 3282 1.696 0.8 13.568 37
I3282 3282 0 1.26158e-05
R3686 3282 3283 1.664 0.8 13.312 37
I3283 3283 0 1.34816e-05
R3687 3283 3284 1.648 0.8 13.184 37
I3284 3284 0 1.32342e-05
R3688 3284 3285 1.68 0.8 13.44 37
I3285 3285 0 1.32342e-05
R3689 3285 3286 1.712 0.8 13.696 37
I3286 3286 0 1.33579e-05
R3690 3286 3287 1.6 0.8 12.8 37
I3287 3287 0 1.24921e-05
R3691 3287 3288 1.616 0.8 12.928 37
I3288 3288 0 1.33579e-05
R3692 3288 3289 1.6 0.8 12.8 37
I3289 3289 0 1.29868e-05
R3693 3289 3290 1.68 0.8 13.44 37
I3290 3290 0 1.23684e-05
R3694 3290 3291 1.712 0.8 13.696 37
I3291 3291 0 1.32342e-05
R3695 3291 3292 1.648 0.8 13.184 37
I3292 3292 0 1.34816e-05
R3696 3292 3293 1.744 0.8 13.952 37
I3293 3293 0 1.23684e-05
R3697 3293 3294 1.696 0.8 13.568 37
I3294 3294 0 1.23684e-05
R3698 3294 3295 1.712 0.8 13.696 37
I3295 3295 0 1.33579e-05
R3699 3295 3296 1.632 0.8 13.056 37
I3296 3296 0 1.31105e-05
R3700 3296 3297 1.616 0.8 12.928 37
I3297 3297 0 1.23684e-05
R3701 3297 3298 1.6 0.8 12.8 37
I3298 3298 0 1.29868e-05
R3702 3298 3299 1.6 0.8 12.8 37
I3299 3299 0 1.27395e-05
R3703 3299 3300 1.664 0.8 13.312 37
I3300 3300 0 1.32342e-05
R3704 3300 3301 1.6 0.8 12.8 37
I3301 3301 0 1.26158e-05
R3705 3301 3302 1.68 0.8 13.44 37
I3302 3302 0 1.26158e-05
R3706 3302 3303 1.68 0.8 13.44 37
I3303 3303 0 1.32342e-05
R3707 3303 3304 1.6 0.8 12.8 37
I3304 3304 0 1.31105e-05
R3708 3304 3305 1.664 0.8 13.312 37
I3305 3305 0 1.32342e-05
R3709 3305 3306 1.696 0.8 13.568 37
I3306 3306 0 1.24921e-05
R3710 3306 3307 1.664 0.8 13.312 37
I3307 3307 0 1.24921e-05
R3711 3307 3308 1.6 0.8 12.8 37
I3308 3308 0 1.28631e-05
R3712 3308 3309 1.648 0.8 13.184 37
I3309 3309 0 1.33579e-05
R3713 3309 3310 1.696 0.8 13.568 37
I3310 3310 0 1.24921e-05
R3714 3310 3311 1.744 0.8 13.952 37
I3311 3311 0 1.33579e-05
R3715 3311 3312 1.744 0.8 13.952 37
I3312 3312 0 1.23684e-05
R3716 3312 3313 1.728 0.8 13.824 37
I3313 3313 0 1.23684e-05
R3717 3313 3314 1.68 0.8 13.44 37
I3314 3314 0 1.23684e-05
R3718 3314 3315 1.68 0.8 13.44 37
I3315 3315 0 1.23684e-05
R3719 3315 3316 1.728 0.8 13.824 37
I3316 3316 0 1.31105e-05
R3720 3316 3317 1.632 0.8 13.056 37
I3317 3317 0 1.29868e-05
R3721 3317 3318 1.6 0.8 12.8 37
I3318 3318 0 1.34816e-05
R3722 3318 3319 1.632 0.8 13.056 37
I3319 3319 0 1.24921e-05
R3723 3319 3320 1.712 0.8 13.696 37
I3320 3320 0 1.33579e-05
R3724 3320 3321 1.6 0.8 12.8 37
I3321 3321 0 1.31105e-05
R3725 3321 3322 1.744 0.8 13.952 37
I3322 3322 0 1.29868e-05
R3726 3322 3323 1.712 0.8 13.696 37
I3323 3323 0 1.26158e-05
R3727 3323 3324 1.616 0.8 12.928 37
I3324 3324 0 1.27395e-05
R3728 3324 3325 1.632 0.8 13.056 37
I3325 3325 0 1.32342e-05
R3729 3325 3326 1.696 0.8 13.568 37
I3326 3326 0 1.24921e-05
R3730 3326 3327 1.712 0.8 13.696 37
I3327 3327 0 1.29868e-05
R3731 3327 3328 1.616 0.8 12.928 37
I3328 3328 0 1.29868e-05
R3732 3328 3329 1.68 0.8 13.44 37
I3329 3329 0 1.32342e-05
R3733 3329 3330 1.728 0.8 13.824 37
I3330 3330 0 1.24921e-05
R3734 3330 3331 1.712 0.8 13.696 37
I3331 3331 0 1.33579e-05
R3735 3331 3332 1.744 0.8 13.952 37
I3332 3332 0 1.24921e-05
R3736 3332 3333 1.648 0.8 13.184 37
I3333 3333 0 1.34816e-05
R3737 3333 3334 1.632 0.8 13.056 37
I3334 3334 0 1.33579e-05
R3738 3334 3335 1.632 0.8 13.056 37
I3335 3335 0 1.23684e-05
R3739 3335 3336 1.696 0.8 13.568 37
I3336 3336 0 1.29868e-05
R3740 3336 3337 1.696 0.8 13.568 37
I3337 3337 0 1.33579e-05
R3741 3337 3338 1.6 0.8 12.8 37
I3338 3338 0 1.29868e-05
R3742 3338 3339 1.632 0.8 13.056 37
I3339 3339 0 1.24921e-05
R3743 3339 3340 1.728 0.8 13.824 37
I3340 3340 0 1.28631e-05
R3744 3340 3341 1.6 0.8 12.8 37
I3341 3341 0 1.28631e-05
R3745 3341 3342 1.696 0.8 13.568 37
I3342 3342 0 1.32342e-05
R3746 3342 3343 1.632 0.8 13.056 37
I3343 3343 0 1.32342e-05
R3747 3343 3344 1.632 0.8 13.056 37
I3344 3344 0 1.32342e-05
R3748 3344 3345 1.696 0.8 13.568 37
I3345 3345 0 1.26158e-05
R3749 3345 3346 1.6 0.8 12.8 37
I3346 3346 0 1.29868e-05
R3750 3346 3347 1.6 0.8 12.8 37
I3347 3347 0 1.24921e-05
R3751 3347 3348 1.728 0.8 13.824 37
I3348 3348 0 1.31105e-05
R3752 3348 3349 1.648 0.8 13.184 37
I3349 3349 0 1.24921e-05
R3753 3349 3350 1.664 0.8 13.312 37
I3350 3350 0 1.29868e-05
R3754 3350 3351 1.616 0.8 12.928 37
I3351 3351 0 1.26158e-05
R3755 3351 3352 1.6 0.8 12.8 37
I3352 3352 0 1.32342e-05
R3756 3352 3353 1.632 0.8 13.056 37
I3353 3353 0 1.26158e-05
R3757 3353 3354 1.664 0.8 13.312 37
I3354 3354 0 1.28631e-05
R3758 3354 3355 1.68 0.8 13.44 37
I3355 3355 0 1.27395e-05
R3759 3355 3356 1.744 0.8 13.952 37
I3356 3356 0 1.29868e-05
R3760 3356 3357 1.744 0.8 13.952 37
I3357 3357 0 1.32342e-05
R3761 3357 3358 1.632 0.8 13.056 37
I3358 3358 0 1.24921e-05
R3762 3358 3359 1.664 0.8 13.312 37
I3359 3359 0 1.32342e-05
R3763 3359 3360 1.616 0.8 12.928 37
I3360 3360 0 1.27395e-05
R3764 3360 3361 1.616 0.8 12.928 37
I3361 3361 0 1.27395e-05
R3765 3361 3362 1.728 0.8 13.824 37
I3362 3362 0 1.26158e-05
R3766 3362 3363 1.68 0.8 13.44 37
I3363 3363 0 1.32342e-05
R3767 3363 3364 1.6 0.8 12.8 37
I3364 3364 0 1.33579e-05
R3768 3364 3365 1.728 0.8 13.824 37
I3365 3365 0 1.28631e-05
R3769 3365 3366 1.68 0.8 13.44 37
I3366 3366 0 1.24921e-05
R3770 3366 3367 1.728 0.8 13.824 37
I3367 3367 0 1.33579e-05
R3771 3367 3368 1.6 0.8 12.8 37
I3368 3368 0 1.24921e-05
R3772 3368 3369 1.6 0.8 12.8 37
I3369 3369 0 1.28631e-05
R3773 3369 3370 1.712 0.8 13.696 37
I3370 3370 0 1.31105e-05
R3774 3370 3371 1.744 0.8 13.952 37
I3371 3371 0 1.31105e-05
R3775 3371 3372 1.648 0.8 13.184 37
I3372 3372 0 1.34816e-05
R3776 3372 3373 1.68 0.8 13.44 37
I3373 3373 0 1.33579e-05
R3777 3373 3374 1.632 0.8 13.056 37
I3374 3374 0 1.23684e-05
R3778 3374 3375 1.68 0.8 13.44 37
I3375 3375 0 1.29868e-05
R3779 3375 3376 1.68 0.8 13.44 37
I3376 3376 0 1.31105e-05
R3780 3376 3377 1.744 0.8 13.952 37
I3377 3377 0 1.27395e-05
R3781 3377 3378 1.6 0.8 12.8 37
I3378 3378 0 1.28631e-05
R3782 3378 3379 1.632 0.8 13.056 37
I3379 3379 0 1.23684e-05
R3783 3379 3380 1.632 0.8 13.056 37
I3380 3380 0 1.23684e-05
R3784 3380 3381 1.696 0.8 13.568 37
I3381 3381 0 1.32342e-05
R3785 3381 3382 1.648 0.8 13.184 37
I3382 3382 0 1.32342e-05
R3786 3382 3383 1.68 0.8 13.44 37
I3383 3383 0 1.27395e-05
R3787 3383 3384 1.728 0.8 13.824 37
I3384 3384 0 1.33579e-05
R3788 3384 3385 1.728 0.8 13.824 37
I3385 3385 0 1.29868e-05
R3789 3385 3386 1.696 0.8 13.568 37
I3386 3386 0 1.34816e-05
R3790 3386 3387 1.664 0.8 13.312 37
I3387 3387 0 1.34816e-05
R3791 3387 3388 1.728 0.8 13.824 37
I3388 3388 0 1.34816e-05
R3792 3388 3389 1.712 0.8 13.696 37
I3389 3389 0 1.27395e-05
R3793 3389 3390 1.616 0.8 12.928 37
I3390 3390 0 1.28631e-05
R3794 3390 3391 1.728 0.8 13.824 37
I3391 3391 0 1.31105e-05
R3795 3391 3392 1.648 0.8 13.184 37
I3392 3392 0 1.34816e-05
R3796 3392 3393 1.632 0.8 13.056 37
I3393 3393 0 1.27395e-05
R3797 3393 3394 1.648 0.8 13.184 37
I3394 3394 0 1.28631e-05
R3798 3394 3395 1.696 0.8 13.568 37
I3395 3395 0 1.32342e-05
R3799 3395 3396 1.712 0.8 13.696 37
I3396 3396 0 1.28631e-05
R3800 3396 3397 1.712 0.8 13.696 37
I3397 3397 0 1.23684e-05
R3801 3397 3398 1.616 0.8 12.928 37
I3398 3398 0 1.28631e-05
R3802 3398 3399 1.664 0.8 13.312 37
I3399 3399 0 1.34816e-05
R3803 3399 3400 1.632 0.8 13.056 37
I3400 3400 0 1.28631e-05
R3804 3400 3401 1.712 0.8 13.696 37
I3401 3401 0 1.33579e-05
R3805 3401 3402 1.648 0.8 13.184 37
I3402 3402 0 1.27395e-05
R3806 3402 3403 1.6 0.8 12.8 37
I3403 3403 0 1.28631e-05
R3807 3403 3404 1.664 0.8 13.312 37
I3404 3404 0 1.34816e-05
R3808 3404 3405 1.712 0.8 13.696 37
I3405 3405 0 1.31105e-05
R3809 3405 3406 1.664 0.8 13.312 37
I3406 3406 0 1.32342e-05
R3810 3406 3407 1.664 0.8 13.312 37
I3407 3407 0 1.32342e-05
R3811 3407 3408 1.712 0.8 13.696 37
I3408 3408 0 1.31105e-05
R3812 3408 3409 1.632 0.8 13.056 37
I3409 3409 0 1.26158e-05
R3813 3409 3410 1.648 0.8 13.184 37
I3410 3410 0 1.23684e-05
R3814 3410 3411 1.6 0.8 12.8 37
I3411 3411 0 1.23684e-05
R3815 3411 3412 1.68 0.8 13.44 37
I3412 3412 0 1.32342e-05
R3816 3412 3413 1.6 0.8 12.8 37
I3413 3413 0 1.31105e-05
R3817 3413 3414 1.616 0.8 12.928 37
I3414 3414 0 1.31105e-05
R3818 3414 3415 1.728 0.8 13.824 37
I3415 3415 0 1.31105e-05
R3819 3415 3416 1.6 0.8 12.8 37
I3416 3416 0 1.32342e-05
R3820 3416 3417 1.696 0.8 13.568 37
I3417 3417 0 1.31105e-05
R3821 3417 3418 1.6 0.8 12.8 37
I3418 3418 0 1.33579e-05
R3822 3418 3419 1.6 0.8 12.8 37
I3419 3419 0 1.28631e-05
R3823 3419 3420 1.728 0.8 13.824 37
I3420 3420 0 1.34816e-05
R3824 3420 3421 1.632 0.8 13.056 37
I3421 3421 0 1.28631e-05
R3825 3421 3422 1.728 0.8 13.824 37
I3422 3422 0 1.32342e-05
R3826 3422 3423 1.648 0.8 13.184 37
I3423 3423 0 1.29868e-05
R3827 3423 3424 1.68 0.8 13.44 37
I3424 3424 0 1.32342e-05
R3828 3424 3425 1.6 0.8 12.8 37
I3425 3425 0 1.33579e-05
R3829 3425 3426 1.728 0.8 13.824 37
I3426 3426 0 1.26158e-05
R3830 3426 3427 1.6 0.8 12.8 37
I3427 3427 0 1.27395e-05
R3831 3427 3428 1.744 0.8 13.952 37
I3428 3428 0 1.27395e-05
R3832 3428 3429 1.616 0.8 12.928 37
I3429 3429 0 1.26158e-05
R3833 3429 3430 1.744 0.8 13.952 37
I3430 3430 0 1.34816e-05
R3834 3430 3431 1.6 0.8 12.8 37
I3431 3431 0 1.23684e-05
R3835 3431 3432 1.696 0.8 13.568 37
I3432 3432 0 1.34816e-05
R3836 3432 3433 1.696 0.8 13.568 37
I3433 3433 0 1.33579e-05
R3837 3433 3434 1.712 0.8 13.696 37
I3434 3434 0 1.33579e-05
R3838 3434 3435 1.648 0.8 13.184 37
I3435 3435 0 1.29868e-05
R3839 3435 3436 1.712 0.8 13.696 37
I3436 3436 0 1.32342e-05
R3840 3436 3437 1.616 0.8 12.928 37
I3437 3437 0 1.29868e-05
R3841 3437 3438 1.696 0.8 13.568 37
I3438 3438 0 1.28631e-05
R3842 3438 3439 1.648 0.8 13.184 37
I3439 3439 0 1.26158e-05
R3843 3439 3440 1.632 0.8 13.056 37
I3440 3440 0 1.29868e-05
R3844 3440 3441 1.632 0.8 13.056 37
I3441 3441 0 1.23684e-05
R3845 3441 3442 1.712 0.8 13.696 37
I3442 3442 0 1.29868e-05
R3846 3442 3443 1.68 0.8 13.44 37
I3443 3443 0 1.33579e-05
R3847 3443 3444 1.728 0.8 13.824 37
I3444 3444 0 1.31105e-05
R3848 3444 3445 1.632 0.8 13.056 37
I3445 3445 0 1.32342e-05
R3849 3445 3446 1.728 0.8 13.824 37
I3446 3446 0 1.27395e-05
R3850 3446 3447 1.744 0.8 13.952 37
I3447 3447 0 1.31105e-05
R3851 3447 3448 1.632 0.8 13.056 37
I3448 3448 0 1.32342e-05
R3852 3448 3449 1.68 0.8 13.44 37
I3449 3449 0 1.24921e-05
R3853 3449 3450 1.68 0.8 13.44 37
I3450 3450 0 1.23684e-05
R3854 3450 3451 1.712 0.8 13.696 37
I3451 3451 0 1.28631e-05
R3855 3451 3452 1.712 0.8 13.696 37
I3452 3452 0 1.23684e-05
R3856 3452 3453 1.632 0.8 13.056 37
I3453 3453 0 1.28631e-05
R3857 3453 3454 1.68 0.8 13.44 37
I3454 3454 0 1.32342e-05
R3858 3454 3455 1.728 0.8 13.824 37
I3455 3455 0 1.32342e-05
R3859 3455 3456 1.632 0.8 13.056 37
I3456 3456 0 1.26158e-05
R3860 3456 3457 1.744 0.8 13.952 37
I3457 3457 0 1.24921e-05
R3861 3457 3458 1.712 0.8 13.696 37
I3458 3458 0 1.31105e-05
R3862 3458 3459 1.744 0.8 13.952 37
I3459 3459 0 1.29868e-05
R3863 3459 3460 1.632 0.8 13.056 37
I3460 3460 0 1.27395e-05
R3864 3460 3461 1.68 0.8 13.44 37
I3461 3461 0 1.26158e-05
R3865 3461 3462 1.696 0.8 13.568 37
I3462 3462 0 1.28631e-05
R3866 3462 3463 1.744 0.8 13.952 37
I3463 3463 0 1.23684e-05
R3867 3463 3464 1.664 0.8 13.312 37
I3464 3464 0 1.28631e-05
R3868 3464 3465 1.632 0.8 13.056 37
I3465 3465 0 1.34816e-05
R3869 3465 3466 1.664 0.8 13.312 37
I3466 3466 0 1.24921e-05
R3870 3466 3467 1.696 0.8 13.568 37
I3467 3467 0 1.27395e-05
R3871 3467 3468 1.616 0.8 12.928 37
I3468 3468 0 1.23684e-05
R3872 3468 3469 1.712 0.8 13.696 37
I3469 3469 0 1.33579e-05
R3873 3469 3470 1.712 0.8 13.696 37
I3470 3470 0 1.32342e-05
R3874 3470 3471 1.712 0.8 13.696 37
I3471 3471 0 1.24921e-05
R3875 3471 3472 1.6 0.8 12.8 37
I3472 3472 0 1.33579e-05
R3876 3472 3473 1.664 0.8 13.312 37
I3473 3473 0 1.32342e-05
R3877 3473 3474 1.664 0.8 13.312 37
I3474 3474 0 1.27395e-05
R3878 3474 3475 1.68 0.8 13.44 37
I3475 3475 0 1.34816e-05
R3879 3475 3476 1.696 0.8 13.568 37
I3476 3476 0 1.23684e-05
R3880 3476 3477 1.616 0.8 12.928 37
I3477 3477 0 1.29868e-05
R3881 3477 3478 1.696 0.8 13.568 37
I3478 3478 0 1.26158e-05
R3882 3478 3479 1.712 0.8 13.696 37
I3479 3479 0 1.23684e-05
R3883 3479 3480 1.696 0.8 13.568 37
I3480 3480 0 1.24921e-05
R3884 3480 3481 1.632 0.8 13.056 37
I3481 3481 0 1.26158e-05
R3885 3481 3482 1.664 0.8 13.312 37
I3482 3482 0 1.33579e-05
R3886 3482 3483 1.696 0.8 13.568 37
I3483 3483 0 1.33579e-05
R3887 3483 3484 1.6 0.8 12.8 37
I3484 3484 0 1.29868e-05
R3888 3484 3485 1.696 0.8 13.568 37
I3485 3485 0 1.34816e-05
R3889 3485 3486 1.648 0.8 13.184 37
I3486 3486 0 1.31105e-05
R3890 3486 3487 1.6 0.8 12.8 37
I3487 3487 0 1.29868e-05
R3891 3487 3488 1.664 0.8 13.312 37
I3488 3488 0 1.31105e-05
R3892 3488 3489 1.632 0.8 13.056 37
I3489 3489 0 1.34816e-05
R3893 3489 3490 1.744 0.8 13.952 37
I3490 3490 0 1.34816e-05
R3894 3490 3491 1.728 0.8 13.824 37
I3491 3491 0 1.32342e-05
R3895 3491 3492 1.616 0.8 12.928 37
I3492 3492 0 1.24921e-05
R3896 3492 3493 1.664 0.8 13.312 37
I3493 3493 0 1.33579e-05
R3897 3493 3494 1.664 0.8 13.312 37
I3494 3494 0 1.26158e-05
R3898 3494 3495 1.728 0.8 13.824 37
I3495 3495 0 1.26158e-05
R3899 3495 3496 1.68 0.8 13.44 37
I3496 3496 0 1.26158e-05
R3900 3496 3497 1.68 0.8 13.44 37
I3497 3497 0 1.23684e-05
R3901 3497 3498 1.632 0.8 13.056 37
I3498 3498 0 1.27395e-05
R3902 3498 3499 1.728 0.8 13.824 37
I3499 3499 0 1.26158e-05
R3903 3499 3500 1.6 0.8 12.8 37
I3500 3500 0 1.31105e-05
R3904 3500 3501 1.616 0.8 12.928 37
I3501 3501 0 1.29868e-05
R3905 3501 3502 1.632 0.8 13.056 37
I3502 3502 0 1.27395e-05
R3906 3502 3503 1.6 0.8 12.8 37
I3503 3503 0 1.32342e-05
R3907 3503 3504 1.744 0.8 13.952 37
I3504 3504 0 1.29868e-05
R3908 3504 3505 1.696 0.8 13.568 37
I3505 3505 0 1.23684e-05
R3909 3505 3506 1.664 0.8 13.312 37
I3506 3506 0 1.31105e-05
R3910 3506 3507 1.6 0.8 12.8 37
I3507 3507 0 1.31105e-05
R3911 3507 3508 1.744 0.8 13.952 37
I3508 3508 0 1.28631e-05
R3912 3508 3509 1.696 0.8 13.568 37
I3509 3509 0 1.27395e-05
R3913 3509 3510 1.728 0.8 13.824 37
I3510 3510 0 1.31105e-05
R3914 3510 3511 1.728 0.8 13.824 37
I3511 3511 0 1.28631e-05
R3915 3511 3512 1.744 0.8 13.952 37
I3512 3512 0 1.27395e-05
R3916 3512 3513 1.696 0.8 13.568 37
I3513 3513 0 1.24921e-05
R3917 3513 3514 1.728 0.8 13.824 37
I3514 3514 0 1.28631e-05
R3918 3514 3515 1.696 0.8 13.568 37
I3515 3515 0 1.33579e-05
R3919 3515 3516 1.6 0.8 12.8 37
I3516 3516 0 1.32342e-05
R3920 3516 3517 1.664 0.8 13.312 37
I3517 3517 0 1.29868e-05
R3921 3517 3518 1.648 0.8 13.184 37
I3518 3518 0 1.28631e-05
R3922 3518 3519 1.632 0.8 13.056 37
I3519 3519 0 1.26158e-05
R3923 3519 3520 1.616 0.8 12.928 37
I3520 3520 0 1.23684e-05
R3924 3520 3521 1.68 0.8 13.44 37
I3521 3521 0 1.31105e-05
R3925 3521 3522 1.728 0.8 13.824 37
I3522 3522 0 1.29868e-05
R3926 3522 3523 1.664 0.8 13.312 37
I3523 3523 0 1.32342e-05
R3927 3523 3524 1.616 0.8 12.928 37
I3524 3524 0 1.23684e-05
R3928 3524 3525 1.648 0.8 13.184 37
I3525 3525 0 1.23684e-05
R3929 3525 3526 1.696 0.8 13.568 37
I3526 3526 0 1.27395e-05
R3930 3526 3527 1.696 0.8 13.568 37
I3527 3527 0 1.29868e-05
R3931 3527 3528 1.696 0.8 13.568 37
I3528 3528 0 1.26158e-05
R3932 3528 3529 1.744 0.8 13.952 37
I3529 3529 0 1.31105e-05
R3933 3529 3530 1.728 0.8 13.824 37
I3530 3530 0 1.29868e-05
R3934 3530 3531 1.696 0.8 13.568 37
I3531 3531 0 1.23684e-05
R3935 3531 3532 1.664 0.8 13.312 37
I3532 3532 0 1.26158e-05
R3936 3532 3533 1.68 0.8 13.44 37
I3533 3533 0 1.32342e-05
R3937 3533 3534 1.744 0.8 13.952 37
I3534 3534 0 1.34816e-05
R3938 3534 3535 1.632 0.8 13.056 37
I3535 3535 0 1.23684e-05
R3939 3535 3536 1.616 0.8 12.928 37
I3536 3536 0 1.32342e-05
R3940 3536 3537 1.696 0.8 13.568 37
I3537 3537 0 1.34816e-05
R3941 3537 3538 1.664 0.8 13.312 37
I3538 3538 0 1.23684e-05
R3942 3538 3539 1.744 0.8 13.952 37
I3539 3539 0 1.29868e-05
R3943 3539 3540 1.632 0.8 13.056 37
I3540 3540 0 1.28631e-05
R3944 3540 3541 1.712 0.8 13.696 37
I3541 3541 0 1.34816e-05
R3945 3541 3542 1.712 0.8 13.696 37
I3542 3542 0 1.29868e-05
R3946 3542 3543 1.664 0.8 13.312 37
I3543 3543 0 1.29868e-05
R3947 3543 3544 1.744 0.8 13.952 37
I3544 3544 0 1.27395e-05
R3948 3544 3545 1.648 0.8 13.184 37
I3545 3545 0 1.32342e-05
R3949 3545 3546 1.6 0.8 12.8 37
I3546 3546 0 1.34816e-05
R3950 3546 3547 1.6 0.8 12.8 37
I3547 3547 0 1.29868e-05
R3951 3547 3548 1.632 0.8 13.056 37
I3548 3548 0 1.29868e-05
R3952 3548 3549 1.632 0.8 13.056 37
I3549 3549 0 1.27395e-05
R3953 3549 3550 1.712 0.8 13.696 37
I3550 3550 0 1.31105e-05
R3954 3550 3551 1.648 0.8 13.184 37
I3551 3551 0 1.33579e-05
R3955 3551 3552 1.648 0.8 13.184 37
I3552 3552 0 1.26158e-05
R3956 3552 3553 1.6 0.8 12.8 37
I3553 3553 0 1.34816e-05
R3957 3553 3554 1.664 0.8 13.312 37
I3554 3554 0 1.34816e-05
R3958 3554 3555 1.712 0.8 13.696 37
I3555 3555 0 1.32342e-05
R3959 3555 3556 1.68 0.8 13.44 37
I3556 3556 0 1.28631e-05
R3960 3556 3557 1.696 0.8 13.568 37
I3557 3557 0 1.26158e-05
R3961 3557 3558 1.632 0.8 13.056 37
I3558 3558 0 1.26158e-05
R3962 3558 3559 1.744 0.8 13.952 37
I3559 3559 0 1.24921e-05
R3963 3559 3560 1.728 0.8 13.824 37
I3560 3560 0 1.26158e-05
R3964 3560 3561 1.616 0.8 12.928 37
I3561 3561 0 1.33579e-05
R3965 3561 3562 1.616 0.8 12.928 37
I3562 3562 0 1.24921e-05
R3966 3562 3563 1.68 0.8 13.44 37
I3563 3563 0 1.29868e-05
R3967 3563 3564 1.728 0.8 13.824 37
I3564 3564 0 1.33579e-05
R3968 3564 3565 1.728 0.8 13.824 37
I3565 3565 0 1.29868e-05
R3969 3565 3566 1.664 0.8 13.312 37
I3566 3566 0 1.26158e-05
R3970 3566 3567 1.696 0.8 13.568 37
I3567 3567 0 1.23684e-05
R3971 3567 3568 1.696 0.8 13.568 37
I3568 3568 0 1.31105e-05
R3972 3568 3569 1.616 0.8 12.928 37
I3569 3569 0 1.23684e-05
R3973 3569 3570 1.712 0.8 13.696 37
I3570 3570 0 1.33579e-05
R3974 3570 3571 1.712 0.8 13.696 37
I3571 3571 0 1.26158e-05
R3975 3571 3572 1.68 0.8 13.44 37
I3572 3572 0 1.29868e-05
R3976 3572 3573 1.664 0.8 13.312 37
I3573 3573 0 1.32342e-05
R3977 3573 3574 1.728 0.8 13.824 37
I3574 3574 0 1.27395e-05
R3978 3574 3575 1.6 0.8 12.8 37
I3575 3575 0 1.31105e-05
R3979 3575 3576 1.68 0.8 13.44 37
I3576 3576 0 1.24921e-05
R3980 3576 3577 1.696 0.8 13.568 37
I3577 3577 0 1.33579e-05
R3981 3577 3578 1.632 0.8 13.056 37
I3578 3578 0 1.26158e-05
R3982 3578 3579 1.664 0.8 13.312 37
I3579 3579 0 1.24921e-05
R3983 3579 3580 1.632 0.8 13.056 37
I3580 3580 0 1.28631e-05
R3984 3580 3581 1.728 0.8 13.824 37
I3581 3581 0 1.33579e-05
R3985 3581 3582 1.728 0.8 13.824 37
I3582 3582 0 1.28631e-05
R3986 3582 3583 1.6 0.8 12.8 37
I3583 3583 0 1.28631e-05
R3987 3583 3584 1.632 0.8 13.056 37
I3584 3584 0 1.26158e-05
R3988 3584 3585 1.68 0.8 13.44 37
I3585 3585 0 1.34816e-05
R3989 3585 3586 1.632 0.8 13.056 37
I3586 3586 0 1.28631e-05
R3990 3586 3587 1.616 0.8 12.928 37
I3587 3587 0 1.32342e-05
R3991 3587 3588 1.6 0.8 12.8 37
I3588 3588 0 1.32342e-05
R3992 3588 3589 1.696 0.8 13.568 37
I3589 3589 0 1.33579e-05
R3993 3589 3590 1.632 0.8 13.056 37
I3590 3590 0 1.32342e-05
R3994 3590 3591 1.696 0.8 13.568 37
I3591 3591 0 1.34816e-05
R3995 3591 3592 1.6 0.8 12.8 37
I3592 3592 0 1.28631e-05
R3996 3592 3593 1.728 0.8 13.824 37
I3593 3593 0 1.27395e-05
R3997 3593 3594 1.696 0.8 13.568 37
I3594 3594 0 1.28631e-05
R3998 3594 3595 1.696 0.8 13.568 37
I3595 3595 0 1.23684e-05
R3999 3595 3596 1.728 0.8 13.824 37
I3596 3596 0 1.31105e-05
R4000 3596 3597 1.744 0.8 13.952 37
I3597 3597 0 1.32342e-05
R4001 3597 3598 1.648 0.8 13.184 37
I3598 3598 0 1.24921e-05
R4002 3598 3599 1.648 0.8 13.184 37
I3599 3599 0 1.29868e-05
R4003 3599 3600 1.648 0.8 13.184 37
I3600 3600 0 1.33579e-05
R4004 3600 3601 1.68 0.8 13.44 37
I3601 3601 0 1.31105e-05
R4005 3601 3602 1.648 0.8 13.184 37
I3602 3602 0 1.31105e-05
R4006 3602 3603 1.68 0.8 13.44 37
I3603 3603 0 1.27395e-05
R4007 3603 3604 1.664 0.8 13.312 37
I3604 3604 0 1.28631e-05
R4008 3604 3605 1.648 0.8 13.184 37
I3605 3605 0 1.33579e-05
R4009 3605 3606 1.616 0.8 12.928 37
I3606 3606 0 1.34816e-05
R4010 3606 3607 1.728 0.8 13.824 37
I3607 3607 0 1.24921e-05
R4011 3607 3608 1.68 0.8 13.44 37
I3608 3608 0 1.31105e-05
R4012 3608 3609 1.696 0.8 13.568 37
I3609 3609 0 1.28631e-05
R4013 3609 3610 1.6 0.8 12.8 37
I3610 3610 0 1.28631e-05
R4014 3610 3611 1.664 0.8 13.312 37
I3611 3611 0 1.23684e-05
R4015 3611 3612 1.648 0.8 13.184 37
I3612 3612 0 1.29868e-05
R4016 3612 3613 1.744 0.8 13.952 37
I3613 3613 0 1.31105e-05
R4017 3613 3614 1.712 0.8 13.696 37
I3614 3614 0 1.27395e-05
R4018 3614 3615 1.648 0.8 13.184 37
I3615 3615 0 1.26158e-05
R4019 3615 3616 1.648 0.8 13.184 37
I3616 3616 0 1.33579e-05
R4020 3616 3617 1.6 0.8 12.8 37
I3617 3617 0 1.31105e-05
R4021 3617 3618 1.712 0.8 13.696 37
I3618 3618 0 1.31105e-05
R4022 3618 3619 1.616 0.8 12.928 37
I3619 3619 0 1.27395e-05
R4023 3619 3620 1.6 0.8 12.8 37
I3620 3620 0 1.28631e-05
R4024 3620 3621 1.616 0.8 12.928 37
I3621 3621 0 1.27395e-05
R4025 3621 3622 1.68 0.8 13.44 37
I3622 3622 0 1.34816e-05
R4026 3622 3623 1.696 0.8 13.568 37
I3623 3623 0 1.27395e-05
R4027 3623 3624 1.68 0.8 13.44 37
I3624 3624 0 1.29868e-05
R4028 3624 3625 1.712 0.8 13.696 37
I3625 3625 0 1.32342e-05
R4029 3625 3626 1.616 0.8 12.928 37
I3626 3626 0 1.24921e-05
R4030 3626 3627 1.6 0.8 12.8 37
I3627 3627 0 1.28631e-05
R4031 3627 3628 1.744 0.8 13.952 37
I3628 3628 0 1.24921e-05
R4032 3628 3629 1.632 0.8 13.056 37
I3629 3629 0 1.33579e-05
R4033 3629 3630 1.664 0.8 13.312 37
I3630 3630 0 1.31105e-05
R4034 3630 3631 1.6 0.8 12.8 37
I3631 3631 0 1.23684e-05
R4035 3631 3632 1.664 0.8 13.312 37
I3632 3632 0 1.24921e-05
R4036 3632 3633 1.696 0.8 13.568 37
I3633 3633 0 1.27395e-05
R4037 3633 3634 1.744 0.8 13.952 37
I3634 3634 0 1.23684e-05
R4038 3634 3635 1.696 0.8 13.568 37
I3635 3635 0 1.24921e-05
R4039 3635 3636 1.696 0.8 13.568 37
I3636 3636 0 1.33579e-05
R4040 3636 3637 1.696 0.8 13.568 37
I3637 3637 0 1.28631e-05
R4041 3637 3638 1.744 0.8 13.952 37
I3638 3638 0 1.28631e-05
R4042 3638 3639 1.712 0.8 13.696 37
I3639 3639 0 1.32342e-05
R4043 3639 3640 1.744 0.8 13.952 37
I3640 3640 0 1.28631e-05
R4044 3640 3641 1.696 0.8 13.568 37
I3641 3641 0 1.27395e-05
R4045 3641 3642 1.712 0.8 13.696 37
I3642 3642 0 1.31105e-05
R4046 3642 3643 1.744 0.8 13.952 37
I3643 3643 0 1.33579e-05
R4047 3643 3644 1.728 0.8 13.824 37
I3644 3644 0 1.26158e-05
R4048 3644 3645 1.696 0.8 13.568 37
I3645 3645 0 1.28631e-05
R4049 3645 3646 1.728 0.8 13.824 37
I3646 3646 0 1.32342e-05
R4050 3646 3647 1.664 0.8 13.312 37
I3647 3647 0 1.28631e-05
R4051 3647 3648 1.6 0.8 12.8 37
I3648 3648 0 1.27395e-05
R4052 3648 3649 1.6 0.8 12.8 37
I3649 3649 0 1.24921e-05
R4053 3649 3650 1.68 0.8 13.44 37
I3650 3650 0 1.31105e-05
R4054 3650 3651 1.664 0.8 13.312 37
I3651 3651 0 1.24921e-05
R4055 3651 3652 1.696 0.8 13.568 37
I3652 3652 0 1.26158e-05
R4056 3652 3653 1.712 0.8 13.696 37
I3653 3653 0 1.31105e-05
R4057 3653 3654 1.696 0.8 13.568 37
I3654 3654 0 1.31105e-05
R4058 3654 3655 1.68 0.8 13.44 37
I3655 3655 0 1.33579e-05
R4059 3655 3656 1.632 0.8 13.056 37
I3656 3656 0 1.24921e-05
R4060 3656 3657 1.616 0.8 12.928 37
I3657 3657 0 1.23684e-05
R4061 3657 3658 1.6 0.8 12.8 37
I3658 3658 0 1.26158e-05
R4062 3658 3659 1.6 0.8 12.8 37
I3659 3659 0 1.23684e-05
R4063 3659 3660 1.664 0.8 13.312 37
I3660 3660 0 1.32342e-05
R4064 3660 3661 1.664 0.8 13.312 37
I3661 3661 0 1.28631e-05
R4065 3661 3662 1.696 0.8 13.568 37
I3662 3662 0 1.24921e-05
R4066 3662 3663 1.616 0.8 12.928 37
I3663 3663 0 1.31105e-05
R4067 3663 3664 1.696 0.8 13.568 37
I3664 3664 0 1.24921e-05
R4068 3664 3665 1.744 0.8 13.952 37
I3665 3665 0 1.24921e-05
R4069 3665 3666 1.744 0.8 13.952 37
I3666 3666 0 1.27395e-05
R4070 3666 3667 1.664 0.8 13.312 37
I3667 3667 0 1.31105e-05
R4071 3667 3668 1.68 0.8 13.44 37
I3668 3668 0 1.26158e-05
R4072 3668 3669 1.664 0.8 13.312 37
I3669 3669 0 1.27395e-05
R4073 3669 3670 1.728 0.8 13.824 37
I3670 3670 0 1.34816e-05
R4074 3670 3671 1.616 0.8 12.928 37
I3671 3671 0 1.24921e-05
R4075 3671 3672 1.632 0.8 13.056 37
I3672 3672 0 1.28631e-05
R4076 3672 3673 1.648 0.8 13.184 37
I3673 3673 0 1.26158e-05
R4077 3673 3674 1.712 0.8 13.696 37
I3674 3674 0 1.27395e-05
R4078 3674 3675 1.632 0.8 13.056 37
I3675 3675 0 1.27395e-05
R4079 3675 3676 1.632 0.8 13.056 37
I3676 3676 0 1.32342e-05
R4080 3676 3677 1.728 0.8 13.824 37
I3677 3677 0 1.33579e-05
R4081 3677 3678 1.6 0.8 12.8 37
I3678 3678 0 1.24921e-05
R4082 3678 3679 1.664 0.8 13.312 37
I3679 3679 0 1.31105e-05
R4083 3679 3680 1.632 0.8 13.056 37
I3680 3680 0 1.29868e-05
R4084 3680 3681 1.744 0.8 13.952 37
I3681 3681 0 1.24921e-05
R4085 3681 3682 1.728 0.8 13.824 37
I3682 3682 0 1.27395e-05
R4086 3682 3683 1.744 0.8 13.952 37
I3683 3683 0 1.29868e-05
R4087 3683 3684 1.712 0.8 13.696 37
I3684 3684 0 1.29868e-05
R4088 3684 3685 1.744 0.8 13.952 37
I3685 3685 0 1.31105e-05
R4089 3685 3686 1.696 0.8 13.568 37
I3686 3686 0 1.26158e-05
R4090 3686 3687 1.744 0.8 13.952 37
I3687 3687 0 1.34816e-05
R4091 3687 3688 1.712 0.8 13.696 37
I3688 3688 0 1.28631e-05
R4092 3688 3689 1.616 0.8 12.928 37
I3689 3689 0 1.31105e-05
R4093 3689 3690 1.712 0.8 13.696 37
I3690 3690 0 1.31105e-05
R4094 3690 3691 1.744 0.8 13.952 37
I3691 3691 0 1.26158e-05
R4095 3691 3692 1.68 0.8 13.44 37
I3692 3692 0 1.32342e-05
R4096 3692 3693 1.6 0.8 12.8 37
I3693 3693 0 1.29868e-05
R4097 3693 3694 1.728 0.8 13.824 37
I3694 3694 0 1.32342e-05
R4098 3694 3695 1.648 0.8 13.184 37
I3695 3695 0 1.26158e-05
R4099 3695 3696 1.632 0.8 13.056 37
I3696 3696 0 1.26158e-05
R4100 3696 3697 1.696 0.8 13.568 37
I3697 3697 0 1.27395e-05
R4101 3697 3698 1.712 0.8 13.696 37
I3698 3698 0 1.32342e-05
R4102 3698 3699 1.728 0.8 13.824 37
I3699 3699 0 1.29868e-05
R4103 3699 3700 1.648 0.8 13.184 37
I3700 3700 0 1.34816e-05
R4104 3700 3701 1.648 0.8 13.184 37
I3701 3701 0 1.24921e-05
R4105 3701 3702 1.664 0.8 13.312 37
I3702 3702 0 1.26158e-05
R4106 3702 3703 1.6 0.8 12.8 37
I3703 3703 0 1.24921e-05
R4107 3703 3704 1.696 0.8 13.568 37
I3704 3704 0 1.28631e-05
R4108 3704 3705 1.744 0.8 13.952 37
I3705 3705 0 1.29868e-05
R4109 3705 3706 1.6 0.8 12.8 37
I3706 3706 0 1.33579e-05
R4110 3706 3707 1.712 0.8 13.696 37
I3707 3707 0 1.29868e-05
R4111 3707 3708 1.728 0.8 13.824 37
I3708 3708 0 1.33579e-05
R4112 3708 3709 1.632 0.8 13.056 37
I3709 3709 0 1.33579e-05
R4113 3709 3710 1.712 0.8 13.696 37
I3710 3710 0 1.29868e-05
R4114 3710 3711 1.616 0.8 12.928 37
I3711 3711 0 1.34816e-05
R4115 3711 3712 1.744 0.8 13.952 37
I3712 3712 0 1.34816e-05
R4116 3712 3713 1.664 0.8 13.312 37
I3713 3713 0 1.31105e-05
R4117 3713 3714 1.696 0.8 13.568 37
I3714 3714 0 1.29868e-05
R4118 3714 3715 1.616 0.8 12.928 37
I3715 3715 0 1.34816e-05
R4119 3715 3716 1.664 0.8 13.312 37
I3716 3716 0 1.28631e-05
R4120 3716 3717 1.616 0.8 12.928 37
I3717 3717 0 1.33579e-05
R4121 3717 3718 1.696 0.8 13.568 37
I3718 3718 0 1.27395e-05
R4122 3718 3719 1.616 0.8 12.928 37
I3719 3719 0 1.28631e-05
R4123 3719 3720 1.744 0.8 13.952 37
I3720 3720 0 1.23684e-05
R4124 3720 3721 1.632 0.8 13.056 37
I3721 3721 0 1.34816e-05
R4125 3721 3722 1.616 0.8 12.928 37
I3722 3722 0 1.24921e-05
R4126 3722 3723 1.696 0.8 13.568 37
I3723 3723 0 1.34816e-05
R4127 3723 3724 1.616 0.8 12.928 37
I3724 3724 0 1.33579e-05
R4128 3724 3725 1.712 0.8 13.696 37
I3725 3725 0 1.33579e-05
R4129 3725 3726 1.68 0.8 13.44 37
I3726 3726 0 1.23684e-05
R4130 3726 3727 1.728 0.8 13.824 37
I3727 3727 0 1.28631e-05
R4131 3727 3728 1.744 0.8 13.952 37
I3728 3728 0 1.26158e-05
R4132 3728 3729 1.616 0.8 12.928 37
I3729 3729 0 1.31105e-05
R4133 3729 3730 1.712 0.8 13.696 37
I3730 3730 0 1.26158e-05
R4134 3730 3731 1.712 0.8 13.696 37
I3731 3731 0 1.28631e-05
R4135 3731 3732 1.744 0.8 13.952 37
I3732 3732 0 1.23684e-05
R4136 3732 3733 1.664 0.8 13.312 37
I3733 3733 0 1.32342e-05
R4137 3733 3734 1.696 0.8 13.568 37
I3734 3734 0 1.33579e-05
R4138 3734 3735 1.632 0.8 13.056 37
I3735 3735 0 1.29868e-05
R4139 3735 3736 1.6 0.8 12.8 37
I3736 3736 0 1.31105e-05
R4140 3736 3737 1.68 0.8 13.44 37
I3737 3737 0 1.24921e-05
R4141 3737 3738 1.712 0.8 13.696 37
I3738 3738 0 1.27395e-05
R4142 3738 3739 1.632 0.8 13.056 37
I3739 3739 0 1.34816e-05
R4143 3739 3740 1.664 0.8 13.312 37
I3740 3740 0 1.23684e-05
R4144 3740 3741 1.712 0.8 13.696 37
I3741 3741 0 1.34816e-05
R4145 3741 3742 1.632 0.8 13.056 37
I3742 3742 0 1.32342e-05
R4146 3742 3743 1.696 0.8 13.568 37
I3743 3743 0 1.26158e-05
R4147 3743 3744 1.632 0.8 13.056 37
I3744 3744 0 1.32342e-05
R4148 3744 3745 1.728 0.8 13.824 37
I3745 3745 0 1.34816e-05
R4149 3745 3746 1.616 0.8 12.928 37
I3746 3746 0 1.32342e-05
R4150 3746 3747 1.68 0.8 13.44 37
I3747 3747 0 1.23684e-05
R4151 3747 3748 1.728 0.8 13.824 37
I3748 3748 0 1.26158e-05
R4152 3748 3749 1.6 0.8 12.8 37
I3749 3749 0 1.28631e-05
R4153 3749 3750 1.6 0.8 12.8 37
I3750 3750 0 1.26158e-05
R4154 3750 3751 1.744 0.8 13.952 37
I3751 3751 0 1.23684e-05
R4155 3751 3752 1.6 0.8 12.8 37
I3752 3752 0 1.31105e-05
R4156 3752 3753 1.664 0.8 13.312 37
I3753 3753 0 1.32342e-05
R4157 3753 3754 1.632 0.8 13.056 37
I3754 3754 0 1.31105e-05
R4158 3754 3755 1.696 0.8 13.568 37
I3755 3755 0 1.31105e-05
R4159 3755 3756 1.728 0.8 13.824 37
I3756 3756 0 1.28631e-05
R4160 3756 3757 1.712 0.8 13.696 37
I3757 3757 0 1.24921e-05
R4161 3757 3758 1.616 0.8 12.928 37
I3758 3758 0 1.27395e-05
R4162 3758 3759 1.68 0.8 13.44 37
I3759 3759 0 1.27395e-05
R4163 3759 3760 1.6 0.8 12.8 37
I3760 3760 0 1.29868e-05
R4164 3760 3761 1.68 0.8 13.44 37
I3761 3761 0 1.28631e-05
R4165 3761 3762 1.632 0.8 13.056 37
I3762 3762 0 1.26158e-05
R4166 3762 3763 1.696 0.8 13.568 37
I3763 3763 0 1.26158e-05
R4167 3763 3764 1.664 0.8 13.312 37
I3764 3764 0 1.31105e-05
R4168 3764 3765 1.728 0.8 13.824 37
I3765 3765 0 1.28631e-05
R4169 3765 3766 1.6 0.8 12.8 37
I3766 3766 0 1.23684e-05
R4170 3766 3767 1.712 0.8 13.696 37
I3767 3767 0 1.23684e-05
R4171 3767 3768 1.696 0.8 13.568 37
I3768 3768 0 1.24921e-05
R4172 3768 3769 1.728 0.8 13.824 37
I3769 3769 0 1.23684e-05
R4173 3769 3770 1.744 0.8 13.952 37
I3770 3770 0 1.31105e-05
R4174 3770 3771 1.696 0.8 13.568 37
I3771 3771 0 1.33579e-05
R4175 3771 3772 1.6 0.8 12.8 37
I3772 3772 0 1.28631e-05
R4176 3772 3773 1.616 0.8 12.928 37
I3773 3773 0 1.28631e-05
R4177 3773 3774 1.712 0.8 13.696 37
I3774 3774 0 1.33579e-05
R4178 3774 3775 1.744 0.8 13.952 37
I3775 3775 0 1.23684e-05
R4179 3775 3776 1.648 0.8 13.184 37
I3776 3776 0 1.31105e-05
R4180 3776 3777 1.696 0.8 13.568 37
I3777 3777 0 1.29868e-05
R4181 3777 3778 1.744 0.8 13.952 37
I3778 3778 0 1.26158e-05
R4182 3778 3779 1.6 0.8 12.8 37
I3779 3779 0 1.27395e-05
R4183 3779 3780 1.616 0.8 12.928 37
I3780 3780 0 1.33579e-05
R4184 3780 3781 1.6 0.8 12.8 37
I3781 3781 0 1.24921e-05
R4185 3781 3782 1.728 0.8 13.824 37
I3782 3782 0 1.34816e-05
R4186 3782 3783 1.664 0.8 13.312 37
I3783 3783 0 1.32342e-05
R4187 3783 3784 1.6 0.8 12.8 37
I3784 3784 0 1.28631e-05
R4188 3784 3785 1.712 0.8 13.696 37
I3785 3785 0 1.24921e-05
R4189 3785 3786 1.6 0.8 12.8 37
I3786 3786 0 1.28631e-05
R4190 3786 3787 1.616 0.8 12.928 37
I3787 3787 0 1.24921e-05
R4191 3787 3788 1.6 0.8 12.8 37
I3788 3788 0 1.28631e-05
R4192 3788 3789 1.712 0.8 13.696 37
I3789 3789 0 1.34816e-05
R4193 3789 3790 1.632 0.8 13.056 37
I3790 3790 0 1.31105e-05
R4194 3790 3791 1.744 0.8 13.952 37
I3791 3791 0 1.29868e-05
R4195 3791 3792 1.68 0.8 13.44 37
I3792 3792 0 1.29868e-05
R4196 3792 3793 1.648 0.8 13.184 37
I3793 3793 0 1.28631e-05
R4197 3793 3794 1.6 0.8 12.8 37
I3794 3794 0 1.27395e-05
R4198 3794 3795 1.744 0.8 13.952 37
I3795 3795 0 1.24921e-05
R4199 3795 3796 1.648 0.8 13.184 37
I3796 3796 0 1.24921e-05
R4200 3796 3797 1.632 0.8 13.056 37
I3797 3797 0 1.26158e-05
R4201 3797 3798 1.6 0.8 12.8 37
I3798 3798 0 1.33579e-05
R4202 3798 3799 1.616 0.8 12.928 37
I3799 3799 0 1.26158e-05
R4203 3799 3800 1.632 0.8 13.056 37
I3800 3800 0 1.33579e-05
R4204 3800 3801 1.696 0.8 13.568 37
I3801 3801 0 1.27395e-05
R4205 3801 3802 1.664 0.8 13.312 37
I3802 3802 0 1.32342e-05
R4206 3802 3803 1.696 0.8 13.568 37
I3803 3803 0 1.31105e-05
R4207 3803 3804 1.632 0.8 13.056 37
I3804 3804 0 1.27395e-05
R4208 3804 3805 1.696 0.8 13.568 37
I3805 3805 0 1.28631e-05
R4209 3805 3806 1.616 0.8 12.928 37
I3806 3806 0 1.29868e-05
R4210 3806 3807 1.632 0.8 13.056 37
I3807 3807 0 1.31105e-05
R4211 3807 3808 1.648 0.8 13.184 37
I3808 3808 0 1.32342e-05
R4212 3808 3809 1.632 0.8 13.056 37
I3809 3809 0 1.27395e-05
R4213 3809 3810 1.6 0.8 12.8 37
I3810 3810 0 1.28631e-05
R4214 3810 3811 1.664 0.8 13.312 37
I3811 3811 0 1.29868e-05
R4215 3811 3812 1.712 0.8 13.696 37
I3812 3812 0 1.33579e-05
R4216 3812 3813 1.744 0.8 13.952 37
I3813 3813 0 1.33579e-05
R4217 3813 3814 1.712 0.8 13.696 37
I3814 3814 0 1.23684e-05
R4218 3814 3815 1.632 0.8 13.056 37
I3815 3815 0 1.24921e-05
R4219 3815 3816 1.744 0.8 13.952 37
I3816 3816 0 1.33579e-05
R4220 3816 3817 1.664 0.8 13.312 37
I3817 3817 0 1.29868e-05
R4221 3817 3818 1.728 0.8 13.824 37
I3818 3818 0 1.23684e-05
R4222 3818 3819 1.632 0.8 13.056 37
I3819 3819 0 1.23684e-05
R4223 3819 3820 1.68 0.8 13.44 37
I3820 3820 0 1.33579e-05
R4224 3820 3821 1.696 0.8 13.568 37
I3821 3821 0 1.32342e-05
R4225 3821 3822 1.68 0.8 13.44 37
I3822 3822 0 1.23684e-05
R4226 3822 3823 1.68 0.8 13.44 37
I3823 3823 0 1.33579e-05
R4227 3823 3824 1.712 0.8 13.696 37
I3824 3824 0 1.23684e-05
R4228 3824 3825 1.648 0.8 13.184 37
I3825 3825 0 1.34816e-05
R4229 3825 3826 1.696 0.8 13.568 37
I3826 3826 0 1.32342e-05
R4230 3826 3827 1.68 0.8 13.44 37
I3827 3827 0 1.27395e-05
R4231 3827 3828 1.728 0.8 13.824 37
I3828 3828 0 1.28631e-05
R4232 3828 3829 1.648 0.8 13.184 37
I3829 3829 0 1.32342e-05
R4233 3829 3830 1.68 0.8 13.44 37
I3830 3830 0 1.31105e-05
R4234 3830 3831 1.728 0.8 13.824 37
I3831 3831 0 1.31105e-05
R4235 3831 3832 1.696 0.8 13.568 37
I3832 3832 0 1.27395e-05
R4236 3832 3833 1.648 0.8 13.184 37
I3833 3833 0 1.28631e-05
R4237 3833 3834 1.68 0.8 13.44 37
I3834 3834 0 1.29868e-05
R4238 3834 3835 1.696 0.8 13.568 37
I3835 3835 0 1.24921e-05
R4239 3835 3836 1.68 0.8 13.44 37
I3836 3836 0 1.29868e-05
R4240 3836 3837 1.6 0.8 12.8 37
I3837 3837 0 1.24921e-05
R4241 3837 3838 1.68 0.8 13.44 37
I3838 3838 0 1.32342e-05
R4242 3838 3839 1.616 0.8 12.928 37
I3839 3839 0 1.27395e-05
R4243 3839 3840 1.712 0.8 13.696 37
I3840 3840 0 1.29868e-05
R4244 3840 3841 1.664 0.8 13.312 37
I3841 3841 0 1.29868e-05
R4245 3841 3842 1.632 0.8 13.056 37
I3842 3842 0 1.34816e-05
R4246 3842 3843 1.744 0.8 13.952 37
I3843 3843 0 1.26158e-05
R4247 3843 3844 1.696 0.8 13.568 37
I3844 3844 0 1.26158e-05
R4248 3844 3845 1.744 0.8 13.952 37
I3845 3845 0 1.27395e-05
R4249 3845 3846 1.6 0.8 12.8 37
I3846 3846 0 1.33579e-05
R4250 3846 3847 1.744 0.8 13.952 37
I3847 3847 0 1.32342e-05
R4251 3847 3848 1.648 0.8 13.184 37
I3848 3848 0 1.26158e-05
R4252 3848 3849 1.648 0.8 13.184 37
I3849 3849 0 1.33579e-05
R4253 3849 3850 1.6 0.8 12.8 37
I3850 3850 0 1.23684e-05
R4254 3850 3851 1.744 0.8 13.952 37
I3851 3851 0 1.29868e-05
R4255 3851 3852 1.712 0.8 13.696 37
I3852 3852 0 1.34816e-05
R4256 3852 3853 1.696 0.8 13.568 37
I3853 3853 0 1.26158e-05
R4257 3853 3854 1.712 0.8 13.696 37
I3854 3854 0 1.33579e-05
R4258 3854 3855 1.712 0.8 13.696 37
I3855 3855 0 1.31105e-05
R4259 3855 3856 1.68 0.8 13.44 37
I3856 3856 0 1.28631e-05
R4260 3856 3857 1.632 0.8 13.056 37
I3857 3857 0 1.32342e-05
R4261 3857 3858 1.648 0.8 13.184 37
I3858 3858 0 1.27395e-05
R4262 3858 3859 1.632 0.8 13.056 37
I3859 3859 0 1.24921e-05
R4263 3859 3860 1.68 0.8 13.44 37
I3860 3860 0 1.24921e-05
R4264 3860 3861 1.664 0.8 13.312 37
I3861 3861 0 1.33579e-05
R4265 3861 3862 1.616 0.8 12.928 37
I3862 3862 0 1.27395e-05
R4266 3862 3863 1.712 0.8 13.696 37
I3863 3863 0 1.28631e-05
R4267 3863 3864 1.728 0.8 13.824 37
I3864 3864 0 1.26158e-05
R4268 3864 3865 1.648 0.8 13.184 37
I3865 3865 0 1.23684e-05
R4269 3865 3866 1.664 0.8 13.312 37
I3866 3866 0 1.28631e-05
R4270 3866 3867 1.68 0.8 13.44 37
I3867 3867 0 1.24921e-05
R4271 3867 3868 1.696 0.8 13.568 37
I3868 3868 0 1.28631e-05
R4272 3868 3869 1.696 0.8 13.568 37
I3869 3869 0 1.27395e-05
R4273 3869 3870 1.664 0.8 13.312 37
I3870 3870 0 1.27395e-05
R4274 3870 3871 1.616 0.8 12.928 37
I3871 3871 0 1.34816e-05
R4275 3871 3872 1.744 0.8 13.952 37
I3872 3872 0 1.29868e-05
R4276 3872 3873 1.728 0.8 13.824 37
I3873 3873 0 1.27395e-05
R4277 3873 3874 1.728 0.8 13.824 37
I3874 3874 0 1.23684e-05
R4278 3874 3875 1.664 0.8 13.312 37
I3875 3875 0 1.31105e-05
R4279 3875 3876 1.664 0.8 13.312 37
I3876 3876 0 1.24921e-05
R4280 3876 3877 1.664 0.8 13.312 37
I3877 3877 0 1.29868e-05
R4281 3877 3878 1.664 0.8 13.312 37
I3878 3878 0 1.27395e-05
R4282 3878 3879 1.6 0.8 12.8 37
I3879 3879 0 1.28631e-05
R4283 3879 3880 1.68 0.8 13.44 37
I3880 3880 0 1.29868e-05
R4284 3880 3881 1.664 0.8 13.312 37
I3881 3881 0 1.23684e-05
R4285 3881 3882 1.744 0.8 13.952 37
I3882 3882 0 1.26158e-05
R4286 3882 3883 1.616 0.8 12.928 37
I3883 3883 0 1.29868e-05
R4287 3883 3884 1.696 0.8 13.568 37
I3884 3884 0 1.32342e-05
R4288 3884 3885 1.6 0.8 12.8 37
I3885 3885 0 1.26158e-05
R4289 3885 3886 1.648 0.8 13.184 37
I3886 3886 0 1.28631e-05
R4290 3886 3887 1.616 0.8 12.928 37
I3887 3887 0 1.26158e-05
R4291 3887 3888 1.744 0.8 13.952 37
I3888 3888 0 1.24921e-05
R4292 3888 3889 1.712 0.8 13.696 37
I3889 3889 0 1.33579e-05
R4293 3889 3890 1.632 0.8 13.056 37
I3890 3890 0 1.28631e-05
R4294 3890 3891 1.696 0.8 13.568 37
I3891 3891 0 1.33579e-05
R4295 3891 3892 1.68 0.8 13.44 37
I3892 3892 0 1.26158e-05
R4296 3892 3893 1.648 0.8 13.184 37
I3893 3893 0 1.24921e-05
R4297 3893 3894 1.68 0.8 13.44 37
I3894 3894 0 1.29868e-05
R4298 3894 3895 1.728 0.8 13.824 37
I3895 3895 0 1.26158e-05
R4299 3895 3896 1.6 0.8 12.8 37
I3896 3896 0 1.28631e-05
R4300 3896 3897 1.632 0.8 13.056 37
I3897 3897 0 1.23684e-05
R4301 3897 3898 1.696 0.8 13.568 37
I3898 3898 0 1.31105e-05
R4302 3898 3899 1.712 0.8 13.696 37
I3899 3899 0 1.28631e-05
R4303 3899 3900 1.68 0.8 13.44 37
I3900 3900 0 1.33579e-05
R4304 3900 3901 1.696 0.8 13.568 37
I3901 3901 0 1.23684e-05
R4305 3901 3902 1.632 0.8 13.056 37
I3902 3902 0 1.34816e-05
R4306 3902 3903 1.68 0.8 13.44 37
I3903 3903 0 1.27395e-05
R4307 3903 3904 1.616 0.8 12.928 37
I3904 3904 0 1.28631e-05
R4308 3904 3905 1.648 0.8 13.184 37
I3905 3905 0 1.29868e-05
R4309 3905 3906 1.728 0.8 13.824 37
I3906 3906 0 1.34816e-05
R4310 3906 3907 1.648 0.8 13.184 37
I3907 3907 0 1.29868e-05
R4311 3907 3908 1.616 0.8 12.928 37
I3908 3908 0 1.33579e-05
R4312 3908 3909 1.744 0.8 13.952 37
I3909 3909 0 1.33579e-05
R4313 3909 3910 1.664 0.8 13.312 37
I3910 3910 0 1.34816e-05
R4314 3910 3911 1.648 0.8 13.184 37
I3911 3911 0 1.28631e-05
R4315 3911 3912 1.648 0.8 13.184 37
I3912 3912 0 1.29868e-05
R4316 3912 3913 1.696 0.8 13.568 37
I3913 3913 0 1.23684e-05
R4317 3913 3914 1.648 0.8 13.184 37
I3914 3914 0 1.28631e-05
R4318 3914 3915 1.696 0.8 13.568 37
I3915 3915 0 1.24921e-05
R4319 3915 3916 1.664 0.8 13.312 37
I3916 3916 0 1.27395e-05
R4320 3916 3917 1.616 0.8 12.928 37
I3917 3917 0 1.33579e-05
R4321 3917 3918 1.664 0.8 13.312 37
I3918 3918 0 1.33579e-05
R4322 3918 3919 1.648 0.8 13.184 37
I3919 3919 0 1.29868e-05
R4323 3919 3920 1.648 0.8 13.184 37
I3920 3920 0 1.32342e-05
R4324 3920 3921 1.632 0.8 13.056 37
I3921 3921 0 1.27395e-05
R4325 3921 3922 1.728 0.8 13.824 37
I3922 3922 0 1.32342e-05
R4326 3922 3923 1.616 0.8 12.928 37
I3923 3923 0 1.26158e-05
R4327 3923 3924 1.696 0.8 13.568 37
I3924 3924 0 1.23684e-05
R4328 3924 3925 1.6 0.8 12.8 37
I3925 3925 0 1.23684e-05
R4329 3925 3926 1.744 0.8 13.952 37
I3926 3926 0 1.27395e-05
R4330 3926 3927 1.696 0.8 13.568 37
I3927 3927 0 1.28631e-05
R4331 3927 3928 1.616 0.8 12.928 37
I3928 3928 0 1.29868e-05
R4332 3928 3929 1.664 0.8 13.312 37
I3929 3929 0 1.31105e-05
R4333 3929 3930 1.744 0.8 13.952 37
I3930 3930 0 1.24921e-05
R4334 3930 3931 1.712 0.8 13.696 37
I3931 3931 0 1.29868e-05
R4335 3931 3932 1.696 0.8 13.568 37
I3932 3932 0 1.24921e-05
R4336 3932 3933 1.68 0.8 13.44 37
I3933 3933 0 1.23684e-05
R4337 3933 3934 1.744 0.8 13.952 37
I3934 3934 0 1.33579e-05
R4338 3934 3935 1.728 0.8 13.824 37
I3935 3935 0 1.26158e-05
R4339 3935 3936 1.68 0.8 13.44 37
I3936 3936 0 1.26158e-05
R4340 3936 3937 1.696 0.8 13.568 37
I3937 3937 0 1.28631e-05
R4341 3937 3938 1.6 0.8 12.8 37
I3938 3938 0 1.32342e-05
R4342 3938 3939 1.696 0.8 13.568 37
I3939 3939 0 1.33579e-05
R4343 3939 3940 1.744 0.8 13.952 37
I3940 3940 0 1.33579e-05
R4344 3940 3941 1.6 0.8 12.8 37
I3941 3941 0 1.23684e-05
R4345 3941 3942 1.664 0.8 13.312 37
I3942 3942 0 1.31105e-05
R4346 3942 3943 1.664 0.8 13.312 37
I3943 3943 0 1.32342e-05
R4347 3943 3944 1.648 0.8 13.184 37
I3944 3944 0 1.24921e-05
R4348 3944 3945 1.648 0.8 13.184 37
I3945 3945 0 1.26158e-05
R4349 3945 3946 1.664 0.8 13.312 37
I3946 3946 0 1.24921e-05
R4350 3946 3947 1.744 0.8 13.952 37
I3947 3947 0 1.26158e-05
R4351 3947 3948 1.632 0.8 13.056 37
I3948 3948 0 1.28631e-05
R4352 3948 3949 1.632 0.8 13.056 37
I3949 3949 0 1.24921e-05
R4353 3949 3950 1.648 0.8 13.184 37
I3950 3950 0 1.26158e-05
R4354 3950 3951 1.696 0.8 13.568 37
I3951 3951 0 1.33579e-05
R4355 3951 3952 1.68 0.8 13.44 37
I3952 3952 0 1.28631e-05
R4356 3952 3953 1.664 0.8 13.312 37
I3953 3953 0 1.32342e-05
R4357 3953 3954 1.648 0.8 13.184 37
I3954 3954 0 1.26158e-05
R4358 3954 3955 1.68 0.8 13.44 37
I3955 3955 0 1.26158e-05
R4359 3955 3956 1.616 0.8 12.928 37
I3956 3956 0 1.29868e-05
R4360 3956 3957 1.664 0.8 13.312 37
I3957 3957 0 1.32342e-05
R4361 3957 3958 1.648 0.8 13.184 37
I3958 3958 0 1.33579e-05
R4362 3958 3959 1.664 0.8 13.312 37
I3959 3959 0 1.32342e-05
R4363 3959 3960 1.616 0.8 12.928 37
I3960 3960 0 1.32342e-05
R4364 3960 3961 1.616 0.8 12.928 37
I3961 3961 0 1.29868e-05
R4365 3961 3962 1.6 0.8 12.8 37
I3962 3962 0 1.24921e-05
R4366 3962 3963 1.744 0.8 13.952 37
I3963 3963 0 1.28631e-05
R4367 3963 3964 1.712 0.8 13.696 37
I3964 3964 0 1.26158e-05
R4368 3964 3965 1.728 0.8 13.824 37
I3965 3965 0 1.23684e-05
R4369 3965 3966 1.696 0.8 13.568 37
I3966 3966 0 1.28631e-05
R4370 3966 3967 1.616 0.8 12.928 37
I3967 3967 0 1.27395e-05
R4371 3967 3968 1.6 0.8 12.8 37
I3968 3968 0 1.32342e-05
R4372 3968 3969 1.6 0.8 12.8 37
I3969 3969 0 1.27395e-05
R4373 3969 3970 1.6 0.8 12.8 37
I3970 3970 0 1.29868e-05
R4374 3970 3971 1.712 0.8 13.696 37
I3971 3971 0 1.27395e-05
R4375 3971 3972 1.632 0.8 13.056 37
I3972 3972 0 1.24921e-05
R4376 3972 3973 1.6 0.8 12.8 37
I3973 3973 0 1.33579e-05
R4377 3973 3974 1.616 0.8 12.928 37
I3974 3974 0 1.31105e-05
R4378 3974 3975 1.712 0.8 13.696 37
I3975 3975 0 1.29868e-05
R4379 3975 3976 1.68 0.8 13.44 37
I3976 3976 0 1.23684e-05
R4380 3976 3977 1.632 0.8 13.056 37
I3977 3977 0 1.31105e-05
R4381 3977 3978 1.648 0.8 13.184 37
I3978 3978 0 1.26158e-05
R4382 3978 3979 1.6 0.8 12.8 37
I3979 3979 0 1.24921e-05
R4383 3979 3980 1.696 0.8 13.568 37
I3980 3980 0 1.23684e-05
R4384 3980 3981 1.648 0.8 13.184 37
I3981 3981 0 1.26158e-05
R4385 3981 3982 1.696 0.8 13.568 37
I3982 3982 0 1.28631e-05
R4386 3982 3983 1.696 0.8 13.568 37
I3983 3983 0 1.31105e-05
R4387 3983 3984 1.664 0.8 13.312 37
I3984 3984 0 1.31105e-05
R4388 3984 3985 1.744 0.8 13.952 37
I3985 3985 0 1.28631e-05
R4389 3985 3986 1.664 0.8 13.312 37
I3986 3986 0 1.31105e-05
R4390 3986 3987 1.744 0.8 13.952 37
I3987 3987 0 1.33579e-05
R4391 3987 3988 1.744 0.8 13.952 37
I3988 3988 0 1.34816e-05
R4392 3988 3989 1.728 0.8 13.824 37
I3989 3989 0 1.27395e-05
R4393 3989 3990 1.68 0.8 13.44 37
I3990 3990 0 1.29868e-05
R4394 3990 3991 1.728 0.8 13.824 37
I3991 3991 0 1.23684e-05
R4395 3991 3992 1.728 0.8 13.824 37
I3992 3992 0 1.26158e-05
R4396 3992 3993 1.728 0.8 13.824 37
I3993 3993 0 1.24921e-05
R4397 3993 3994 1.664 0.8 13.312 37
I3994 3994 0 1.24921e-05
R4398 3994 3995 1.632 0.8 13.056 37
I3995 3995 0 1.23684e-05
R4399 3995 3996 1.616 0.8 12.928 37
I3996 3996 0 1.33579e-05
R4400 3996 3997 1.648 0.8 13.184 37
I3997 3997 0 1.33579e-05
R4401 3997 3998 1.664 0.8 13.312 37
I3998 3998 0 1.24921e-05
R4402 3998 3999 1.664 0.8 13.312 37
I3999 3999 0 1.33579e-05
R4403 3999 4000 1.712 0.8 13.696 37
I4000 4000 0 1.23684e-05
R4404 4000 10001 0.5 10 50 37
*seg: 5
* inter-segment connection
R4405 4010 5010 6.16 0.8 49.28 37
R4406 4020 5020 6.16 0.8 49.28 37
R4407 4030 5030 6.16 0.8 49.28 37
R4408 4040 5040 6.16 0.8 49.28 37
R4409 4050 5050 6.16 0.8 49.28 37
R4410 4060 5060 6.16 0.8 49.28 37
R4411 4070 5070 6.16 0.8 49.28 37
R4412 4080 5080 6.16 0.8 49.28 37
R4413 4090 5090 6.16 0.8 49.28 37
R4414 4100 5100 6.16 0.8 49.28 37
R4415 4110 5110 6.16 0.8 49.28 37
R4416 4120 5120 6.16 0.8 49.28 37
R4417 4130 5130 6.16 0.8 49.28 37
R4418 4140 5140 6.16 0.8 49.28 37
R4419 4150 5150 6.16 0.8 49.28 37
R4420 4160 5160 6.16 0.8 49.28 37
R4421 4170 5170 6.16 0.8 49.28 37
R4422 4180 5180 6.16 0.8 49.28 37
R4423 4190 5190 6.16 0.8 49.28 37
R4424 4200 5200 6.16 0.8 49.28 37
R4425 4210 5210 6.16 0.8 49.28 37
R4426 4220 5220 6.16 0.8 49.28 37
R4427 4230 5230 6.16 0.8 49.28 37
R4428 4240 5240 6.16 0.8 49.28 37
R4429 4250 5250 6.16 0.8 49.28 37
R4430 4260 5260 6.16 0.8 49.28 37
R4431 4270 5270 6.16 0.8 49.28 37
R4432 4280 5280 6.16 0.8 49.28 37
R4433 4290 5290 6.16 0.8 49.28 37
R4434 4300 5300 6.16 0.8 49.28 37
R4435 4310 5310 6.16 0.8 49.28 37
R4436 4320 5320 6.16 0.8 49.28 37
R4437 4330 5330 6.16 0.8 49.28 37
R4438 4340 5340 6.16 0.8 49.28 37
R4439 4350 5350 6.16 0.8 49.28 37
R4440 4360 5360 6.16 0.8 49.28 37
R4441 4370 5370 6.16 0.8 49.28 37
R4442 4380 5380 6.16 0.8 49.28 37
R4443 4390 5390 6.16 0.8 49.28 37
R4444 4400 5400 6.16 0.8 49.28 37
R4445 4410 5410 6.16 0.8 49.28 37
R4446 4420 5420 6.16 0.8 49.28 37
R4447 4430 5430 6.16 0.8 49.28 37
R4448 4440 5440 6.16 0.8 49.28 37
R4449 4450 5450 6.16 0.8 49.28 37
R4450 4460 5460 6.16 0.8 49.28 37
R4451 4470 5470 6.16 0.8 49.28 37
R4452 4480 5480 6.16 0.8 49.28 37
R4453 4490 5490 6.16 0.8 49.28 37
R4454 4500 5500 6.16 0.8 49.28 37
R4455 4510 5510 6.16 0.8 49.28 37
R4456 4520 5520 6.16 0.8 49.28 37
R4457 4530 5530 6.16 0.8 49.28 37
R4458 4540 5540 6.16 0.8 49.28 37
R4459 4550 5550 6.16 0.8 49.28 37
R4460 4560 5560 6.16 0.8 49.28 37
R4461 4570 5570 6.16 0.8 49.28 37
R4462 4580 5580 6.16 0.8 49.28 37
R4463 4590 5590 6.16 0.8 49.28 37
R4464 4600 5600 6.16 0.8 49.28 37
R4465 4610 5610 6.16 0.8 49.28 37
R4466 4620 5620 6.16 0.8 49.28 37
R4467 4630 5630 6.16 0.8 49.28 37
R4468 4640 5640 6.16 0.8 49.28 37
R4469 4650 5650 6.16 0.8 49.28 37
R4470 4660 5660 6.16 0.8 49.28 37
R4471 4670 5670 6.16 0.8 49.28 37
R4472 4680 5680 6.16 0.8 49.28 37
R4473 4690 5690 6.16 0.8 49.28 37
R4474 4700 5700 6.16 0.8 49.28 37
R4475 4710 5710 6.16 0.8 49.28 37
R4476 4720 5720 6.16 0.8 49.28 37
R4477 4730 5730 6.16 0.8 49.28 37
R4478 4740 5740 6.16 0.8 49.28 37
R4479 4750 5750 6.16 0.8 49.28 37
R4480 4760 5760 6.16 0.8 49.28 37
R4481 4770 5770 6.16 0.8 49.28 37
R4482 4780 5780 6.16 0.8 49.28 37
R4483 4790 5790 6.16 0.8 49.28 37
R4484 4800 5800 6.16 0.8 49.28 37
R4485 4810 5810 6.16 0.8 49.28 37
R4486 4820 5820 6.16 0.8 49.28 37
R4487 4830 5830 6.16 0.8 49.28 37
R4488 4840 5840 6.16 0.8 49.28 37
R4489 4850 5850 6.16 0.8 49.28 37
R4490 4860 5860 6.16 0.8 49.28 37
R4491 4870 5870 6.16 0.8 49.28 37
R4492 4880 5880 6.16 0.8 49.28 37
R4493 4890 5890 6.16 0.8 49.28 37
R4494 4900 5900 6.16 0.8 49.28 37
R4495 4910 5910 6.16 0.8 49.28 37
R4496 4920 5920 6.16 0.8 49.28 37
R4497 4930 5930 6.16 0.8 49.28 37
R4498 4940 5940 6.16 0.8 49.28 37
R4499 4950 5950 6.16 0.8 49.28 37
R4500 4960 5960 6.16 0.8 49.28 37
R4501 4970 5970 6.16 0.8 49.28 37
R4502 4980 5980 6.16 0.8 49.28 37
R4503 4990 5990 6.16 0.8 49.28 37
R4504 5000 6000 6.16 0.8 49.28 37
R4505 10001 4001 0.4 20 80 37
I4001 4001 0 1.31105e-05
R4506 4001 4002 1.632 0.8 13.056 37
I4002 4002 0 1.27395e-05
R4507 4002 4003 1.664 0.8 13.312 37
I4003 4003 0 1.27395e-05
R4508 4003 4004 1.664 0.8 13.312 37
I4004 4004 0 1.31105e-05
R4509 4004 4005 1.632 0.8 13.056 37
I4005 4005 0 1.26158e-05
R4510 4005 4006 1.616 0.8 12.928 37
I4006 4006 0 1.34816e-05
R4511 4006 4007 1.6 0.8 12.8 37
I4007 4007 0 1.24921e-05
R4512 4007 4008 1.632 0.8 13.056 37
I4008 4008 0 1.33579e-05
R4513 4008 4009 1.648 0.8 13.184 37
I4009 4009 0 1.26158e-05
R4514 4009 4010 1.744 0.8 13.952 37
I4010 4010 0 1.33579e-05
R4515 4010 4011 1.648 0.8 13.184 37
I4011 4011 0 1.28631e-05
R4516 4011 4012 1.728 0.8 13.824 37
I4012 4012 0 1.32342e-05
R4517 4012 4013 1.664 0.8 13.312 37
I4013 4013 0 1.27395e-05
R4518 4013 4014 1.712 0.8 13.696 37
I4014 4014 0 1.33579e-05
R4519 4014 4015 1.664 0.8 13.312 37
I4015 4015 0 1.27395e-05
R4520 4015 4016 1.712 0.8 13.696 37
I4016 4016 0 1.28631e-05
R4521 4016 4017 1.616 0.8 12.928 37
I4017 4017 0 1.24921e-05
R4522 4017 4018 1.744 0.8 13.952 37
I4018 4018 0 1.31105e-05
R4523 4018 4019 1.68 0.8 13.44 37
I4019 4019 0 1.27395e-05
R4524 4019 4020 1.664 0.8 13.312 37
I4020 4020 0 1.34816e-05
R4525 4020 4021 1.696 0.8 13.568 37
I4021 4021 0 1.29868e-05
R4526 4021 4022 1.616 0.8 12.928 37
I4022 4022 0 1.31105e-05
R4527 4022 4023 1.696 0.8 13.568 37
I4023 4023 0 1.27395e-05
R4528 4023 4024 1.696 0.8 13.568 37
I4024 4024 0 1.34816e-05
R4529 4024 4025 1.712 0.8 13.696 37
I4025 4025 0 1.32342e-05
R4530 4025 4026 1.712 0.8 13.696 37
I4026 4026 0 1.27395e-05
R4531 4026 4027 1.616 0.8 12.928 37
I4027 4027 0 1.33579e-05
R4532 4027 4028 1.6 0.8 12.8 37
I4028 4028 0 1.29868e-05
R4533 4028 4029 1.616 0.8 12.928 37
I4029 4029 0 1.34816e-05
R4534 4029 4030 1.696 0.8 13.568 37
I4030 4030 0 1.33579e-05
R4535 4030 4031 1.632 0.8 13.056 37
I4031 4031 0 1.27395e-05
R4536 4031 4032 1.664 0.8 13.312 37
I4032 4032 0 1.31105e-05
R4537 4032 4033 1.696 0.8 13.568 37
I4033 4033 0 1.27395e-05
R4538 4033 4034 1.632 0.8 13.056 37
I4034 4034 0 1.24921e-05
R4539 4034 4035 1.712 0.8 13.696 37
I4035 4035 0 1.31105e-05
R4540 4035 4036 1.648 0.8 13.184 37
I4036 4036 0 1.27395e-05
R4541 4036 4037 1.616 0.8 12.928 37
I4037 4037 0 1.28631e-05
R4542 4037 4038 1.616 0.8 12.928 37
I4038 4038 0 1.32342e-05
R4543 4038 4039 1.744 0.8 13.952 37
I4039 4039 0 1.34816e-05
R4544 4039 4040 1.728 0.8 13.824 37
I4040 4040 0 1.31105e-05
R4545 4040 4041 1.696 0.8 13.568 37
I4041 4041 0 1.31105e-05
R4546 4041 4042 1.744 0.8 13.952 37
I4042 4042 0 1.23684e-05
R4547 4042 4043 1.696 0.8 13.568 37
I4043 4043 0 1.24921e-05
R4548 4043 4044 1.712 0.8 13.696 37
I4044 4044 0 1.34816e-05
R4549 4044 4045 1.632 0.8 13.056 37
I4045 4045 0 1.27395e-05
R4550 4045 4046 1.712 0.8 13.696 37
I4046 4046 0 1.32342e-05
R4551 4046 4047 1.728 0.8 13.824 37
I4047 4047 0 1.24921e-05
R4552 4047 4048 1.648 0.8 13.184 37
I4048 4048 0 1.29868e-05
R4553 4048 4049 1.68 0.8 13.44 37
I4049 4049 0 1.32342e-05
R4554 4049 4050 1.728 0.8 13.824 37
I4050 4050 0 1.28631e-05
R4555 4050 4051 1.648 0.8 13.184 37
I4051 4051 0 1.24921e-05
R4556 4051 4052 1.744 0.8 13.952 37
I4052 4052 0 1.31105e-05
R4557 4052 4053 1.68 0.8 13.44 37
I4053 4053 0 1.23684e-05
R4558 4053 4054 1.68 0.8 13.44 37
I4054 4054 0 1.31105e-05
R4559 4054 4055 1.616 0.8 12.928 37
I4055 4055 0 1.27395e-05
R4560 4055 4056 1.648 0.8 13.184 37
I4056 4056 0 1.32342e-05
R4561 4056 4057 1.616 0.8 12.928 37
I4057 4057 0 1.28631e-05
R4562 4057 4058 1.744 0.8 13.952 37
I4058 4058 0 1.32342e-05
R4563 4058 4059 1.728 0.8 13.824 37
I4059 4059 0 1.32342e-05
R4564 4059 4060 1.712 0.8 13.696 37
I4060 4060 0 1.26158e-05
R4565 4060 4061 1.632 0.8 13.056 37
I4061 4061 0 1.28631e-05
R4566 4061 4062 1.744 0.8 13.952 37
I4062 4062 0 1.24921e-05
R4567 4062 4063 1.728 0.8 13.824 37
I4063 4063 0 1.26158e-05
R4568 4063 4064 1.728 0.8 13.824 37
I4064 4064 0 1.29868e-05
R4569 4064 4065 1.744 0.8 13.952 37
I4065 4065 0 1.31105e-05
R4570 4065 4066 1.744 0.8 13.952 37
I4066 4066 0 1.28631e-05
R4571 4066 4067 1.728 0.8 13.824 37
I4067 4067 0 1.33579e-05
R4572 4067 4068 1.632 0.8 13.056 37
I4068 4068 0 1.29868e-05
R4573 4068 4069 1.6 0.8 12.8 37
I4069 4069 0 1.32342e-05
R4574 4069 4070 1.632 0.8 13.056 37
I4070 4070 0 1.24921e-05
R4575 4070 4071 1.616 0.8 12.928 37
I4071 4071 0 1.32342e-05
R4576 4071 4072 1.6 0.8 12.8 37
I4072 4072 0 1.28631e-05
R4577 4072 4073 1.648 0.8 13.184 37
I4073 4073 0 1.23684e-05
R4578 4073 4074 1.632 0.8 13.056 37
I4074 4074 0 1.27395e-05
R4579 4074 4075 1.744 0.8 13.952 37
I4075 4075 0 1.34816e-05
R4580 4075 4076 1.696 0.8 13.568 37
I4076 4076 0 1.24921e-05
R4581 4076 4077 1.68 0.8 13.44 37
I4077 4077 0 1.29868e-05
R4582 4077 4078 1.664 0.8 13.312 37
I4078 4078 0 1.29868e-05
R4583 4078 4079 1.6 0.8 12.8 37
I4079 4079 0 1.26158e-05
R4584 4079 4080 1.6 0.8 12.8 37
I4080 4080 0 1.24921e-05
R4585 4080 4081 1.744 0.8 13.952 37
I4081 4081 0 1.34816e-05
R4586 4081 4082 1.728 0.8 13.824 37
I4082 4082 0 1.34816e-05
R4587 4082 4083 1.712 0.8 13.696 37
I4083 4083 0 1.23684e-05
R4588 4083 4084 1.696 0.8 13.568 37
I4084 4084 0 1.34816e-05
R4589 4084 4085 1.728 0.8 13.824 37
I4085 4085 0 1.23684e-05
R4590 4085 4086 1.6 0.8 12.8 37
I4086 4086 0 1.24921e-05
R4591 4086 4087 1.712 0.8 13.696 37
I4087 4087 0 1.24921e-05
R4592 4087 4088 1.68 0.8 13.44 37
I4088 4088 0 1.27395e-05
R4593 4088 4089 1.648 0.8 13.184 37
I4089 4089 0 1.34816e-05
R4594 4089 4090 1.696 0.8 13.568 37
I4090 4090 0 1.26158e-05
R4595 4090 4091 1.6 0.8 12.8 37
I4091 4091 0 1.26158e-05
R4596 4091 4092 1.648 0.8 13.184 37
I4092 4092 0 1.33579e-05
R4597 4092 4093 1.6 0.8 12.8 37
I4093 4093 0 1.33579e-05
R4598 4093 4094 1.648 0.8 13.184 37
I4094 4094 0 1.26158e-05
R4599 4094 4095 1.632 0.8 13.056 37
I4095 4095 0 1.31105e-05
R4600 4095 4096 1.648 0.8 13.184 37
I4096 4096 0 1.24921e-05
R4601 4096 4097 1.712 0.8 13.696 37
I4097 4097 0 1.24921e-05
R4602 4097 4098 1.632 0.8 13.056 37
I4098 4098 0 1.29868e-05
R4603 4098 4099 1.664 0.8 13.312 37
I4099 4099 0 1.34816e-05
R4604 4099 4100 1.696 0.8 13.568 37
I4100 4100 0 1.26158e-05
R4605 4100 4101 1.744 0.8 13.952 37
I4101 4101 0 1.32342e-05
R4606 4101 4102 1.68 0.8 13.44 37
I4102 4102 0 1.34816e-05
R4607 4102 4103 1.6 0.8 12.8 37
I4103 4103 0 1.26158e-05
R4608 4103 4104 1.632 0.8 13.056 37
I4104 4104 0 1.27395e-05
R4609 4104 4105 1.632 0.8 13.056 37
I4105 4105 0 1.23684e-05
R4610 4105 4106 1.68 0.8 13.44 37
I4106 4106 0 1.28631e-05
R4611 4106 4107 1.68 0.8 13.44 37
I4107 4107 0 1.23684e-05
R4612 4107 4108 1.632 0.8 13.056 37
I4108 4108 0 1.32342e-05
R4613 4108 4109 1.6 0.8 12.8 37
I4109 4109 0 1.33579e-05
R4614 4109 4110 1.744 0.8 13.952 37
I4110 4110 0 1.27395e-05
R4615 4110 4111 1.664 0.8 13.312 37
I4111 4111 0 1.28631e-05
R4616 4111 4112 1.696 0.8 13.568 37
I4112 4112 0 1.24921e-05
R4617 4112 4113 1.728 0.8 13.824 37
I4113 4113 0 1.34816e-05
R4618 4113 4114 1.728 0.8 13.824 37
I4114 4114 0 1.26158e-05
R4619 4114 4115 1.6 0.8 12.8 37
I4115 4115 0 1.29868e-05
R4620 4115 4116 1.696 0.8 13.568 37
I4116 4116 0 1.24921e-05
R4621 4116 4117 1.664 0.8 13.312 37
I4117 4117 0 1.24921e-05
R4622 4117 4118 1.6 0.8 12.8 37
I4118 4118 0 1.28631e-05
R4623 4118 4119 1.68 0.8 13.44 37
I4119 4119 0 1.28631e-05
R4624 4119 4120 1.744 0.8 13.952 37
I4120 4120 0 1.32342e-05
R4625 4120 4121 1.68 0.8 13.44 37
I4121 4121 0 1.28631e-05
R4626 4121 4122 1.664 0.8 13.312 37
I4122 4122 0 1.26158e-05
R4627 4122 4123 1.696 0.8 13.568 37
I4123 4123 0 1.31105e-05
R4628 4123 4124 1.744 0.8 13.952 37
I4124 4124 0 1.32342e-05
R4629 4124 4125 1.664 0.8 13.312 37
I4125 4125 0 1.33579e-05
R4630 4125 4126 1.632 0.8 13.056 37
I4126 4126 0 1.23684e-05
R4631 4126 4127 1.664 0.8 13.312 37
I4127 4127 0 1.23684e-05
R4632 4127 4128 1.632 0.8 13.056 37
I4128 4128 0 1.26158e-05
R4633 4128 4129 1.744 0.8 13.952 37
I4129 4129 0 1.26158e-05
R4634 4129 4130 1.696 0.8 13.568 37
I4130 4130 0 1.24921e-05
R4635 4130 4131 1.712 0.8 13.696 37
I4131 4131 0 1.26158e-05
R4636 4131 4132 1.648 0.8 13.184 37
I4132 4132 0 1.24921e-05
R4637 4132 4133 1.68 0.8 13.44 37
I4133 4133 0 1.29868e-05
R4638 4133 4134 1.712 0.8 13.696 37
I4134 4134 0 1.24921e-05
R4639 4134 4135 1.6 0.8 12.8 37
I4135 4135 0 1.31105e-05
R4640 4135 4136 1.6 0.8 12.8 37
I4136 4136 0 1.32342e-05
R4641 4136 4137 1.632 0.8 13.056 37
I4137 4137 0 1.28631e-05
R4642 4137 4138 1.744 0.8 13.952 37
I4138 4138 0 1.34816e-05
R4643 4138 4139 1.616 0.8 12.928 37
I4139 4139 0 1.23684e-05
R4644 4139 4140 1.728 0.8 13.824 37
I4140 4140 0 1.32342e-05
R4645 4140 4141 1.728 0.8 13.824 37
I4141 4141 0 1.26158e-05
R4646 4141 4142 1.728 0.8 13.824 37
I4142 4142 0 1.28631e-05
R4647 4142 4143 1.632 0.8 13.056 37
I4143 4143 0 1.26158e-05
R4648 4143 4144 1.712 0.8 13.696 37
I4144 4144 0 1.28631e-05
R4649 4144 4145 1.664 0.8 13.312 37
I4145 4145 0 1.27395e-05
R4650 4145 4146 1.68 0.8 13.44 37
I4146 4146 0 1.28631e-05
R4651 4146 4147 1.696 0.8 13.568 37
I4147 4147 0 1.23684e-05
R4652 4147 4148 1.712 0.8 13.696 37
I4148 4148 0 1.27395e-05
R4653 4148 4149 1.696 0.8 13.568 37
I4149 4149 0 1.29868e-05
R4654 4149 4150 1.664 0.8 13.312 37
I4150 4150 0 1.33579e-05
R4655 4150 4151 1.648 0.8 13.184 37
I4151 4151 0 1.29868e-05
R4656 4151 4152 1.68 0.8 13.44 37
I4152 4152 0 1.31105e-05
R4657 4152 4153 1.616 0.8 12.928 37
I4153 4153 0 1.31105e-05
R4658 4153 4154 1.712 0.8 13.696 37
I4154 4154 0 1.28631e-05
R4659 4154 4155 1.696 0.8 13.568 37
I4155 4155 0 1.32342e-05
R4660 4155 4156 1.632 0.8 13.056 37
I4156 4156 0 1.31105e-05
R4661 4156 4157 1.744 0.8 13.952 37
I4157 4157 0 1.26158e-05
R4662 4157 4158 1.6 0.8 12.8 37
I4158 4158 0 1.24921e-05
R4663 4158 4159 1.664 0.8 13.312 37
I4159 4159 0 1.34816e-05
R4664 4159 4160 1.712 0.8 13.696 37
I4160 4160 0 1.23684e-05
R4665 4160 4161 1.648 0.8 13.184 37
I4161 4161 0 1.29868e-05
R4666 4161 4162 1.664 0.8 13.312 37
I4162 4162 0 1.24921e-05
R4667 4162 4163 1.68 0.8 13.44 37
I4163 4163 0 1.26158e-05
R4668 4163 4164 1.696 0.8 13.568 37
I4164 4164 0 1.27395e-05
R4669 4164 4165 1.744 0.8 13.952 37
I4165 4165 0 1.24921e-05
R4670 4165 4166 1.616 0.8 12.928 37
I4166 4166 0 1.26158e-05
R4671 4166 4167 1.728 0.8 13.824 37
I4167 4167 0 1.33579e-05
R4672 4167 4168 1.728 0.8 13.824 37
I4168 4168 0 1.34816e-05
R4673 4168 4169 1.696 0.8 13.568 37
I4169 4169 0 1.32342e-05
R4674 4169 4170 1.664 0.8 13.312 37
I4170 4170 0 1.28631e-05
R4675 4170 4171 1.664 0.8 13.312 37
I4171 4171 0 1.33579e-05
R4676 4171 4172 1.632 0.8 13.056 37
I4172 4172 0 1.27395e-05
R4677 4172 4173 1.6 0.8 12.8 37
I4173 4173 0 1.27395e-05
R4678 4173 4174 1.712 0.8 13.696 37
I4174 4174 0 1.31105e-05
R4679 4174 4175 1.664 0.8 13.312 37
I4175 4175 0 1.31105e-05
R4680 4175 4176 1.696 0.8 13.568 37
I4176 4176 0 1.32342e-05
R4681 4176 4177 1.616 0.8 12.928 37
I4177 4177 0 1.24921e-05
R4682 4177 4178 1.6 0.8 12.8 37
I4178 4178 0 1.34816e-05
R4683 4178 4179 1.68 0.8 13.44 37
I4179 4179 0 1.32342e-05
R4684 4179 4180 1.632 0.8 13.056 37
I4180 4180 0 1.28631e-05
R4685 4180 4181 1.6 0.8 12.8 37
I4181 4181 0 1.31105e-05
R4686 4181 4182 1.696 0.8 13.568 37
I4182 4182 0 1.23684e-05
R4687 4182 4183 1.696 0.8 13.568 37
I4183 4183 0 1.32342e-05
R4688 4183 4184 1.744 0.8 13.952 37
I4184 4184 0 1.29868e-05
R4689 4184 4185 1.696 0.8 13.568 37
I4185 4185 0 1.29868e-05
R4690 4185 4186 1.744 0.8 13.952 37
I4186 4186 0 1.24921e-05
R4691 4186 4187 1.68 0.8 13.44 37
I4187 4187 0 1.26158e-05
R4692 4187 4188 1.696 0.8 13.568 37
I4188 4188 0 1.29868e-05
R4693 4188 4189 1.712 0.8 13.696 37
I4189 4189 0 1.29868e-05
R4694 4189 4190 1.648 0.8 13.184 37
I4190 4190 0 1.24921e-05
R4695 4190 4191 1.632 0.8 13.056 37
I4191 4191 0 1.23684e-05
R4696 4191 4192 1.616 0.8 12.928 37
I4192 4192 0 1.27395e-05
R4697 4192 4193 1.648 0.8 13.184 37
I4193 4193 0 1.27395e-05
R4698 4193 4194 1.664 0.8 13.312 37
I4194 4194 0 1.33579e-05
R4699 4194 4195 1.632 0.8 13.056 37
I4195 4195 0 1.34816e-05
R4700 4195 4196 1.632 0.8 13.056 37
I4196 4196 0 1.28631e-05
R4701 4196 4197 1.68 0.8 13.44 37
I4197 4197 0 1.23684e-05
R4702 4197 4198 1.664 0.8 13.312 37
I4198 4198 0 1.27395e-05
R4703 4198 4199 1.744 0.8 13.952 37
I4199 4199 0 1.31105e-05
R4704 4199 4200 1.728 0.8 13.824 37
I4200 4200 0 1.31105e-05
R4705 4200 4201 1.616 0.8 12.928 37
I4201 4201 0 1.23684e-05
R4706 4201 4202 1.712 0.8 13.696 37
I4202 4202 0 1.32342e-05
R4707 4202 4203 1.664 0.8 13.312 37
I4203 4203 0 1.29868e-05
R4708 4203 4204 1.664 0.8 13.312 37
I4204 4204 0 1.24921e-05
R4709 4204 4205 1.616 0.8 12.928 37
I4205 4205 0 1.33579e-05
R4710 4205 4206 1.664 0.8 13.312 37
I4206 4206 0 1.27395e-05
R4711 4206 4207 1.728 0.8 13.824 37
I4207 4207 0 1.29868e-05
R4712 4207 4208 1.728 0.8 13.824 37
I4208 4208 0 1.27395e-05
R4713 4208 4209 1.616 0.8 12.928 37
I4209 4209 0 1.27395e-05
R4714 4209 4210 1.616 0.8 12.928 37
I4210 4210 0 1.27395e-05
R4715 4210 4211 1.664 0.8 13.312 37
I4211 4211 0 1.29868e-05
R4716 4211 4212 1.728 0.8 13.824 37
I4212 4212 0 1.34816e-05
R4717 4212 4213 1.712 0.8 13.696 37
I4213 4213 0 1.26158e-05
R4718 4213 4214 1.664 0.8 13.312 37
I4214 4214 0 1.32342e-05
R4719 4214 4215 1.6 0.8 12.8 37
I4215 4215 0 1.29868e-05
R4720 4215 4216 1.68 0.8 13.44 37
I4216 4216 0 1.26158e-05
R4721 4216 4217 1.712 0.8 13.696 37
I4217 4217 0 1.28631e-05
R4722 4217 4218 1.616 0.8 12.928 37
I4218 4218 0 1.24921e-05
R4723 4218 4219 1.744 0.8 13.952 37
I4219 4219 0 1.29868e-05
R4724 4219 4220 1.664 0.8 13.312 37
I4220 4220 0 1.26158e-05
R4725 4220 4221 1.68 0.8 13.44 37
I4221 4221 0 1.33579e-05
R4726 4221 4222 1.68 0.8 13.44 37
I4222 4222 0 1.29868e-05
R4727 4222 4223 1.696 0.8 13.568 37
I4223 4223 0 1.31105e-05
R4728 4223 4224 1.728 0.8 13.824 37
I4224 4224 0 1.32342e-05
R4729 4224 4225 1.616 0.8 12.928 37
I4225 4225 0 1.34816e-05
R4730 4225 4226 1.632 0.8 13.056 37
I4226 4226 0 1.29868e-05
R4731 4226 4227 1.696 0.8 13.568 37
I4227 4227 0 1.26158e-05
R4732 4227 4228 1.696 0.8 13.568 37
I4228 4228 0 1.28631e-05
R4733 4228 4229 1.712 0.8 13.696 37
I4229 4229 0 1.26158e-05
R4734 4229 4230 1.648 0.8 13.184 37
I4230 4230 0 1.32342e-05
R4735 4230 4231 1.712 0.8 13.696 37
I4231 4231 0 1.33579e-05
R4736 4231 4232 1.744 0.8 13.952 37
I4232 4232 0 1.28631e-05
R4737 4232 4233 1.632 0.8 13.056 37
I4233 4233 0 1.26158e-05
R4738 4233 4234 1.68 0.8 13.44 37
I4234 4234 0 1.27395e-05
R4739 4234 4235 1.728 0.8 13.824 37
I4235 4235 0 1.24921e-05
R4740 4235 4236 1.696 0.8 13.568 37
I4236 4236 0 1.29868e-05
R4741 4236 4237 1.6 0.8 12.8 37
I4237 4237 0 1.27395e-05
R4742 4237 4238 1.616 0.8 12.928 37
I4238 4238 0 1.31105e-05
R4743 4238 4239 1.744 0.8 13.952 37
I4239 4239 0 1.34816e-05
R4744 4239 4240 1.68 0.8 13.44 37
I4240 4240 0 1.26158e-05
R4745 4240 4241 1.616 0.8 12.928 37
I4241 4241 0 1.34816e-05
R4746 4241 4242 1.712 0.8 13.696 37
I4242 4242 0 1.32342e-05
R4747 4242 4243 1.632 0.8 13.056 37
I4243 4243 0 1.29868e-05
R4748 4243 4244 1.648 0.8 13.184 37
I4244 4244 0 1.34816e-05
R4749 4244 4245 1.728 0.8 13.824 37
I4245 4245 0 1.31105e-05
R4750 4245 4246 1.696 0.8 13.568 37
I4246 4246 0 1.29868e-05
R4751 4246 4247 1.664 0.8 13.312 37
I4247 4247 0 1.33579e-05
R4752 4247 4248 1.632 0.8 13.056 37
I4248 4248 0 1.33579e-05
R4753 4248 4249 1.6 0.8 12.8 37
I4249 4249 0 1.34816e-05
R4754 4249 4250 1.664 0.8 13.312 37
I4250 4250 0 1.23684e-05
R4755 4250 4251 1.616 0.8 12.928 37
I4251 4251 0 1.23684e-05
R4756 4251 4252 1.696 0.8 13.568 37
I4252 4252 0 1.24921e-05
R4757 4252 4253 1.648 0.8 13.184 37
I4253 4253 0 1.32342e-05
R4758 4253 4254 1.744 0.8 13.952 37
I4254 4254 0 1.29868e-05
R4759 4254 4255 1.728 0.8 13.824 37
I4255 4255 0 1.31105e-05
R4760 4255 4256 1.712 0.8 13.696 37
I4256 4256 0 1.34816e-05
R4761 4256 4257 1.68 0.8 13.44 37
I4257 4257 0 1.32342e-05
R4762 4257 4258 1.712 0.8 13.696 37
I4258 4258 0 1.32342e-05
R4763 4258 4259 1.632 0.8 13.056 37
I4259 4259 0 1.23684e-05
R4764 4259 4260 1.728 0.8 13.824 37
I4260 4260 0 1.23684e-05
R4765 4260 4261 1.712 0.8 13.696 37
I4261 4261 0 1.32342e-05
R4766 4261 4262 1.728 0.8 13.824 37
I4262 4262 0 1.27395e-05
R4767 4262 4263 1.68 0.8 13.44 37
I4263 4263 0 1.23684e-05
R4768 4263 4264 1.664 0.8 13.312 37
I4264 4264 0 1.32342e-05
R4769 4264 4265 1.744 0.8 13.952 37
I4265 4265 0 1.33579e-05
R4770 4265 4266 1.6 0.8 12.8 37
I4266 4266 0 1.26158e-05
R4771 4266 4267 1.6 0.8 12.8 37
I4267 4267 0 1.33579e-05
R4772 4267 4268 1.68 0.8 13.44 37
I4268 4268 0 1.29868e-05
R4773 4268 4269 1.68 0.8 13.44 37
I4269 4269 0 1.31105e-05
R4774 4269 4270 1.6 0.8 12.8 37
I4270 4270 0 1.29868e-05
R4775 4270 4271 1.632 0.8 13.056 37
I4271 4271 0 1.23684e-05
R4776 4271 4272 1.68 0.8 13.44 37
I4272 4272 0 1.23684e-05
R4777 4272 4273 1.712 0.8 13.696 37
I4273 4273 0 1.26158e-05
R4778 4273 4274 1.712 0.8 13.696 37
I4274 4274 0 1.24921e-05
R4779 4274 4275 1.664 0.8 13.312 37
I4275 4275 0 1.33579e-05
R4780 4275 4276 1.664 0.8 13.312 37
I4276 4276 0 1.27395e-05
R4781 4276 4277 1.68 0.8 13.44 37
I4277 4277 0 1.26158e-05
R4782 4277 4278 1.744 0.8 13.952 37
I4278 4278 0 1.23684e-05
R4783 4278 4279 1.664 0.8 13.312 37
I4279 4279 0 1.27395e-05
R4784 4279 4280 1.744 0.8 13.952 37
I4280 4280 0 1.29868e-05
R4785 4280 4281 1.648 0.8 13.184 37
I4281 4281 0 1.34816e-05
R4786 4281 4282 1.728 0.8 13.824 37
I4282 4282 0 1.27395e-05
R4787 4282 4283 1.712 0.8 13.696 37
I4283 4283 0 1.27395e-05
R4788 4283 4284 1.728 0.8 13.824 37
I4284 4284 0 1.28631e-05
R4789 4284 4285 1.6 0.8 12.8 37
I4285 4285 0 1.24921e-05
R4790 4285 4286 1.6 0.8 12.8 37
I4286 4286 0 1.26158e-05
R4791 4286 4287 1.616 0.8 12.928 37
I4287 4287 0 1.29868e-05
R4792 4287 4288 1.664 0.8 13.312 37
I4288 4288 0 1.23684e-05
R4793 4288 4289 1.744 0.8 13.952 37
I4289 4289 0 1.28631e-05
R4794 4289 4290 1.648 0.8 13.184 37
I4290 4290 0 1.27395e-05
R4795 4290 4291 1.632 0.8 13.056 37
I4291 4291 0 1.32342e-05
R4796 4291 4292 1.744 0.8 13.952 37
I4292 4292 0 1.32342e-05
R4797 4292 4293 1.616 0.8 12.928 37
I4293 4293 0 1.33579e-05
R4798 4293 4294 1.744 0.8 13.952 37
I4294 4294 0 1.29868e-05
R4799 4294 4295 1.616 0.8 12.928 37
I4295 4295 0 1.23684e-05
R4800 4295 4296 1.616 0.8 12.928 37
I4296 4296 0 1.31105e-05
R4801 4296 4297 1.6 0.8 12.8 37
I4297 4297 0 1.34816e-05
R4802 4297 4298 1.744 0.8 13.952 37
I4298 4298 0 1.34816e-05
R4803 4298 4299 1.664 0.8 13.312 37
I4299 4299 0 1.34816e-05
R4804 4299 4300 1.664 0.8 13.312 37
I4300 4300 0 1.28631e-05
R4805 4300 4301 1.6 0.8 12.8 37
I4301 4301 0 1.31105e-05
R4806 4301 4302 1.744 0.8 13.952 37
I4302 4302 0 1.27395e-05
R4807 4302 4303 1.648 0.8 13.184 37
I4303 4303 0 1.27395e-05
R4808 4303 4304 1.68 0.8 13.44 37
I4304 4304 0 1.26158e-05
R4809 4304 4305 1.712 0.8 13.696 37
I4305 4305 0 1.34816e-05
R4810 4305 4306 1.712 0.8 13.696 37
I4306 4306 0 1.24921e-05
R4811 4306 4307 1.728 0.8 13.824 37
I4307 4307 0 1.31105e-05
R4812 4307 4308 1.728 0.8 13.824 37
I4308 4308 0 1.23684e-05
R4813 4308 4309 1.664 0.8 13.312 37
I4309 4309 0 1.34816e-05
R4814 4309 4310 1.68 0.8 13.44 37
I4310 4310 0 1.32342e-05
R4815 4310 4311 1.6 0.8 12.8 37
I4311 4311 0 1.33579e-05
R4816 4311 4312 1.648 0.8 13.184 37
I4312 4312 0 1.23684e-05
R4817 4312 4313 1.712 0.8 13.696 37
I4313 4313 0 1.26158e-05
R4818 4313 4314 1.616 0.8 12.928 37
I4314 4314 0 1.26158e-05
R4819 4314 4315 1.664 0.8 13.312 37
I4315 4315 0 1.29868e-05
R4820 4315 4316 1.728 0.8 13.824 37
I4316 4316 0 1.28631e-05
R4821 4316 4317 1.648 0.8 13.184 37
I4317 4317 0 1.32342e-05
R4822 4317 4318 1.6 0.8 12.8 37
I4318 4318 0 1.31105e-05
R4823 4318 4319 1.648 0.8 13.184 37
I4319 4319 0 1.29868e-05
R4824 4319 4320 1.6 0.8 12.8 37
I4320 4320 0 1.26158e-05
R4825 4320 4321 1.696 0.8 13.568 37
I4321 4321 0 1.33579e-05
R4826 4321 4322 1.664 0.8 13.312 37
I4322 4322 0 1.29868e-05
R4827 4322 4323 1.696 0.8 13.568 37
I4323 4323 0 1.28631e-05
R4828 4323 4324 1.68 0.8 13.44 37
I4324 4324 0 1.24921e-05
R4829 4324 4325 1.664 0.8 13.312 37
I4325 4325 0 1.26158e-05
R4830 4325 4326 1.6 0.8 12.8 37
I4326 4326 0 1.28631e-05
R4831 4326 4327 1.616 0.8 12.928 37
I4327 4327 0 1.28631e-05
R4832 4327 4328 1.696 0.8 13.568 37
I4328 4328 0 1.23684e-05
R4833 4328 4329 1.728 0.8 13.824 37
I4329 4329 0 1.32342e-05
R4834 4329 4330 1.664 0.8 13.312 37
I4330 4330 0 1.26158e-05
R4835 4330 4331 1.68 0.8 13.44 37
I4331 4331 0 1.27395e-05
R4836 4331 4332 1.744 0.8 13.952 37
I4332 4332 0 1.33579e-05
R4837 4332 4333 1.632 0.8 13.056 37
I4333 4333 0 1.24921e-05
R4838 4333 4334 1.712 0.8 13.696 37
I4334 4334 0 1.32342e-05
R4839 4334 4335 1.728 0.8 13.824 37
I4335 4335 0 1.32342e-05
R4840 4335 4336 1.6 0.8 12.8 37
I4336 4336 0 1.29868e-05
R4841 4336 4337 1.712 0.8 13.696 37
I4337 4337 0 1.28631e-05
R4842 4337 4338 1.6 0.8 12.8 37
I4338 4338 0 1.28631e-05
R4843 4338 4339 1.728 0.8 13.824 37
I4339 4339 0 1.32342e-05
R4844 4339 4340 1.712 0.8 13.696 37
I4340 4340 0 1.28631e-05
R4845 4340 4341 1.744 0.8 13.952 37
I4341 4341 0 1.32342e-05
R4846 4341 4342 1.728 0.8 13.824 37
I4342 4342 0 1.26158e-05
R4847 4342 4343 1.648 0.8 13.184 37
I4343 4343 0 1.31105e-05
R4848 4343 4344 1.648 0.8 13.184 37
I4344 4344 0 1.26158e-05
R4849 4344 4345 1.696 0.8 13.568 37
I4345 4345 0 1.32342e-05
R4850 4345 4346 1.696 0.8 13.568 37
I4346 4346 0 1.24921e-05
R4851 4346 4347 1.6 0.8 12.8 37
I4347 4347 0 1.32342e-05
R4852 4347 4348 1.616 0.8 12.928 37
I4348 4348 0 1.29868e-05
R4853 4348 4349 1.6 0.8 12.8 37
I4349 4349 0 1.33579e-05
R4854 4349 4350 1.632 0.8 13.056 37
I4350 4350 0 1.34816e-05
R4855 4350 4351 1.728 0.8 13.824 37
I4351 4351 0 1.26158e-05
R4856 4351 4352 1.664 0.8 13.312 37
I4352 4352 0 1.29868e-05
R4857 4352 4353 1.728 0.8 13.824 37
I4353 4353 0 1.31105e-05
R4858 4353 4354 1.744 0.8 13.952 37
I4354 4354 0 1.32342e-05
R4859 4354 4355 1.648 0.8 13.184 37
I4355 4355 0 1.31105e-05
R4860 4355 4356 1.616 0.8 12.928 37
I4356 4356 0 1.28631e-05
R4861 4356 4357 1.696 0.8 13.568 37
I4357 4357 0 1.26158e-05
R4862 4357 4358 1.712 0.8 13.696 37
I4358 4358 0 1.34816e-05
R4863 4358 4359 1.728 0.8 13.824 37
I4359 4359 0 1.23684e-05
R4864 4359 4360 1.648 0.8 13.184 37
I4360 4360 0 1.31105e-05
R4865 4360 4361 1.712 0.8 13.696 37
I4361 4361 0 1.26158e-05
R4866 4361 4362 1.712 0.8 13.696 37
I4362 4362 0 1.23684e-05
R4867 4362 4363 1.616 0.8 12.928 37
I4363 4363 0 1.24921e-05
R4868 4363 4364 1.68 0.8 13.44 37
I4364 4364 0 1.26158e-05
R4869 4364 4365 1.616 0.8 12.928 37
I4365 4365 0 1.32342e-05
R4870 4365 4366 1.616 0.8 12.928 37
I4366 4366 0 1.34816e-05
R4871 4366 4367 1.6 0.8 12.8 37
I4367 4367 0 1.32342e-05
R4872 4367 4368 1.68 0.8 13.44 37
I4368 4368 0 1.23684e-05
R4873 4368 4369 1.648 0.8 13.184 37
I4369 4369 0 1.31105e-05
R4874 4369 4370 1.712 0.8 13.696 37
I4370 4370 0 1.31105e-05
R4875 4370 4371 1.68 0.8 13.44 37
I4371 4371 0 1.24921e-05
R4876 4371 4372 1.6 0.8 12.8 37
I4372 4372 0 1.24921e-05
R4877 4372 4373 1.68 0.8 13.44 37
I4373 4373 0 1.34816e-05
R4878 4373 4374 1.6 0.8 12.8 37
I4374 4374 0 1.29868e-05
R4879 4374 4375 1.744 0.8 13.952 37
I4375 4375 0 1.31105e-05
R4880 4375 4376 1.632 0.8 13.056 37
I4376 4376 0 1.34816e-05
R4881 4376 4377 1.728 0.8 13.824 37
I4377 4377 0 1.24921e-05
R4882 4377 4378 1.744 0.8 13.952 37
I4378 4378 0 1.34816e-05
R4883 4378 4379 1.632 0.8 13.056 37
I4379 4379 0 1.28631e-05
R4884 4379 4380 1.616 0.8 12.928 37
I4380 4380 0 1.31105e-05
R4885 4380 4381 1.648 0.8 13.184 37
I4381 4381 0 1.28631e-05
R4886 4381 4382 1.68 0.8 13.44 37
I4382 4382 0 1.29868e-05
R4887 4382 4383 1.616 0.8 12.928 37
I4383 4383 0 1.26158e-05
R4888 4383 4384 1.696 0.8 13.568 37
I4384 4384 0 1.28631e-05
R4889 4384 4385 1.616 0.8 12.928 37
I4385 4385 0 1.29868e-05
R4890 4385 4386 1.632 0.8 13.056 37
I4386 4386 0 1.31105e-05
R4891 4386 4387 1.696 0.8 13.568 37
I4387 4387 0 1.29868e-05
R4892 4387 4388 1.712 0.8 13.696 37
I4388 4388 0 1.27395e-05
R4893 4388 4389 1.664 0.8 13.312 37
I4389 4389 0 1.34816e-05
R4894 4389 4390 1.744 0.8 13.952 37
I4390 4390 0 1.31105e-05
R4895 4390 4391 1.712 0.8 13.696 37
I4391 4391 0 1.24921e-05
R4896 4391 4392 1.68 0.8 13.44 37
I4392 4392 0 1.29868e-05
R4897 4392 4393 1.632 0.8 13.056 37
I4393 4393 0 1.28631e-05
R4898 4393 4394 1.712 0.8 13.696 37
I4394 4394 0 1.32342e-05
R4899 4394 4395 1.6 0.8 12.8 37
I4395 4395 0 1.33579e-05
R4900 4395 4396 1.648 0.8 13.184 37
I4396 4396 0 1.29868e-05
R4901 4396 4397 1.68 0.8 13.44 37
I4397 4397 0 1.23684e-05
R4902 4397 4398 1.616 0.8 12.928 37
I4398 4398 0 1.31105e-05
R4903 4398 4399 1.68 0.8 13.44 37
I4399 4399 0 1.34816e-05
R4904 4399 4400 1.648 0.8 13.184 37
I4400 4400 0 1.31105e-05
R4905 4400 4401 1.664 0.8 13.312 37
I4401 4401 0 1.29868e-05
R4906 4401 4402 1.632 0.8 13.056 37
I4402 4402 0 1.27395e-05
R4907 4402 4403 1.632 0.8 13.056 37
I4403 4403 0 1.24921e-05
R4908 4403 4404 1.696 0.8 13.568 37
I4404 4404 0 1.34816e-05
R4909 4404 4405 1.632 0.8 13.056 37
I4405 4405 0 1.32342e-05
R4910 4405 4406 1.68 0.8 13.44 37
I4406 4406 0 1.23684e-05
R4911 4406 4407 1.728 0.8 13.824 37
I4407 4407 0 1.23684e-05
R4912 4407 4408 1.712 0.8 13.696 37
I4408 4408 0 1.27395e-05
R4913 4408 4409 1.696 0.8 13.568 37
I4409 4409 0 1.28631e-05
R4914 4409 4410 1.6 0.8 12.8 37
I4410 4410 0 1.33579e-05
R4915 4410 4411 1.68 0.8 13.44 37
I4411 4411 0 1.29868e-05
R4916 4411 4412 1.648 0.8 13.184 37
I4412 4412 0 1.23684e-05
R4917 4412 4413 1.68 0.8 13.44 37
I4413 4413 0 1.31105e-05
R4918 4413 4414 1.728 0.8 13.824 37
I4414 4414 0 1.26158e-05
R4919 4414 4415 1.712 0.8 13.696 37
I4415 4415 0 1.24921e-05
R4920 4415 4416 1.728 0.8 13.824 37
I4416 4416 0 1.28631e-05
R4921 4416 4417 1.744 0.8 13.952 37
I4417 4417 0 1.26158e-05
R4922 4417 4418 1.712 0.8 13.696 37
I4418 4418 0 1.24921e-05
R4923 4418 4419 1.68 0.8 13.44 37
I4419 4419 0 1.29868e-05
R4924 4419 4420 1.6 0.8 12.8 37
I4420 4420 0 1.33579e-05
R4925 4420 4421 1.648 0.8 13.184 37
I4421 4421 0 1.29868e-05
R4926 4421 4422 1.6 0.8 12.8 37
I4422 4422 0 1.24921e-05
R4927 4422 4423 1.712 0.8 13.696 37
I4423 4423 0 1.34816e-05
R4928 4423 4424 1.696 0.8 13.568 37
I4424 4424 0 1.27395e-05
R4929 4424 4425 1.664 0.8 13.312 37
I4425 4425 0 1.33579e-05
R4930 4425 4426 1.648 0.8 13.184 37
I4426 4426 0 1.24921e-05
R4931 4426 4427 1.648 0.8 13.184 37
I4427 4427 0 1.34816e-05
R4932 4427 4428 1.648 0.8 13.184 37
I4428 4428 0 1.24921e-05
R4933 4428 4429 1.712 0.8 13.696 37
I4429 4429 0 1.24921e-05
R4934 4429 4430 1.648 0.8 13.184 37
I4430 4430 0 1.29868e-05
R4935 4430 4431 1.648 0.8 13.184 37
I4431 4431 0 1.26158e-05
R4936 4431 4432 1.744 0.8 13.952 37
I4432 4432 0 1.26158e-05
R4937 4432 4433 1.696 0.8 13.568 37
I4433 4433 0 1.33579e-05
R4938 4433 4434 1.648 0.8 13.184 37
I4434 4434 0 1.26158e-05
R4939 4434 4435 1.648 0.8 13.184 37
I4435 4435 0 1.31105e-05
R4940 4435 4436 1.632 0.8 13.056 37
I4436 4436 0 1.33579e-05
R4941 4436 4437 1.616 0.8 12.928 37
I4437 4437 0 1.28631e-05
R4942 4437 4438 1.632 0.8 13.056 37
I4438 4438 0 1.24921e-05
R4943 4438 4439 1.648 0.8 13.184 37
I4439 4439 0 1.33579e-05
R4944 4439 4440 1.664 0.8 13.312 37
I4440 4440 0 1.34816e-05
R4945 4440 4441 1.712 0.8 13.696 37
I4441 4441 0 1.23684e-05
R4946 4441 4442 1.632 0.8 13.056 37
I4442 4442 0 1.23684e-05
R4947 4442 4443 1.744 0.8 13.952 37
I4443 4443 0 1.29868e-05
R4948 4443 4444 1.648 0.8 13.184 37
I4444 4444 0 1.33579e-05
R4949 4444 4445 1.712 0.8 13.696 37
I4445 4445 0 1.32342e-05
R4950 4445 4446 1.68 0.8 13.44 37
I4446 4446 0 1.23684e-05
R4951 4446 4447 1.616 0.8 12.928 37
I4447 4447 0 1.28631e-05
R4952 4447 4448 1.664 0.8 13.312 37
I4448 4448 0 1.32342e-05
R4953 4448 4449 1.664 0.8 13.312 37
I4449 4449 0 1.32342e-05
R4954 4449 4450 1.616 0.8 12.928 37
I4450 4450 0 1.33579e-05
R4955 4450 4451 1.68 0.8 13.44 37
I4451 4451 0 1.29868e-05
R4956 4451 4452 1.696 0.8 13.568 37
I4452 4452 0 1.32342e-05
R4957 4452 4453 1.744 0.8 13.952 37
I4453 4453 0 1.23684e-05
R4958 4453 4454 1.728 0.8 13.824 37
I4454 4454 0 1.29868e-05
R4959 4454 4455 1.744 0.8 13.952 37
I4455 4455 0 1.28631e-05
R4960 4455 4456 1.664 0.8 13.312 37
I4456 4456 0 1.31105e-05
R4961 4456 4457 1.696 0.8 13.568 37
I4457 4457 0 1.34816e-05
R4962 4457 4458 1.728 0.8 13.824 37
I4458 4458 0 1.32342e-05
R4963 4458 4459 1.664 0.8 13.312 37
I4459 4459 0 1.28631e-05
R4964 4459 4460 1.696 0.8 13.568 37
I4460 4460 0 1.24921e-05
R4965 4460 4461 1.616 0.8 12.928 37
I4461 4461 0 1.24921e-05
R4966 4461 4462 1.648 0.8 13.184 37
I4462 4462 0 1.28631e-05
R4967 4462 4463 1.728 0.8 13.824 37
I4463 4463 0 1.32342e-05
R4968 4463 4464 1.648 0.8 13.184 37
I4464 4464 0 1.26158e-05
R4969 4464 4465 1.712 0.8 13.696 37
I4465 4465 0 1.29868e-05
R4970 4465 4466 1.632 0.8 13.056 37
I4466 4466 0 1.26158e-05
R4971 4466 4467 1.6 0.8 12.8 37
I4467 4467 0 1.24921e-05
R4972 4467 4468 1.744 0.8 13.952 37
I4468 4468 0 1.26158e-05
R4973 4468 4469 1.616 0.8 12.928 37
I4469 4469 0 1.34816e-05
R4974 4469 4470 1.712 0.8 13.696 37
I4470 4470 0 1.23684e-05
R4975 4470 4471 1.696 0.8 13.568 37
I4471 4471 0 1.27395e-05
R4976 4471 4472 1.728 0.8 13.824 37
I4472 4472 0 1.26158e-05
R4977 4472 4473 1.632 0.8 13.056 37
I4473 4473 0 1.34816e-05
R4978 4473 4474 1.6 0.8 12.8 37
I4474 4474 0 1.32342e-05
R4979 4474 4475 1.648 0.8 13.184 37
I4475 4475 0 1.31105e-05
R4980 4475 4476 1.6 0.8 12.8 37
I4476 4476 0 1.31105e-05
R4981 4476 4477 1.744 0.8 13.952 37
I4477 4477 0 1.28631e-05
R4982 4477 4478 1.632 0.8 13.056 37
I4478 4478 0 1.32342e-05
R4983 4478 4479 1.616 0.8 12.928 37
I4479 4479 0 1.29868e-05
R4984 4479 4480 1.6 0.8 12.8 37
I4480 4480 0 1.33579e-05
R4985 4480 4481 1.632 0.8 13.056 37
I4481 4481 0 1.28631e-05
R4986 4481 4482 1.616 0.8 12.928 37
I4482 4482 0 1.29868e-05
R4987 4482 4483 1.68 0.8 13.44 37
I4483 4483 0 1.26158e-05
R4988 4483 4484 1.712 0.8 13.696 37
I4484 4484 0 1.32342e-05
R4989 4484 4485 1.664 0.8 13.312 37
I4485 4485 0 1.28631e-05
R4990 4485 4486 1.744 0.8 13.952 37
I4486 4486 0 1.23684e-05
R4991 4486 4487 1.744 0.8 13.952 37
I4487 4487 0 1.33579e-05
R4992 4487 4488 1.632 0.8 13.056 37
I4488 4488 0 1.28631e-05
R4993 4488 4489 1.744 0.8 13.952 37
I4489 4489 0 1.26158e-05
R4994 4489 4490 1.616 0.8 12.928 37
I4490 4490 0 1.28631e-05
R4995 4490 4491 1.6 0.8 12.8 37
I4491 4491 0 1.27395e-05
R4996 4491 4492 1.6 0.8 12.8 37
I4492 4492 0 1.23684e-05
R4997 4492 4493 1.712 0.8 13.696 37
I4493 4493 0 1.26158e-05
R4998 4493 4494 1.744 0.8 13.952 37
I4494 4494 0 1.24921e-05
R4999 4494 4495 1.744 0.8 13.952 37
I4495 4495 0 1.24921e-05
R5000 4495 4496 1.744 0.8 13.952 37
I4496 4496 0 1.26158e-05
R5001 4496 4497 1.696 0.8 13.568 37
I4497 4497 0 1.26158e-05
R5002 4497 4498 1.712 0.8 13.696 37
I4498 4498 0 1.24921e-05
R5003 4498 4499 1.68 0.8 13.44 37
I4499 4499 0 1.28631e-05
R5004 4499 4500 1.6 0.8 12.8 37
I4500 4500 0 1.24921e-05
R5005 4500 4501 1.6 0.8 12.8 37
I4501 4501 0 1.23684e-05
R5006 4501 4502 1.616 0.8 12.928 37
I4502 4502 0 1.24921e-05
R5007 4502 4503 1.6 0.8 12.8 37
I4503 4503 0 1.27395e-05
R5008 4503 4504 1.68 0.8 13.44 37
I4504 4504 0 1.34816e-05
R5009 4504 4505 1.728 0.8 13.824 37
I4505 4505 0 1.33579e-05
R5010 4505 4506 1.648 0.8 13.184 37
I4506 4506 0 1.23684e-05
R5011 4506 4507 1.632 0.8 13.056 37
I4507 4507 0 1.29868e-05
R5012 4507 4508 1.632 0.8 13.056 37
I4508 4508 0 1.34816e-05
R5013 4508 4509 1.744 0.8 13.952 37
I4509 4509 0 1.28631e-05
R5014 4509 4510 1.632 0.8 13.056 37
I4510 4510 0 1.33579e-05
R5015 4510 4511 1.68 0.8 13.44 37
I4511 4511 0 1.26158e-05
R5016 4511 4512 1.6 0.8 12.8 37
I4512 4512 0 1.24921e-05
R5017 4512 4513 1.696 0.8 13.568 37
I4513 4513 0 1.32342e-05
R5018 4513 4514 1.68 0.8 13.44 37
I4514 4514 0 1.27395e-05
R5019 4514 4515 1.648 0.8 13.184 37
I4515 4515 0 1.29868e-05
R5020 4515 4516 1.664 0.8 13.312 37
I4516 4516 0 1.29868e-05
R5021 4516 4517 1.712 0.8 13.696 37
I4517 4517 0 1.29868e-05
R5022 4517 4518 1.712 0.8 13.696 37
I4518 4518 0 1.34816e-05
R5023 4518 4519 1.616 0.8 12.928 37
I4519 4519 0 1.26158e-05
R5024 4519 4520 1.728 0.8 13.824 37
I4520 4520 0 1.24921e-05
R5025 4520 4521 1.616 0.8 12.928 37
I4521 4521 0 1.27395e-05
R5026 4521 4522 1.616 0.8 12.928 37
I4522 4522 0 1.27395e-05
R5027 4522 4523 1.6 0.8 12.8 37
I4523 4523 0 1.31105e-05
R5028 4523 4524 1.664 0.8 13.312 37
I4524 4524 0 1.34816e-05
R5029 4524 4525 1.6 0.8 12.8 37
I4525 4525 0 1.32342e-05
R5030 4525 4526 1.6 0.8 12.8 37
I4526 4526 0 1.29868e-05
R5031 4526 4527 1.616 0.8 12.928 37
I4527 4527 0 1.23684e-05
R5032 4527 4528 1.744 0.8 13.952 37
I4528 4528 0 1.32342e-05
R5033 4528 4529 1.6 0.8 12.8 37
I4529 4529 0 1.31105e-05
R5034 4529 4530 1.648 0.8 13.184 37
I4530 4530 0 1.29868e-05
R5035 4530 4531 1.648 0.8 13.184 37
I4531 4531 0 1.32342e-05
R5036 4531 4532 1.616 0.8 12.928 37
I4532 4532 0 1.24921e-05
R5037 4532 4533 1.648 0.8 13.184 37
I4533 4533 0 1.33579e-05
R5038 4533 4534 1.6 0.8 12.8 37
I4534 4534 0 1.31105e-05
R5039 4534 4535 1.6 0.8 12.8 37
I4535 4535 0 1.24921e-05
R5040 4535 4536 1.712 0.8 13.696 37
I4536 4536 0 1.27395e-05
R5041 4536 4537 1.696 0.8 13.568 37
I4537 4537 0 1.23684e-05
R5042 4537 4538 1.728 0.8 13.824 37
I4538 4538 0 1.34816e-05
R5043 4538 4539 1.696 0.8 13.568 37
I4539 4539 0 1.27395e-05
R5044 4539 4540 1.6 0.8 12.8 37
I4540 4540 0 1.33579e-05
R5045 4540 4541 1.632 0.8 13.056 37
I4541 4541 0 1.23684e-05
R5046 4541 4542 1.696 0.8 13.568 37
I4542 4542 0 1.27395e-05
R5047 4542 4543 1.648 0.8 13.184 37
I4543 4543 0 1.29868e-05
R5048 4543 4544 1.632 0.8 13.056 37
I4544 4544 0 1.29868e-05
R5049 4544 4545 1.616 0.8 12.928 37
I4545 4545 0 1.29868e-05
R5050 4545 4546 1.6 0.8 12.8 37
I4546 4546 0 1.28631e-05
R5051 4546 4547 1.68 0.8 13.44 37
I4547 4547 0 1.27395e-05
R5052 4547 4548 1.712 0.8 13.696 37
I4548 4548 0 1.23684e-05
R5053 4548 4549 1.648 0.8 13.184 37
I4549 4549 0 1.23684e-05
R5054 4549 4550 1.696 0.8 13.568 37
I4550 4550 0 1.31105e-05
R5055 4550 4551 1.648 0.8 13.184 37
I4551 4551 0 1.29868e-05
R5056 4551 4552 1.744 0.8 13.952 37
I4552 4552 0 1.34816e-05
R5057 4552 4553 1.68 0.8 13.44 37
I4553 4553 0 1.33579e-05
R5058 4553 4554 1.728 0.8 13.824 37
I4554 4554 0 1.28631e-05
R5059 4554 4555 1.648 0.8 13.184 37
I4555 4555 0 1.24921e-05
R5060 4555 4556 1.664 0.8 13.312 37
I4556 4556 0 1.29868e-05
R5061 4556 4557 1.616 0.8 12.928 37
I4557 4557 0 1.23684e-05
R5062 4557 4558 1.6 0.8 12.8 37
I4558 4558 0 1.28631e-05
R5063 4558 4559 1.68 0.8 13.44 37
I4559 4559 0 1.28631e-05
R5064 4559 4560 1.616 0.8 12.928 37
I4560 4560 0 1.33579e-05
R5065 4560 4561 1.6 0.8 12.8 37
I4561 4561 0 1.26158e-05
R5066 4561 4562 1.68 0.8 13.44 37
I4562 4562 0 1.32342e-05
R5067 4562 4563 1.712 0.8 13.696 37
I4563 4563 0 1.26158e-05
R5068 4563 4564 1.712 0.8 13.696 37
I4564 4564 0 1.24921e-05
R5069 4564 4565 1.632 0.8 13.056 37
I4565 4565 0 1.27395e-05
R5070 4565 4566 1.712 0.8 13.696 37
I4566 4566 0 1.29868e-05
R5071 4566 4567 1.728 0.8 13.824 37
I4567 4567 0 1.31105e-05
R5072 4567 4568 1.712 0.8 13.696 37
I4568 4568 0 1.29868e-05
R5073 4568 4569 1.696 0.8 13.568 37
I4569 4569 0 1.32342e-05
R5074 4569 4570 1.616 0.8 12.928 37
I4570 4570 0 1.34816e-05
R5075 4570 4571 1.728 0.8 13.824 37
I4571 4571 0 1.31105e-05
R5076 4571 4572 1.696 0.8 13.568 37
I4572 4572 0 1.26158e-05
R5077 4572 4573 1.696 0.8 13.568 37
I4573 4573 0 1.31105e-05
R5078 4573 4574 1.728 0.8 13.824 37
I4574 4574 0 1.28631e-05
R5079 4574 4575 1.616 0.8 12.928 37
I4575 4575 0 1.23684e-05
R5080 4575 4576 1.632 0.8 13.056 37
I4576 4576 0 1.27395e-05
R5081 4576 4577 1.664 0.8 13.312 37
I4577 4577 0 1.34816e-05
R5082 4577 4578 1.6 0.8 12.8 37
I4578 4578 0 1.24921e-05
R5083 4578 4579 1.632 0.8 13.056 37
I4579 4579 0 1.34816e-05
R5084 4579 4580 1.632 0.8 13.056 37
I4580 4580 0 1.31105e-05
R5085 4580 4581 1.632 0.8 13.056 37
I4581 4581 0 1.34816e-05
R5086 4581 4582 1.664 0.8 13.312 37
I4582 4582 0 1.26158e-05
R5087 4582 4583 1.728 0.8 13.824 37
I4583 4583 0 1.27395e-05
R5088 4583 4584 1.712 0.8 13.696 37
I4584 4584 0 1.28631e-05
R5089 4584 4585 1.632 0.8 13.056 37
I4585 4585 0 1.34816e-05
R5090 4585 4586 1.664 0.8 13.312 37
I4586 4586 0 1.27395e-05
R5091 4586 4587 1.712 0.8 13.696 37
I4587 4587 0 1.23684e-05
R5092 4587 4588 1.68 0.8 13.44 37
I4588 4588 0 1.27395e-05
R5093 4588 4589 1.744 0.8 13.952 37
I4589 4589 0 1.27395e-05
R5094 4589 4590 1.744 0.8 13.952 37
I4590 4590 0 1.26158e-05
R5095 4590 4591 1.648 0.8 13.184 37
I4591 4591 0 1.28631e-05
R5096 4591 4592 1.712 0.8 13.696 37
I4592 4592 0 1.32342e-05
R5097 4592 4593 1.648 0.8 13.184 37
I4593 4593 0 1.34816e-05
R5098 4593 4594 1.616 0.8 12.928 37
I4594 4594 0 1.32342e-05
R5099 4594 4595 1.728 0.8 13.824 37
I4595 4595 0 1.27395e-05
R5100 4595 4596 1.664 0.8 13.312 37
I4596 4596 0 1.23684e-05
R5101 4596 4597 1.68 0.8 13.44 37
I4597 4597 0 1.23684e-05
R5102 4597 4598 1.664 0.8 13.312 37
I4598 4598 0 1.27395e-05
R5103 4598 4599 1.68 0.8 13.44 37
I4599 4599 0 1.24921e-05
R5104 4599 4600 1.744 0.8 13.952 37
I4600 4600 0 1.32342e-05
R5105 4600 4601 1.632 0.8 13.056 37
I4601 4601 0 1.29868e-05
R5106 4601 4602 1.6 0.8 12.8 37
I4602 4602 0 1.34816e-05
R5107 4602 4603 1.696 0.8 13.568 37
I4603 4603 0 1.32342e-05
R5108 4603 4604 1.68 0.8 13.44 37
I4604 4604 0 1.32342e-05
R5109 4604 4605 1.616 0.8 12.928 37
I4605 4605 0 1.28631e-05
R5110 4605 4606 1.744 0.8 13.952 37
I4606 4606 0 1.31105e-05
R5111 4606 4607 1.728 0.8 13.824 37
I4607 4607 0 1.33579e-05
R5112 4607 4608 1.696 0.8 13.568 37
I4608 4608 0 1.28631e-05
R5113 4608 4609 1.712 0.8 13.696 37
I4609 4609 0 1.32342e-05
R5114 4609 4610 1.616 0.8 12.928 37
I4610 4610 0 1.29868e-05
R5115 4610 4611 1.632 0.8 13.056 37
I4611 4611 0 1.32342e-05
R5116 4611 4612 1.712 0.8 13.696 37
I4612 4612 0 1.32342e-05
R5117 4612 4613 1.712 0.8 13.696 37
I4613 4613 0 1.24921e-05
R5118 4613 4614 1.632 0.8 13.056 37
I4614 4614 0 1.28631e-05
R5119 4614 4615 1.664 0.8 13.312 37
I4615 4615 0 1.26158e-05
R5120 4615 4616 1.664 0.8 13.312 37
I4616 4616 0 1.34816e-05
R5121 4616 4617 1.744 0.8 13.952 37
I4617 4617 0 1.28631e-05
R5122 4617 4618 1.728 0.8 13.824 37
I4618 4618 0 1.29868e-05
R5123 4618 4619 1.632 0.8 13.056 37
I4619 4619 0 1.29868e-05
R5124 4619 4620 1.664 0.8 13.312 37
I4620 4620 0 1.29868e-05
R5125 4620 4621 1.632 0.8 13.056 37
I4621 4621 0 1.29868e-05
R5126 4621 4622 1.616 0.8 12.928 37
I4622 4622 0 1.26158e-05
R5127 4622 4623 1.648 0.8 13.184 37
I4623 4623 0 1.32342e-05
R5128 4623 4624 1.696 0.8 13.568 37
I4624 4624 0 1.23684e-05
R5129 4624 4625 1.696 0.8 13.568 37
I4625 4625 0 1.33579e-05
R5130 4625 4626 1.712 0.8 13.696 37
I4626 4626 0 1.34816e-05
R5131 4626 4627 1.68 0.8 13.44 37
I4627 4627 0 1.28631e-05
R5132 4627 4628 1.728 0.8 13.824 37
I4628 4628 0 1.29868e-05
R5133 4628 4629 1.712 0.8 13.696 37
I4629 4629 0 1.27395e-05
R5134 4629 4630 1.744 0.8 13.952 37
I4630 4630 0 1.26158e-05
R5135 4630 4631 1.68 0.8 13.44 37
I4631 4631 0 1.29868e-05
R5136 4631 4632 1.616 0.8 12.928 37
I4632 4632 0 1.31105e-05
R5137 4632 4633 1.6 0.8 12.8 37
I4633 4633 0 1.24921e-05
R5138 4633 4634 1.632 0.8 13.056 37
I4634 4634 0 1.28631e-05
R5139 4634 4635 1.744 0.8 13.952 37
I4635 4635 0 1.33579e-05
R5140 4635 4636 1.744 0.8 13.952 37
I4636 4636 0 1.24921e-05
R5141 4636 4637 1.664 0.8 13.312 37
I4637 4637 0 1.26158e-05
R5142 4637 4638 1.68 0.8 13.44 37
I4638 4638 0 1.32342e-05
R5143 4638 4639 1.6 0.8 12.8 37
I4639 4639 0 1.26158e-05
R5144 4639 4640 1.6 0.8 12.8 37
I4640 4640 0 1.33579e-05
R5145 4640 4641 1.6 0.8 12.8 37
I4641 4641 0 1.32342e-05
R5146 4641 4642 1.712 0.8 13.696 37
I4642 4642 0 1.32342e-05
R5147 4642 4643 1.664 0.8 13.312 37
I4643 4643 0 1.31105e-05
R5148 4643 4644 1.632 0.8 13.056 37
I4644 4644 0 1.27395e-05
R5149 4644 4645 1.744 0.8 13.952 37
I4645 4645 0 1.28631e-05
R5150 4645 4646 1.712 0.8 13.696 37
I4646 4646 0 1.31105e-05
R5151 4646 4647 1.744 0.8 13.952 37
I4647 4647 0 1.33579e-05
R5152 4647 4648 1.632 0.8 13.056 37
I4648 4648 0 1.24921e-05
R5153 4648 4649 1.632 0.8 13.056 37
I4649 4649 0 1.31105e-05
R5154 4649 4650 1.712 0.8 13.696 37
I4650 4650 0 1.27395e-05
R5155 4650 4651 1.68 0.8 13.44 37
I4651 4651 0 1.31105e-05
R5156 4651 4652 1.696 0.8 13.568 37
I4652 4652 0 1.24921e-05
R5157 4652 4653 1.616 0.8 12.928 37
I4653 4653 0 1.24921e-05
R5158 4653 4654 1.728 0.8 13.824 37
I4654 4654 0 1.27395e-05
R5159 4654 4655 1.648 0.8 13.184 37
I4655 4655 0 1.33579e-05
R5160 4655 4656 1.616 0.8 12.928 37
I4656 4656 0 1.29868e-05
R5161 4656 4657 1.696 0.8 13.568 37
I4657 4657 0 1.34816e-05
R5162 4657 4658 1.68 0.8 13.44 37
I4658 4658 0 1.26158e-05
R5163 4658 4659 1.712 0.8 13.696 37
I4659 4659 0 1.34816e-05
R5164 4659 4660 1.68 0.8 13.44 37
I4660 4660 0 1.33579e-05
R5165 4660 4661 1.648 0.8 13.184 37
I4661 4661 0 1.27395e-05
R5166 4661 4662 1.696 0.8 13.568 37
I4662 4662 0 1.29868e-05
R5167 4662 4663 1.648 0.8 13.184 37
I4663 4663 0 1.23684e-05
R5168 4663 4664 1.728 0.8 13.824 37
I4664 4664 0 1.32342e-05
R5169 4664 4665 1.712 0.8 13.696 37
I4665 4665 0 1.31105e-05
R5170 4665 4666 1.6 0.8 12.8 37
I4666 4666 0 1.28631e-05
R5171 4666 4667 1.664 0.8 13.312 37
I4667 4667 0 1.31105e-05
R5172 4667 4668 1.68 0.8 13.44 37
I4668 4668 0 1.32342e-05
R5173 4668 4669 1.6 0.8 12.8 37
I4669 4669 0 1.29868e-05
R5174 4669 4670 1.6 0.8 12.8 37
I4670 4670 0 1.29868e-05
R5175 4670 4671 1.664 0.8 13.312 37
I4671 4671 0 1.26158e-05
R5176 4671 4672 1.616 0.8 12.928 37
I4672 4672 0 1.26158e-05
R5177 4672 4673 1.616 0.8 12.928 37
I4673 4673 0 1.31105e-05
R5178 4673 4674 1.696 0.8 13.568 37
I4674 4674 0 1.23684e-05
R5179 4674 4675 1.68 0.8 13.44 37
I4675 4675 0 1.24921e-05
R5180 4675 4676 1.728 0.8 13.824 37
I4676 4676 0 1.24921e-05
R5181 4676 4677 1.696 0.8 13.568 37
I4677 4677 0 1.31105e-05
R5182 4677 4678 1.728 0.8 13.824 37
I4678 4678 0 1.23684e-05
R5183 4678 4679 1.696 0.8 13.568 37
I4679 4679 0 1.33579e-05
R5184 4679 4680 1.744 0.8 13.952 37
I4680 4680 0 1.29868e-05
R5185 4680 4681 1.696 0.8 13.568 37
I4681 4681 0 1.23684e-05
R5186 4681 4682 1.744 0.8 13.952 37
I4682 4682 0 1.27395e-05
R5187 4682 4683 1.728 0.8 13.824 37
I4683 4683 0 1.31105e-05
R5188 4683 4684 1.6 0.8 12.8 37
I4684 4684 0 1.23684e-05
R5189 4684 4685 1.664 0.8 13.312 37
I4685 4685 0 1.24921e-05
R5190 4685 4686 1.696 0.8 13.568 37
I4686 4686 0 1.33579e-05
R5191 4686 4687 1.648 0.8 13.184 37
I4687 4687 0 1.34816e-05
R5192 4687 4688 1.632 0.8 13.056 37
I4688 4688 0 1.31105e-05
R5193 4688 4689 1.712 0.8 13.696 37
I4689 4689 0 1.23684e-05
R5194 4689 4690 1.728 0.8 13.824 37
I4690 4690 0 1.28631e-05
R5195 4690 4691 1.616 0.8 12.928 37
I4691 4691 0 1.33579e-05
R5196 4691 4692 1.68 0.8 13.44 37
I4692 4692 0 1.23684e-05
R5197 4692 4693 1.664 0.8 13.312 37
I4693 4693 0 1.29868e-05
R5198 4693 4694 1.6 0.8 12.8 37
I4694 4694 0 1.23684e-05
R5199 4694 4695 1.696 0.8 13.568 37
I4695 4695 0 1.34816e-05
R5200 4695 4696 1.696 0.8 13.568 37
I4696 4696 0 1.26158e-05
R5201 4696 4697 1.616 0.8 12.928 37
I4697 4697 0 1.32342e-05
R5202 4697 4698 1.68 0.8 13.44 37
I4698 4698 0 1.26158e-05
R5203 4698 4699 1.696 0.8 13.568 37
I4699 4699 0 1.33579e-05
R5204 4699 4700 1.632 0.8 13.056 37
I4700 4700 0 1.23684e-05
R5205 4700 4701 1.744 0.8 13.952 37
I4701 4701 0 1.23684e-05
R5206 4701 4702 1.6 0.8 12.8 37
I4702 4702 0 1.28631e-05
R5207 4702 4703 1.744 0.8 13.952 37
I4703 4703 0 1.26158e-05
R5208 4703 4704 1.6 0.8 12.8 37
I4704 4704 0 1.31105e-05
R5209 4704 4705 1.632 0.8 13.056 37
I4705 4705 0 1.33579e-05
R5210 4705 4706 1.616 0.8 12.928 37
I4706 4706 0 1.29868e-05
R5211 4706 4707 1.728 0.8 13.824 37
I4707 4707 0 1.33579e-05
R5212 4707 4708 1.68 0.8 13.44 37
I4708 4708 0 1.26158e-05
R5213 4708 4709 1.696 0.8 13.568 37
I4709 4709 0 1.32342e-05
R5214 4709 4710 1.632 0.8 13.056 37
I4710 4710 0 1.26158e-05
R5215 4710 4711 1.744 0.8 13.952 37
I4711 4711 0 1.23684e-05
R5216 4711 4712 1.696 0.8 13.568 37
I4712 4712 0 1.23684e-05
R5217 4712 4713 1.6 0.8 12.8 37
I4713 4713 0 1.26158e-05
R5218 4713 4714 1.664 0.8 13.312 37
I4714 4714 0 1.31105e-05
R5219 4714 4715 1.6 0.8 12.8 37
I4715 4715 0 1.34816e-05
R5220 4715 4716 1.696 0.8 13.568 37
I4716 4716 0 1.24921e-05
R5221 4716 4717 1.744 0.8 13.952 37
I4717 4717 0 1.31105e-05
R5222 4717 4718 1.68 0.8 13.44 37
I4718 4718 0 1.34816e-05
R5223 4718 4719 1.6 0.8 12.8 37
I4719 4719 0 1.32342e-05
R5224 4719 4720 1.712 0.8 13.696 37
I4720 4720 0 1.28631e-05
R5225 4720 4721 1.712 0.8 13.696 37
I4721 4721 0 1.33579e-05
R5226 4721 4722 1.744 0.8 13.952 37
I4722 4722 0 1.29868e-05
R5227 4722 4723 1.744 0.8 13.952 37
I4723 4723 0 1.32342e-05
R5228 4723 4724 1.712 0.8 13.696 37
I4724 4724 0 1.29868e-05
R5229 4724 4725 1.664 0.8 13.312 37
I4725 4725 0 1.24921e-05
R5230 4725 4726 1.712 0.8 13.696 37
I4726 4726 0 1.27395e-05
R5231 4726 4727 1.632 0.8 13.056 37
I4727 4727 0 1.29868e-05
R5232 4727 4728 1.696 0.8 13.568 37
I4728 4728 0 1.26158e-05
R5233 4728 4729 1.744 0.8 13.952 37
I4729 4729 0 1.26158e-05
R5234 4729 4730 1.6 0.8 12.8 37
I4730 4730 0 1.24921e-05
R5235 4730 4731 1.616 0.8 12.928 37
I4731 4731 0 1.31105e-05
R5236 4731 4732 1.632 0.8 13.056 37
I4732 4732 0 1.24921e-05
R5237 4732 4733 1.664 0.8 13.312 37
I4733 4733 0 1.32342e-05
R5238 4733 4734 1.632 0.8 13.056 37
I4734 4734 0 1.28631e-05
R5239 4734 4735 1.664 0.8 13.312 37
I4735 4735 0 1.34816e-05
R5240 4735 4736 1.728 0.8 13.824 37
I4736 4736 0 1.24921e-05
R5241 4736 4737 1.728 0.8 13.824 37
I4737 4737 0 1.34816e-05
R5242 4737 4738 1.728 0.8 13.824 37
I4738 4738 0 1.34816e-05
R5243 4738 4739 1.696 0.8 13.568 37
I4739 4739 0 1.29868e-05
R5244 4739 4740 1.664 0.8 13.312 37
I4740 4740 0 1.27395e-05
R5245 4740 4741 1.712 0.8 13.696 37
I4741 4741 0 1.27395e-05
R5246 4741 4742 1.696 0.8 13.568 37
I4742 4742 0 1.24921e-05
R5247 4742 4743 1.728 0.8 13.824 37
I4743 4743 0 1.28631e-05
R5248 4743 4744 1.68 0.8 13.44 37
I4744 4744 0 1.33579e-05
R5249 4744 4745 1.712 0.8 13.696 37
I4745 4745 0 1.29868e-05
R5250 4745 4746 1.744 0.8 13.952 37
I4746 4746 0 1.33579e-05
R5251 4746 4747 1.616 0.8 12.928 37
I4747 4747 0 1.28631e-05
R5252 4747 4748 1.616 0.8 12.928 37
I4748 4748 0 1.29868e-05
R5253 4748 4749 1.648 0.8 13.184 37
I4749 4749 0 1.27395e-05
R5254 4749 4750 1.616 0.8 12.928 37
I4750 4750 0 1.33579e-05
R5255 4750 4751 1.648 0.8 13.184 37
I4751 4751 0 1.34816e-05
R5256 4751 4752 1.616 0.8 12.928 37
I4752 4752 0 1.27395e-05
R5257 4752 4753 1.728 0.8 13.824 37
I4753 4753 0 1.23684e-05
R5258 4753 4754 1.632 0.8 13.056 37
I4754 4754 0 1.32342e-05
R5259 4754 4755 1.712 0.8 13.696 37
I4755 4755 0 1.33579e-05
R5260 4755 4756 1.6 0.8 12.8 37
I4756 4756 0 1.28631e-05
R5261 4756 4757 1.616 0.8 12.928 37
I4757 4757 0 1.33579e-05
R5262 4757 4758 1.712 0.8 13.696 37
I4758 4758 0 1.24921e-05
R5263 4758 4759 1.648 0.8 13.184 37
I4759 4759 0 1.26158e-05
R5264 4759 4760 1.616 0.8 12.928 37
I4760 4760 0 1.26158e-05
R5265 4760 4761 1.712 0.8 13.696 37
I4761 4761 0 1.24921e-05
R5266 4761 4762 1.6 0.8 12.8 37
I4762 4762 0 1.23684e-05
R5267 4762 4763 1.712 0.8 13.696 37
I4763 4763 0 1.28631e-05
R5268 4763 4764 1.712 0.8 13.696 37
I4764 4764 0 1.23684e-05
R5269 4764 4765 1.712 0.8 13.696 37
I4765 4765 0 1.33579e-05
R5270 4765 4766 1.6 0.8 12.8 37
I4766 4766 0 1.26158e-05
R5271 4766 4767 1.744 0.8 13.952 37
I4767 4767 0 1.26158e-05
R5272 4767 4768 1.712 0.8 13.696 37
I4768 4768 0 1.23684e-05
R5273 4768 4769 1.664 0.8 13.312 37
I4769 4769 0 1.34816e-05
R5274 4769 4770 1.712 0.8 13.696 37
I4770 4770 0 1.27395e-05
R5275 4770 4771 1.744 0.8 13.952 37
I4771 4771 0 1.34816e-05
R5276 4771 4772 1.6 0.8 12.8 37
I4772 4772 0 1.23684e-05
R5277 4772 4773 1.712 0.8 13.696 37
I4773 4773 0 1.32342e-05
R5278 4773 4774 1.664 0.8 13.312 37
I4774 4774 0 1.26158e-05
R5279 4774 4775 1.632 0.8 13.056 37
I4775 4775 0 1.29868e-05
R5280 4775 4776 1.664 0.8 13.312 37
I4776 4776 0 1.24921e-05
R5281 4776 4777 1.728 0.8 13.824 37
I4777 4777 0 1.32342e-05
R5282 4777 4778 1.632 0.8 13.056 37
I4778 4778 0 1.29868e-05
R5283 4778 4779 1.616 0.8 12.928 37
I4779 4779 0 1.24921e-05
R5284 4779 4780 1.696 0.8 13.568 37
I4780 4780 0 1.23684e-05
R5285 4780 4781 1.632 0.8 13.056 37
I4781 4781 0 1.31105e-05
R5286 4781 4782 1.648 0.8 13.184 37
I4782 4782 0 1.27395e-05
R5287 4782 4783 1.6 0.8 12.8 37
I4783 4783 0 1.23684e-05
R5288 4783 4784 1.648 0.8 13.184 37
I4784 4784 0 1.31105e-05
R5289 4784 4785 1.632 0.8 13.056 37
I4785 4785 0 1.26158e-05
R5290 4785 4786 1.6 0.8 12.8 37
I4786 4786 0 1.24921e-05
R5291 4786 4787 1.616 0.8 12.928 37
I4787 4787 0 1.23684e-05
R5292 4787 4788 1.664 0.8 13.312 37
I4788 4788 0 1.24921e-05
R5293 4788 4789 1.712 0.8 13.696 37
I4789 4789 0 1.33579e-05
R5294 4789 4790 1.648 0.8 13.184 37
I4790 4790 0 1.24921e-05
R5295 4790 4791 1.648 0.8 13.184 37
I4791 4791 0 1.23684e-05
R5296 4791 4792 1.648 0.8 13.184 37
I4792 4792 0 1.26158e-05
R5297 4792 4793 1.712 0.8 13.696 37
I4793 4793 0 1.32342e-05
R5298 4793 4794 1.712 0.8 13.696 37
I4794 4794 0 1.33579e-05
R5299 4794 4795 1.6 0.8 12.8 37
I4795 4795 0 1.27395e-05
R5300 4795 4796 1.728 0.8 13.824 37
I4796 4796 0 1.26158e-05
R5301 4796 4797 1.632 0.8 13.056 37
I4797 4797 0 1.27395e-05
R5302 4797 4798 1.696 0.8 13.568 37
I4798 4798 0 1.26158e-05
R5303 4798 4799 1.664 0.8 13.312 37
I4799 4799 0 1.24921e-05
R5304 4799 4800 1.744 0.8 13.952 37
I4800 4800 0 1.33579e-05
R5305 4800 4801 1.664 0.8 13.312 37
I4801 4801 0 1.34816e-05
R5306 4801 4802 1.744 0.8 13.952 37
I4802 4802 0 1.32342e-05
R5307 4802 4803 1.616 0.8 12.928 37
I4803 4803 0 1.27395e-05
R5308 4803 4804 1.728 0.8 13.824 37
I4804 4804 0 1.23684e-05
R5309 4804 4805 1.616 0.8 12.928 37
I4805 4805 0 1.28631e-05
R5310 4805 4806 1.632 0.8 13.056 37
I4806 4806 0 1.32342e-05
R5311 4806 4807 1.664 0.8 13.312 37
I4807 4807 0 1.29868e-05
R5312 4807 4808 1.744 0.8 13.952 37
I4808 4808 0 1.24921e-05
R5313 4808 4809 1.632 0.8 13.056 37
I4809 4809 0 1.33579e-05
R5314 4809 4810 1.616 0.8 12.928 37
I4810 4810 0 1.26158e-05
R5315 4810 4811 1.664 0.8 13.312 37
I4811 4811 0 1.24921e-05
R5316 4811 4812 1.712 0.8 13.696 37
I4812 4812 0 1.31105e-05
R5317 4812 4813 1.68 0.8 13.44 37
I4813 4813 0 1.29868e-05
R5318 4813 4814 1.6 0.8 12.8 37
I4814 4814 0 1.24921e-05
R5319 4814 4815 1.696 0.8 13.568 37
I4815 4815 0 1.34816e-05
R5320 4815 4816 1.744 0.8 13.952 37
I4816 4816 0 1.23684e-05
R5321 4816 4817 1.6 0.8 12.8 37
I4817 4817 0 1.33579e-05
R5322 4817 4818 1.6 0.8 12.8 37
I4818 4818 0 1.24921e-05
R5323 4818 4819 1.664 0.8 13.312 37
I4819 4819 0 1.33579e-05
R5324 4819 4820 1.632 0.8 13.056 37
I4820 4820 0 1.32342e-05
R5325 4820 4821 1.632 0.8 13.056 37
I4821 4821 0 1.31105e-05
R5326 4821 4822 1.664 0.8 13.312 37
I4822 4822 0 1.33579e-05
R5327 4822 4823 1.616 0.8 12.928 37
I4823 4823 0 1.29868e-05
R5328 4823 4824 1.744 0.8 13.952 37
I4824 4824 0 1.29868e-05
R5329 4824 4825 1.696 0.8 13.568 37
I4825 4825 0 1.26158e-05
R5330 4825 4826 1.744 0.8 13.952 37
I4826 4826 0 1.23684e-05
R5331 4826 4827 1.664 0.8 13.312 37
I4827 4827 0 1.33579e-05
R5332 4827 4828 1.728 0.8 13.824 37
I4828 4828 0 1.34816e-05
R5333 4828 4829 1.648 0.8 13.184 37
I4829 4829 0 1.33579e-05
R5334 4829 4830 1.632 0.8 13.056 37
I4830 4830 0 1.23684e-05
R5335 4830 4831 1.6 0.8 12.8 37
I4831 4831 0 1.24921e-05
R5336 4831 4832 1.632 0.8 13.056 37
I4832 4832 0 1.26158e-05
R5337 4832 4833 1.616 0.8 12.928 37
I4833 4833 0 1.26158e-05
R5338 4833 4834 1.696 0.8 13.568 37
I4834 4834 0 1.32342e-05
R5339 4834 4835 1.616 0.8 12.928 37
I4835 4835 0 1.23684e-05
R5340 4835 4836 1.68 0.8 13.44 37
I4836 4836 0 1.29868e-05
R5341 4836 4837 1.696 0.8 13.568 37
I4837 4837 0 1.34816e-05
R5342 4837 4838 1.664 0.8 13.312 37
I4838 4838 0 1.32342e-05
R5343 4838 4839 1.712 0.8 13.696 37
I4839 4839 0 1.29868e-05
R5344 4839 4840 1.664 0.8 13.312 37
I4840 4840 0 1.27395e-05
R5345 4840 4841 1.728 0.8 13.824 37
I4841 4841 0 1.29868e-05
R5346 4841 4842 1.648 0.8 13.184 37
I4842 4842 0 1.26158e-05
R5347 4842 4843 1.664 0.8 13.312 37
I4843 4843 0 1.27395e-05
R5348 4843 4844 1.648 0.8 13.184 37
I4844 4844 0 1.32342e-05
R5349 4844 4845 1.648 0.8 13.184 37
I4845 4845 0 1.29868e-05
R5350 4845 4846 1.712 0.8 13.696 37
I4846 4846 0 1.29868e-05
R5351 4846 4847 1.728 0.8 13.824 37
I4847 4847 0 1.23684e-05
R5352 4847 4848 1.728 0.8 13.824 37
I4848 4848 0 1.24921e-05
R5353 4848 4849 1.632 0.8 13.056 37
I4849 4849 0 1.28631e-05
R5354 4849 4850 1.744 0.8 13.952 37
I4850 4850 0 1.29868e-05
R5355 4850 4851 1.696 0.8 13.568 37
I4851 4851 0 1.28631e-05
R5356 4851 4852 1.648 0.8 13.184 37
I4852 4852 0 1.26158e-05
R5357 4852 4853 1.68 0.8 13.44 37
I4853 4853 0 1.32342e-05
R5358 4853 4854 1.616 0.8 12.928 37
I4854 4854 0 1.26158e-05
R5359 4854 4855 1.664 0.8 13.312 37
I4855 4855 0 1.29868e-05
R5360 4855 4856 1.712 0.8 13.696 37
I4856 4856 0 1.26158e-05
R5361 4856 4857 1.6 0.8 12.8 37
I4857 4857 0 1.26158e-05
R5362 4857 4858 1.664 0.8 13.312 37
I4858 4858 0 1.28631e-05
R5363 4858 4859 1.68 0.8 13.44 37
I4859 4859 0 1.34816e-05
R5364 4859 4860 1.664 0.8 13.312 37
I4860 4860 0 1.24921e-05
R5365 4860 4861 1.696 0.8 13.568 37
I4861 4861 0 1.24921e-05
R5366 4861 4862 1.696 0.8 13.568 37
I4862 4862 0 1.28631e-05
R5367 4862 4863 1.648 0.8 13.184 37
I4863 4863 0 1.28631e-05
R5368 4863 4864 1.696 0.8 13.568 37
I4864 4864 0 1.33579e-05
R5369 4864 4865 1.6 0.8 12.8 37
I4865 4865 0 1.32342e-05
R5370 4865 4866 1.68 0.8 13.44 37
I4866 4866 0 1.31105e-05
R5371 4866 4867 1.616 0.8 12.928 37
I4867 4867 0 1.33579e-05
R5372 4867 4868 1.6 0.8 12.8 37
I4868 4868 0 1.33579e-05
R5373 4868 4869 1.712 0.8 13.696 37
I4869 4869 0 1.24921e-05
R5374 4869 4870 1.648 0.8 13.184 37
I4870 4870 0 1.26158e-05
R5375 4870 4871 1.728 0.8 13.824 37
I4871 4871 0 1.23684e-05
R5376 4871 4872 1.664 0.8 13.312 37
I4872 4872 0 1.34816e-05
R5377 4872 4873 1.648 0.8 13.184 37
I4873 4873 0 1.24921e-05
R5378 4873 4874 1.68 0.8 13.44 37
I4874 4874 0 1.23684e-05
R5379 4874 4875 1.6 0.8 12.8 37
I4875 4875 0 1.24921e-05
R5380 4875 4876 1.616 0.8 12.928 37
I4876 4876 0 1.32342e-05
R5381 4876 4877 1.68 0.8 13.44 37
I4877 4877 0 1.33579e-05
R5382 4877 4878 1.648 0.8 13.184 37
I4878 4878 0 1.33579e-05
R5383 4878 4879 1.664 0.8 13.312 37
I4879 4879 0 1.24921e-05
R5384 4879 4880 1.728 0.8 13.824 37
I4880 4880 0 1.32342e-05
R5385 4880 4881 1.728 0.8 13.824 37
I4881 4881 0 1.28631e-05
R5386 4881 4882 1.68 0.8 13.44 37
I4882 4882 0 1.24921e-05
R5387 4882 4883 1.632 0.8 13.056 37
I4883 4883 0 1.31105e-05
R5388 4883 4884 1.6 0.8 12.8 37
I4884 4884 0 1.23684e-05
R5389 4884 4885 1.744 0.8 13.952 37
I4885 4885 0 1.27395e-05
R5390 4885 4886 1.632 0.8 13.056 37
I4886 4886 0 1.33579e-05
R5391 4886 4887 1.68 0.8 13.44 37
I4887 4887 0 1.33579e-05
R5392 4887 4888 1.744 0.8 13.952 37
I4888 4888 0 1.23684e-05
R5393 4888 4889 1.744 0.8 13.952 37
I4889 4889 0 1.31105e-05
R5394 4889 4890 1.616 0.8 12.928 37
I4890 4890 0 1.26158e-05
R5395 4890 4891 1.728 0.8 13.824 37
I4891 4891 0 1.28631e-05
R5396 4891 4892 1.616 0.8 12.928 37
I4892 4892 0 1.27395e-05
R5397 4892 4893 1.664 0.8 13.312 37
I4893 4893 0 1.28631e-05
R5398 4893 4894 1.648 0.8 13.184 37
I4894 4894 0 1.34816e-05
R5399 4894 4895 1.696 0.8 13.568 37
I4895 4895 0 1.26158e-05
R5400 4895 4896 1.728 0.8 13.824 37
I4896 4896 0 1.31105e-05
R5401 4896 4897 1.728 0.8 13.824 37
I4897 4897 0 1.27395e-05
R5402 4897 4898 1.728 0.8 13.824 37
I4898 4898 0 1.26158e-05
R5403 4898 4899 1.616 0.8 12.928 37
I4899 4899 0 1.23684e-05
R5404 4899 4900 1.632 0.8 13.056 37
I4900 4900 0 1.24921e-05
R5405 4900 4901 1.68 0.8 13.44 37
I4901 4901 0 1.31105e-05
R5406 4901 4902 1.744 0.8 13.952 37
I4902 4902 0 1.23684e-05
R5407 4902 4903 1.712 0.8 13.696 37
I4903 4903 0 1.23684e-05
R5408 4903 4904 1.616 0.8 12.928 37
I4904 4904 0 1.31105e-05
R5409 4904 4905 1.696 0.8 13.568 37
I4905 4905 0 1.28631e-05
R5410 4905 4906 1.728 0.8 13.824 37
I4906 4906 0 1.28631e-05
R5411 4906 4907 1.6 0.8 12.8 37
I4907 4907 0 1.34816e-05
R5412 4907 4908 1.744 0.8 13.952 37
I4908 4908 0 1.29868e-05
R5413 4908 4909 1.696 0.8 13.568 37
I4909 4909 0 1.29868e-05
R5414 4909 4910 1.696 0.8 13.568 37
I4910 4910 0 1.28631e-05
R5415 4910 4911 1.712 0.8 13.696 37
I4911 4911 0 1.28631e-05
R5416 4911 4912 1.6 0.8 12.8 37
I4912 4912 0 1.32342e-05
R5417 4912 4913 1.744 0.8 13.952 37
I4913 4913 0 1.23684e-05
R5418 4913 4914 1.744 0.8 13.952 37
I4914 4914 0 1.24921e-05
R5419 4914 4915 1.6 0.8 12.8 37
I4915 4915 0 1.28631e-05
R5420 4915 4916 1.632 0.8 13.056 37
I4916 4916 0 1.29868e-05
R5421 4916 4917 1.632 0.8 13.056 37
I4917 4917 0 1.27395e-05
R5422 4917 4918 1.728 0.8 13.824 37
I4918 4918 0 1.34816e-05
R5423 4918 4919 1.648 0.8 13.184 37
I4919 4919 0 1.24921e-05
R5424 4919 4920 1.696 0.8 13.568 37
I4920 4920 0 1.24921e-05
R5425 4920 4921 1.712 0.8 13.696 37
I4921 4921 0 1.31105e-05
R5426 4921 4922 1.728 0.8 13.824 37
I4922 4922 0 1.32342e-05
R5427 4922 4923 1.728 0.8 13.824 37
I4923 4923 0 1.32342e-05
R5428 4923 4924 1.664 0.8 13.312 37
I4924 4924 0 1.28631e-05
R5429 4924 4925 1.632 0.8 13.056 37
I4925 4925 0 1.23684e-05
R5430 4925 4926 1.6 0.8 12.8 37
I4926 4926 0 1.24921e-05
R5431 4926 4927 1.696 0.8 13.568 37
I4927 4927 0 1.23684e-05
R5432 4927 4928 1.728 0.8 13.824 37
I4928 4928 0 1.33579e-05
R5433 4928 4929 1.616 0.8 12.928 37
I4929 4929 0 1.23684e-05
R5434 4929 4930 1.744 0.8 13.952 37
I4930 4930 0 1.27395e-05
R5435 4930 4931 1.664 0.8 13.312 37
I4931 4931 0 1.27395e-05
R5436 4931 4932 1.616 0.8 12.928 37
I4932 4932 0 1.33579e-05
R5437 4932 4933 1.728 0.8 13.824 37
I4933 4933 0 1.34816e-05
R5438 4933 4934 1.728 0.8 13.824 37
I4934 4934 0 1.27395e-05
R5439 4934 4935 1.6 0.8 12.8 37
I4935 4935 0 1.31105e-05
R5440 4935 4936 1.664 0.8 13.312 37
I4936 4936 0 1.34816e-05
R5441 4936 4937 1.632 0.8 13.056 37
I4937 4937 0 1.26158e-05
R5442 4937 4938 1.696 0.8 13.568 37
I4938 4938 0 1.26158e-05
R5443 4938 4939 1.6 0.8 12.8 37
I4939 4939 0 1.24921e-05
R5444 4939 4940 1.728 0.8 13.824 37
I4940 4940 0 1.28631e-05
R5445 4940 4941 1.648 0.8 13.184 37
I4941 4941 0 1.33579e-05
R5446 4941 4942 1.728 0.8 13.824 37
I4942 4942 0 1.26158e-05
R5447 4942 4943 1.744 0.8 13.952 37
I4943 4943 0 1.31105e-05
R5448 4943 4944 1.6 0.8 12.8 37
I4944 4944 0 1.26158e-05
R5449 4944 4945 1.728 0.8 13.824 37
I4945 4945 0 1.24921e-05
R5450 4945 4946 1.712 0.8 13.696 37
I4946 4946 0 1.28631e-05
R5451 4946 4947 1.664 0.8 13.312 37
I4947 4947 0 1.33579e-05
R5452 4947 4948 1.648 0.8 13.184 37
I4948 4948 0 1.28631e-05
R5453 4948 4949 1.744 0.8 13.952 37
I4949 4949 0 1.24921e-05
R5454 4949 4950 1.712 0.8 13.696 37
I4950 4950 0 1.24921e-05
R5455 4950 4951 1.712 0.8 13.696 37
I4951 4951 0 1.24921e-05
R5456 4951 4952 1.6 0.8 12.8 37
I4952 4952 0 1.24921e-05
R5457 4952 4953 1.664 0.8 13.312 37
I4953 4953 0 1.32342e-05
R5458 4953 4954 1.696 0.8 13.568 37
I4954 4954 0 1.31105e-05
R5459 4954 4955 1.6 0.8 12.8 37
I4955 4955 0 1.28631e-05
R5460 4955 4956 1.632 0.8 13.056 37
I4956 4956 0 1.29868e-05
R5461 4956 4957 1.648 0.8 13.184 37
I4957 4957 0 1.23684e-05
R5462 4957 4958 1.744 0.8 13.952 37
I4958 4958 0 1.26158e-05
R5463 4958 4959 1.744 0.8 13.952 37
I4959 4959 0 1.34816e-05
R5464 4959 4960 1.696 0.8 13.568 37
I4960 4960 0 1.32342e-05
R5465 4960 4961 1.632 0.8 13.056 37
I4961 4961 0 1.27395e-05
R5466 4961 4962 1.632 0.8 13.056 37
I4962 4962 0 1.31105e-05
R5467 4962 4963 1.664 0.8 13.312 37
I4963 4963 0 1.29868e-05
R5468 4963 4964 1.632 0.8 13.056 37
I4964 4964 0 1.27395e-05
R5469 4964 4965 1.728 0.8 13.824 37
I4965 4965 0 1.34816e-05
R5470 4965 4966 1.68 0.8 13.44 37
I4966 4966 0 1.32342e-05
R5471 4966 4967 1.616 0.8 12.928 37
I4967 4967 0 1.32342e-05
R5472 4967 4968 1.6 0.8 12.8 37
I4968 4968 0 1.32342e-05
R5473 4968 4969 1.664 0.8 13.312 37
I4969 4969 0 1.31105e-05
R5474 4969 4970 1.648 0.8 13.184 37
I4970 4970 0 1.31105e-05
R5475 4970 4971 1.616 0.8 12.928 37
I4971 4971 0 1.29868e-05
R5476 4971 4972 1.664 0.8 13.312 37
I4972 4972 0 1.28631e-05
R5477 4972 4973 1.728 0.8 13.824 37
I4973 4973 0 1.27395e-05
R5478 4973 4974 1.728 0.8 13.824 37
I4974 4974 0 1.32342e-05
R5479 4974 4975 1.648 0.8 13.184 37
I4975 4975 0 1.31105e-05
R5480 4975 4976 1.664 0.8 13.312 37
I4976 4976 0 1.32342e-05
R5481 4976 4977 1.616 0.8 12.928 37
I4977 4977 0 1.33579e-05
R5482 4977 4978 1.664 0.8 13.312 37
I4978 4978 0 1.29868e-05
R5483 4978 4979 1.68 0.8 13.44 37
I4979 4979 0 1.33579e-05
R5484 4979 4980 1.616 0.8 12.928 37
I4980 4980 0 1.27395e-05
R5485 4980 4981 1.728 0.8 13.824 37
I4981 4981 0 1.33579e-05
R5486 4981 4982 1.632 0.8 13.056 37
I4982 4982 0 1.34816e-05
R5487 4982 4983 1.68 0.8 13.44 37
I4983 4983 0 1.27395e-05
R5488 4983 4984 1.696 0.8 13.568 37
I4984 4984 0 1.26158e-05
R5489 4984 4985 1.616 0.8 12.928 37
I4985 4985 0 1.24921e-05
R5490 4985 4986 1.6 0.8 12.8 37
I4986 4986 0 1.26158e-05
R5491 4986 4987 1.728 0.8 13.824 37
I4987 4987 0 1.28631e-05
R5492 4987 4988 1.728 0.8 13.824 37
I4988 4988 0 1.31105e-05
R5493 4988 4989 1.728 0.8 13.824 37
I4989 4989 0 1.33579e-05
R5494 4989 4990 1.648 0.8 13.184 37
I4990 4990 0 1.27395e-05
R5495 4990 4991 1.664 0.8 13.312 37
I4991 4991 0 1.23684e-05
R5496 4991 4992 1.6 0.8 12.8 37
I4992 4992 0 1.31105e-05
R5497 4992 4993 1.728 0.8 13.824 37
I4993 4993 0 1.31105e-05
R5498 4993 4994 1.648 0.8 13.184 37
I4994 4994 0 1.28631e-05
R5499 4994 4995 1.68 0.8 13.44 37
I4995 4995 0 1.28631e-05
R5500 4995 4996 1.744 0.8 13.952 37
I4996 4996 0 1.27395e-05
R5501 4996 4997 1.632 0.8 13.056 37
I4997 4997 0 1.26158e-05
R5502 4997 4998 1.664 0.8 13.312 37
I4998 4998 0 1.23684e-05
R5503 4998 4999 1.712 0.8 13.696 37
I4999 4999 0 1.26158e-05
R5504 4999 5000 1.632 0.8 13.056 37
I5000 5000 0 1.23684e-05
R5505 5000 10001 0.5 10 50 37
*seg: 6
* inter-segment connection
R5506 5010 6010 6.16 0.8 49.28 37
R5507 5020 6020 6.16 0.8 49.28 37
R5508 5030 6030 6.16 0.8 49.28 37
R5509 5040 6040 6.16 0.8 49.28 37
R5510 5050 6050 6.16 0.8 49.28 37
R5511 5060 6060 6.16 0.8 49.28 37
R5512 5070 6070 6.16 0.8 49.28 37
R5513 5080 6080 6.16 0.8 49.28 37
R5514 5090 6090 6.16 0.8 49.28 37
R5515 5100 6100 6.16 0.8 49.28 37
R5516 5110 6110 6.16 0.8 49.28 37
R5517 5120 6120 6.16 0.8 49.28 37
R5518 5130 6130 6.16 0.8 49.28 37
R5519 5140 6140 6.16 0.8 49.28 37
R5520 5150 6150 6.16 0.8 49.28 37
R5521 5160 6160 6.16 0.8 49.28 37
R5522 5170 6170 6.16 0.8 49.28 37
R5523 5180 6180 6.16 0.8 49.28 37
R5524 5190 6190 6.16 0.8 49.28 37
R5525 5200 6200 6.16 0.8 49.28 37
R5526 5210 6210 6.16 0.8 49.28 37
R5527 5220 6220 6.16 0.8 49.28 37
R5528 5230 6230 6.16 0.8 49.28 37
R5529 5240 6240 6.16 0.8 49.28 37
R5530 5250 6250 6.16 0.8 49.28 37
R5531 5260 6260 6.16 0.8 49.28 37
R5532 5270 6270 6.16 0.8 49.28 37
R5533 5280 6280 6.16 0.8 49.28 37
R5534 5290 6290 6.16 0.8 49.28 37
R5535 5300 6300 6.16 0.8 49.28 37
R5536 5310 6310 6.16 0.8 49.28 37
R5537 5320 6320 6.16 0.8 49.28 37
R5538 5330 6330 6.16 0.8 49.28 37
R5539 5340 6340 6.16 0.8 49.28 37
R5540 5350 6350 6.16 0.8 49.28 37
R5541 5360 6360 6.16 0.8 49.28 37
R5542 5370 6370 6.16 0.8 49.28 37
R5543 5380 6380 6.16 0.8 49.28 37
R5544 5390 6390 6.16 0.8 49.28 37
R5545 5400 6400 6.16 0.8 49.28 37
R5546 5410 6410 6.16 0.8 49.28 37
R5547 5420 6420 6.16 0.8 49.28 37
R5548 5430 6430 6.16 0.8 49.28 37
R5549 5440 6440 6.16 0.8 49.28 37
R5550 5450 6450 6.16 0.8 49.28 37
R5551 5460 6460 6.16 0.8 49.28 37
R5552 5470 6470 6.16 0.8 49.28 37
R5553 5480 6480 6.16 0.8 49.28 37
R5554 5490 6490 6.16 0.8 49.28 37
R5555 5500 6500 6.16 0.8 49.28 37
R5556 5510 6510 6.16 0.8 49.28 37
R5557 5520 6520 6.16 0.8 49.28 37
R5558 5530 6530 6.16 0.8 49.28 37
R5559 5540 6540 6.16 0.8 49.28 37
R5560 5550 6550 6.16 0.8 49.28 37
R5561 5560 6560 6.16 0.8 49.28 37
R5562 5570 6570 6.16 0.8 49.28 37
R5563 5580 6580 6.16 0.8 49.28 37
R5564 5590 6590 6.16 0.8 49.28 37
R5565 5600 6600 6.16 0.8 49.28 37
R5566 5610 6610 6.16 0.8 49.28 37
R5567 5620 6620 6.16 0.8 49.28 37
R5568 5630 6630 6.16 0.8 49.28 37
R5569 5640 6640 6.16 0.8 49.28 37
R5570 5650 6650 6.16 0.8 49.28 37
R5571 5660 6660 6.16 0.8 49.28 37
R5572 5670 6670 6.16 0.8 49.28 37
R5573 5680 6680 6.16 0.8 49.28 37
R5574 5690 6690 6.16 0.8 49.28 37
R5575 5700 6700 6.16 0.8 49.28 37
R5576 5710 6710 6.16 0.8 49.28 37
R5577 5720 6720 6.16 0.8 49.28 37
R5578 5730 6730 6.16 0.8 49.28 37
R5579 5740 6740 6.16 0.8 49.28 37
R5580 5750 6750 6.16 0.8 49.28 37
R5581 5760 6760 6.16 0.8 49.28 37
R5582 5770 6770 6.16 0.8 49.28 37
R5583 5780 6780 6.16 0.8 49.28 37
R5584 5790 6790 6.16 0.8 49.28 37
R5585 5800 6800 6.16 0.8 49.28 37
R5586 5810 6810 6.16 0.8 49.28 37
R5587 5820 6820 6.16 0.8 49.28 37
R5588 5830 6830 6.16 0.8 49.28 37
R5589 5840 6840 6.16 0.8 49.28 37
R5590 5850 6850 6.16 0.8 49.28 37
R5591 5860 6860 6.16 0.8 49.28 37
R5592 5870 6870 6.16 0.8 49.28 37
R5593 5880 6880 6.16 0.8 49.28 37
R5594 5890 6890 6.16 0.8 49.28 37
R5595 5900 6900 6.16 0.8 49.28 37
R5596 5910 6910 6.16 0.8 49.28 37
R5597 5920 6920 6.16 0.8 49.28 37
R5598 5930 6930 6.16 0.8 49.28 37
R5599 5940 6940 6.16 0.8 49.28 37
R5600 5950 6950 6.16 0.8 49.28 37
R5601 5960 6960 6.16 0.8 49.28 37
R5602 5970 6970 6.16 0.8 49.28 37
R5603 5980 6980 6.16 0.8 49.28 37
R5604 5990 6990 6.16 0.8 49.28 37
R5605 6000 7000 6.16 0.8 49.28 37
R5606 10001 5001 0.4 20 80 37
I5001 5001 0 1.33579e-05
R5607 5001 5002 1.68 0.8 13.44 37
I5002 5002 0 1.26158e-05
R5608 5002 5003 1.648 0.8 13.184 37
I5003 5003 0 1.27395e-05
R5609 5003 5004 1.712 0.8 13.696 37
I5004 5004 0 1.24921e-05
R5610 5004 5005 1.632 0.8 13.056 37
I5005 5005 0 1.32342e-05
R5611 5005 5006 1.6 0.8 12.8 37
I5006 5006 0 1.32342e-05
R5612 5006 5007 1.6 0.8 12.8 37
I5007 5007 0 1.31105e-05
R5613 5007 5008 1.712 0.8 13.696 37
I5008 5008 0 1.26158e-05
R5614 5008 5009 1.632 0.8 13.056 37
I5009 5009 0 1.31105e-05
R5615 5009 5010 1.744 0.8 13.952 37
I5010 5010 0 1.31105e-05
R5616 5010 5011 1.632 0.8 13.056 37
I5011 5011 0 1.31105e-05
R5617 5011 5012 1.632 0.8 13.056 37
I5012 5012 0 1.27395e-05
R5618 5012 5013 1.744 0.8 13.952 37
I5013 5013 0 1.32342e-05
R5619 5013 5014 1.68 0.8 13.44 37
I5014 5014 0 1.29868e-05
R5620 5014 5015 1.712 0.8 13.696 37
I5015 5015 0 1.28631e-05
R5621 5015 5016 1.712 0.8 13.696 37
I5016 5016 0 1.24921e-05
R5622 5016 5017 1.68 0.8 13.44 37
I5017 5017 0 1.26158e-05
R5623 5017 5018 1.648 0.8 13.184 37
I5018 5018 0 1.33579e-05
R5624 5018 5019 1.712 0.8 13.696 37
I5019 5019 0 1.26158e-05
R5625 5019 5020 1.616 0.8 12.928 37
I5020 5020 0 1.34816e-05
R5626 5020 5021 1.744 0.8 13.952 37
I5021 5021 0 1.27395e-05
R5627 5021 5022 1.712 0.8 13.696 37
I5022 5022 0 1.24921e-05
R5628 5022 5023 1.6 0.8 12.8 37
I5023 5023 0 1.31105e-05
R5629 5023 5024 1.696 0.8 13.568 37
I5024 5024 0 1.28631e-05
R5630 5024 5025 1.664 0.8 13.312 37
I5025 5025 0 1.29868e-05
R5631 5025 5026 1.6 0.8 12.8 37
I5026 5026 0 1.31105e-05
R5632 5026 5027 1.648 0.8 13.184 37
I5027 5027 0 1.29868e-05
R5633 5027 5028 1.6 0.8 12.8 37
I5028 5028 0 1.28631e-05
R5634 5028 5029 1.632 0.8 13.056 37
I5029 5029 0 1.32342e-05
R5635 5029 5030 1.744 0.8 13.952 37
I5030 5030 0 1.24921e-05
R5636 5030 5031 1.664 0.8 13.312 37
I5031 5031 0 1.33579e-05
R5637 5031 5032 1.632 0.8 13.056 37
I5032 5032 0 1.34816e-05
R5638 5032 5033 1.6 0.8 12.8 37
I5033 5033 0 1.29868e-05
R5639 5033 5034 1.712 0.8 13.696 37
I5034 5034 0 1.34816e-05
R5640 5034 5035 1.6 0.8 12.8 37
I5035 5035 0 1.33579e-05
R5641 5035 5036 1.616 0.8 12.928 37
I5036 5036 0 1.24921e-05
R5642 5036 5037 1.664 0.8 13.312 37
I5037 5037 0 1.23684e-05
R5643 5037 5038 1.68 0.8 13.44 37
I5038 5038 0 1.28631e-05
R5644 5038 5039 1.696 0.8 13.568 37
I5039 5039 0 1.24921e-05
R5645 5039 5040 1.728 0.8 13.824 37
I5040 5040 0 1.24921e-05
R5646 5040 5041 1.728 0.8 13.824 37
I5041 5041 0 1.24921e-05
R5647 5041 5042 1.744 0.8 13.952 37
I5042 5042 0 1.24921e-05
R5648 5042 5043 1.696 0.8 13.568 37
I5043 5043 0 1.24921e-05
R5649 5043 5044 1.68 0.8 13.44 37
I5044 5044 0 1.23684e-05
R5650 5044 5045 1.744 0.8 13.952 37
I5045 5045 0 1.31105e-05
R5651 5045 5046 1.616 0.8 12.928 37
I5046 5046 0 1.27395e-05
R5652 5046 5047 1.664 0.8 13.312 37
I5047 5047 0 1.27395e-05
R5653 5047 5048 1.664 0.8 13.312 37
I5048 5048 0 1.31105e-05
R5654 5048 5049 1.6 0.8 12.8 37
I5049 5049 0 1.24921e-05
R5655 5049 5050 1.68 0.8 13.44 37
I5050 5050 0 1.23684e-05
R5656 5050 5051 1.616 0.8 12.928 37
I5051 5051 0 1.33579e-05
R5657 5051 5052 1.632 0.8 13.056 37
I5052 5052 0 1.29868e-05
R5658 5052 5053 1.728 0.8 13.824 37
I5053 5053 0 1.34816e-05
R5659 5053 5054 1.744 0.8 13.952 37
I5054 5054 0 1.32342e-05
R5660 5054 5055 1.6 0.8 12.8 37
I5055 5055 0 1.23684e-05
R5661 5055 5056 1.728 0.8 13.824 37
I5056 5056 0 1.23684e-05
R5662 5056 5057 1.616 0.8 12.928 37
I5057 5057 0 1.34816e-05
R5663 5057 5058 1.616 0.8 12.928 37
I5058 5058 0 1.34816e-05
R5664 5058 5059 1.616 0.8 12.928 37
I5059 5059 0 1.33579e-05
R5665 5059 5060 1.744 0.8 13.952 37
I5060 5060 0 1.26158e-05
R5666 5060 5061 1.664 0.8 13.312 37
I5061 5061 0 1.23684e-05
R5667 5061 5062 1.712 0.8 13.696 37
I5062 5062 0 1.33579e-05
R5668 5062 5063 1.648 0.8 13.184 37
I5063 5063 0 1.24921e-05
R5669 5063 5064 1.664 0.8 13.312 37
I5064 5064 0 1.27395e-05
R5670 5064 5065 1.664 0.8 13.312 37
I5065 5065 0 1.24921e-05
R5671 5065 5066 1.696 0.8 13.568 37
I5066 5066 0 1.29868e-05
R5672 5066 5067 1.6 0.8 12.8 37
I5067 5067 0 1.23684e-05
R5673 5067 5068 1.648 0.8 13.184 37
I5068 5068 0 1.33579e-05
R5674 5068 5069 1.744 0.8 13.952 37
I5069 5069 0 1.28631e-05
R5675 5069 5070 1.68 0.8 13.44 37
I5070 5070 0 1.34816e-05
R5676 5070 5071 1.664 0.8 13.312 37
I5071 5071 0 1.29868e-05
R5677 5071 5072 1.616 0.8 12.928 37
I5072 5072 0 1.32342e-05
R5678 5072 5073 1.712 0.8 13.696 37
I5073 5073 0 1.26158e-05
R5679 5073 5074 1.696 0.8 13.568 37
I5074 5074 0 1.33579e-05
R5680 5074 5075 1.632 0.8 13.056 37
I5075 5075 0 1.29868e-05
R5681 5075 5076 1.632 0.8 13.056 37
I5076 5076 0 1.31105e-05
R5682 5076 5077 1.68 0.8 13.44 37
I5077 5077 0 1.24921e-05
R5683 5077 5078 1.696 0.8 13.568 37
I5078 5078 0 1.23684e-05
R5684 5078 5079 1.664 0.8 13.312 37
I5079 5079 0 1.23684e-05
R5685 5079 5080 1.664 0.8 13.312 37
I5080 5080 0 1.33579e-05
R5686 5080 5081 1.616 0.8 12.928 37
I5081 5081 0 1.26158e-05
R5687 5081 5082 1.68 0.8 13.44 37
I5082 5082 0 1.24921e-05
R5688 5082 5083 1.632 0.8 13.056 37
I5083 5083 0 1.33579e-05
R5689 5083 5084 1.632 0.8 13.056 37
I5084 5084 0 1.24921e-05
R5690 5084 5085 1.68 0.8 13.44 37
I5085 5085 0 1.34816e-05
R5691 5085 5086 1.632 0.8 13.056 37
I5086 5086 0 1.34816e-05
R5692 5086 5087 1.68 0.8 13.44 37
I5087 5087 0 1.27395e-05
R5693 5087 5088 1.712 0.8 13.696 37
I5088 5088 0 1.28631e-05
R5694 5088 5089 1.712 0.8 13.696 37
I5089 5089 0 1.27395e-05
R5695 5089 5090 1.664 0.8 13.312 37
I5090 5090 0 1.34816e-05
R5696 5090 5091 1.616 0.8 12.928 37
I5091 5091 0 1.31105e-05
R5697 5091 5092 1.68 0.8 13.44 37
I5092 5092 0 1.33579e-05
R5698 5092 5093 1.744 0.8 13.952 37
I5093 5093 0 1.24921e-05
R5699 5093 5094 1.744 0.8 13.952 37
I5094 5094 0 1.27395e-05
R5700 5094 5095 1.648 0.8 13.184 37
I5095 5095 0 1.29868e-05
R5701 5095 5096 1.648 0.8 13.184 37
I5096 5096 0 1.31105e-05
R5702 5096 5097 1.712 0.8 13.696 37
I5097 5097 0 1.33579e-05
R5703 5097 5098 1.6 0.8 12.8 37
I5098 5098 0 1.34816e-05
R5704 5098 5099 1.744 0.8 13.952 37
I5099 5099 0 1.26158e-05
R5705 5099 5100 1.632 0.8 13.056 37
I5100 5100 0 1.31105e-05
R5706 5100 5101 1.648 0.8 13.184 37
I5101 5101 0 1.28631e-05
R5707 5101 5102 1.68 0.8 13.44 37
I5102 5102 0 1.23684e-05
R5708 5102 5103 1.744 0.8 13.952 37
I5103 5103 0 1.28631e-05
R5709 5103 5104 1.664 0.8 13.312 37
I5104 5104 0 1.31105e-05
R5710 5104 5105 1.728 0.8 13.824 37
I5105 5105 0 1.33579e-05
R5711 5105 5106 1.68 0.8 13.44 37
I5106 5106 0 1.24921e-05
R5712 5106 5107 1.696 0.8 13.568 37
I5107 5107 0 1.26158e-05
R5713 5107 5108 1.744 0.8 13.952 37
I5108 5108 0 1.29868e-05
R5714 5108 5109 1.68 0.8 13.44 37
I5109 5109 0 1.33579e-05
R5715 5109 5110 1.728 0.8 13.824 37
I5110 5110 0 1.23684e-05
R5716 5110 5111 1.68 0.8 13.44 37
I5111 5111 0 1.27395e-05
R5717 5111 5112 1.696 0.8 13.568 37
I5112 5112 0 1.28631e-05
R5718 5112 5113 1.664 0.8 13.312 37
I5113 5113 0 1.33579e-05
R5719 5113 5114 1.648 0.8 13.184 37
I5114 5114 0 1.29868e-05
R5720 5114 5115 1.6 0.8 12.8 37
I5115 5115 0 1.32342e-05
R5721 5115 5116 1.616 0.8 12.928 37
I5116 5116 0 1.31105e-05
R5722 5116 5117 1.616 0.8 12.928 37
I5117 5117 0 1.31105e-05
R5723 5117 5118 1.696 0.8 13.568 37
I5118 5118 0 1.23684e-05
R5724 5118 5119 1.616 0.8 12.928 37
I5119 5119 0 1.24921e-05
R5725 5119 5120 1.728 0.8 13.824 37
I5120 5120 0 1.24921e-05
R5726 5120 5121 1.616 0.8 12.928 37
I5121 5121 0 1.29868e-05
R5727 5121 5122 1.664 0.8 13.312 37
I5122 5122 0 1.33579e-05
R5728 5122 5123 1.744 0.8 13.952 37
I5123 5123 0 1.27395e-05
R5729 5123 5124 1.648 0.8 13.184 37
I5124 5124 0 1.28631e-05
R5730 5124 5125 1.664 0.8 13.312 37
I5125 5125 0 1.28631e-05
R5731 5125 5126 1.696 0.8 13.568 37
I5126 5126 0 1.34816e-05
R5732 5126 5127 1.712 0.8 13.696 37
I5127 5127 0 1.29868e-05
R5733 5127 5128 1.664 0.8 13.312 37
I5128 5128 0 1.27395e-05
R5734 5128 5129 1.648 0.8 13.184 37
I5129 5129 0 1.34816e-05
R5735 5129 5130 1.728 0.8 13.824 37
I5130 5130 0 1.31105e-05
R5736 5130 5131 1.712 0.8 13.696 37
I5131 5131 0 1.34816e-05
R5737 5131 5132 1.632 0.8 13.056 37
I5132 5132 0 1.23684e-05
R5738 5132 5133 1.728 0.8 13.824 37
I5133 5133 0 1.23684e-05
R5739 5133 5134 1.648 0.8 13.184 37
I5134 5134 0 1.24921e-05
R5740 5134 5135 1.616 0.8 12.928 37
I5135 5135 0 1.24921e-05
R5741 5135 5136 1.632 0.8 13.056 37
I5136 5136 0 1.29868e-05
R5742 5136 5137 1.712 0.8 13.696 37
I5137 5137 0 1.31105e-05
R5743 5137 5138 1.648 0.8 13.184 37
I5138 5138 0 1.31105e-05
R5744 5138 5139 1.616 0.8 12.928 37
I5139 5139 0 1.33579e-05
R5745 5139 5140 1.648 0.8 13.184 37
I5140 5140 0 1.29868e-05
R5746 5140 5141 1.632 0.8 13.056 37
I5141 5141 0 1.34816e-05
R5747 5141 5142 1.712 0.8 13.696 37
I5142 5142 0 1.26158e-05
R5748 5142 5143 1.696 0.8 13.568 37
I5143 5143 0 1.27395e-05
R5749 5143 5144 1.68 0.8 13.44 37
I5144 5144 0 1.23684e-05
R5750 5144 5145 1.632 0.8 13.056 37
I5145 5145 0 1.28631e-05
R5751 5145 5146 1.696 0.8 13.568 37
I5146 5146 0 1.24921e-05
R5752 5146 5147 1.68 0.8 13.44 37
I5147 5147 0 1.23684e-05
R5753 5147 5148 1.632 0.8 13.056 37
I5148 5148 0 1.27395e-05
R5754 5148 5149 1.6 0.8 12.8 37
I5149 5149 0 1.29868e-05
R5755 5149 5150 1.664 0.8 13.312 37
I5150 5150 0 1.28631e-05
R5756 5150 5151 1.728 0.8 13.824 37
I5151 5151 0 1.31105e-05
R5757 5151 5152 1.744 0.8 13.952 37
I5152 5152 0 1.29868e-05
R5758 5152 5153 1.664 0.8 13.312 37
I5153 5153 0 1.26158e-05
R5759 5153 5154 1.664 0.8 13.312 37
I5154 5154 0 1.31105e-05
R5760 5154 5155 1.6 0.8 12.8 37
I5155 5155 0 1.32342e-05
R5761 5155 5156 1.648 0.8 13.184 37
I5156 5156 0 1.29868e-05
R5762 5156 5157 1.728 0.8 13.824 37
I5157 5157 0 1.23684e-05
R5763 5157 5158 1.744 0.8 13.952 37
I5158 5158 0 1.29868e-05
R5764 5158 5159 1.648 0.8 13.184 37
I5159 5159 0 1.28631e-05
R5765 5159 5160 1.712 0.8 13.696 37
I5160 5160 0 1.33579e-05
R5766 5160 5161 1.6 0.8 12.8 37
I5161 5161 0 1.27395e-05
R5767 5161 5162 1.744 0.8 13.952 37
I5162 5162 0 1.31105e-05
R5768 5162 5163 1.648 0.8 13.184 37
I5163 5163 0 1.27395e-05
R5769 5163 5164 1.744 0.8 13.952 37
I5164 5164 0 1.29868e-05
R5770 5164 5165 1.6 0.8 12.8 37
I5165 5165 0 1.28631e-05
R5771 5165 5166 1.744 0.8 13.952 37
I5166 5166 0 1.34816e-05
R5772 5166 5167 1.632 0.8 13.056 37
I5167 5167 0 1.33579e-05
R5773 5167 5168 1.696 0.8 13.568 37
I5168 5168 0 1.34816e-05
R5774 5168 5169 1.632 0.8 13.056 37
I5169 5169 0 1.23684e-05
R5775 5169 5170 1.712 0.8 13.696 37
I5170 5170 0 1.29868e-05
R5776 5170 5171 1.744 0.8 13.952 37
I5171 5171 0 1.23684e-05
R5777 5171 5172 1.6 0.8 12.8 37
I5172 5172 0 1.23684e-05
R5778 5172 5173 1.648 0.8 13.184 37
I5173 5173 0 1.34816e-05
R5779 5173 5174 1.712 0.8 13.696 37
I5174 5174 0 1.33579e-05
R5780 5174 5175 1.68 0.8 13.44 37
I5175 5175 0 1.28631e-05
R5781 5175 5176 1.696 0.8 13.568 37
I5176 5176 0 1.31105e-05
R5782 5176 5177 1.744 0.8 13.952 37
I5177 5177 0 1.33579e-05
R5783 5177 5178 1.632 0.8 13.056 37
I5178 5178 0 1.28631e-05
R5784 5178 5179 1.648 0.8 13.184 37
I5179 5179 0 1.24921e-05
R5785 5179 5180 1.744 0.8 13.952 37
I5180 5180 0 1.31105e-05
R5786 5180 5181 1.712 0.8 13.696 37
I5181 5181 0 1.34816e-05
R5787 5181 5182 1.68 0.8 13.44 37
I5182 5182 0 1.26158e-05
R5788 5182 5183 1.744 0.8 13.952 37
I5183 5183 0 1.27395e-05
R5789 5183 5184 1.616 0.8 12.928 37
I5184 5184 0 1.26158e-05
R5790 5184 5185 1.664 0.8 13.312 37
I5185 5185 0 1.33579e-05
R5791 5185 5186 1.712 0.8 13.696 37
I5186 5186 0 1.29868e-05
R5792 5186 5187 1.6 0.8 12.8 37
I5187 5187 0 1.34816e-05
R5793 5187 5188 1.68 0.8 13.44 37
I5188 5188 0 1.29868e-05
R5794 5188 5189 1.6 0.8 12.8 37
I5189 5189 0 1.26158e-05
R5795 5189 5190 1.664 0.8 13.312 37
I5190 5190 0 1.29868e-05
R5796 5190 5191 1.728 0.8 13.824 37
I5191 5191 0 1.26158e-05
R5797 5191 5192 1.616 0.8 12.928 37
I5192 5192 0 1.32342e-05
R5798 5192 5193 1.632 0.8 13.056 37
I5193 5193 0 1.29868e-05
R5799 5193 5194 1.616 0.8 12.928 37
I5194 5194 0 1.31105e-05
R5800 5194 5195 1.744 0.8 13.952 37
I5195 5195 0 1.27395e-05
R5801 5195 5196 1.632 0.8 13.056 37
I5196 5196 0 1.31105e-05
R5802 5196 5197 1.632 0.8 13.056 37
I5197 5197 0 1.34816e-05
R5803 5197 5198 1.728 0.8 13.824 37
I5198 5198 0 1.24921e-05
R5804 5198 5199 1.664 0.8 13.312 37
I5199 5199 0 1.24921e-05
R5805 5199 5200 1.68 0.8 13.44 37
I5200 5200 0 1.23684e-05
R5806 5200 5201 1.744 0.8 13.952 37
I5201 5201 0 1.28631e-05
R5807 5201 5202 1.696 0.8 13.568 37
I5202 5202 0 1.26158e-05
R5808 5202 5203 1.648 0.8 13.184 37
I5203 5203 0 1.27395e-05
R5809 5203 5204 1.712 0.8 13.696 37
I5204 5204 0 1.27395e-05
R5810 5204 5205 1.728 0.8 13.824 37
I5205 5205 0 1.27395e-05
R5811 5205 5206 1.616 0.8 12.928 37
I5206 5206 0 1.31105e-05
R5812 5206 5207 1.696 0.8 13.568 37
I5207 5207 0 1.26158e-05
R5813 5207 5208 1.664 0.8 13.312 37
I5208 5208 0 1.23684e-05
R5814 5208 5209 1.6 0.8 12.8 37
I5209 5209 0 1.32342e-05
R5815 5209 5210 1.696 0.8 13.568 37
I5210 5210 0 1.34816e-05
R5816 5210 5211 1.6 0.8 12.8 37
I5211 5211 0 1.23684e-05
R5817 5211 5212 1.712 0.8 13.696 37
I5212 5212 0 1.28631e-05
R5818 5212 5213 1.616 0.8 12.928 37
I5213 5213 0 1.33579e-05
R5819 5213 5214 1.728 0.8 13.824 37
I5214 5214 0 1.31105e-05
R5820 5214 5215 1.744 0.8 13.952 37
I5215 5215 0 1.27395e-05
R5821 5215 5216 1.696 0.8 13.568 37
I5216 5216 0 1.24921e-05
R5822 5216 5217 1.728 0.8 13.824 37
I5217 5217 0 1.28631e-05
R5823 5217 5218 1.648 0.8 13.184 37
I5218 5218 0 1.27395e-05
R5824 5218 5219 1.728 0.8 13.824 37
I5219 5219 0 1.26158e-05
R5825 5219 5220 1.744 0.8 13.952 37
I5220 5220 0 1.31105e-05
R5826 5220 5221 1.696 0.8 13.568 37
I5221 5221 0 1.23684e-05
R5827 5221 5222 1.632 0.8 13.056 37
I5222 5222 0 1.28631e-05
R5828 5222 5223 1.664 0.8 13.312 37
I5223 5223 0 1.33579e-05
R5829 5223 5224 1.664 0.8 13.312 37
I5224 5224 0 1.28631e-05
R5830 5224 5225 1.728 0.8 13.824 37
I5225 5225 0 1.27395e-05
R5831 5225 5226 1.648 0.8 13.184 37
I5226 5226 0 1.33579e-05
R5832 5226 5227 1.68 0.8 13.44 37
I5227 5227 0 1.27395e-05
R5833 5227 5228 1.648 0.8 13.184 37
I5228 5228 0 1.32342e-05
R5834 5228 5229 1.616 0.8 12.928 37
I5229 5229 0 1.27395e-05
R5835 5229 5230 1.68 0.8 13.44 37
I5230 5230 0 1.23684e-05
R5836 5230 5231 1.696 0.8 13.568 37
I5231 5231 0 1.27395e-05
R5837 5231 5232 1.616 0.8 12.928 37
I5232 5232 0 1.31105e-05
R5838 5232 5233 1.728 0.8 13.824 37
I5233 5233 0 1.31105e-05
R5839 5233 5234 1.632 0.8 13.056 37
I5234 5234 0 1.33579e-05
R5840 5234 5235 1.616 0.8 12.928 37
I5235 5235 0 1.24921e-05
R5841 5235 5236 1.664 0.8 13.312 37
I5236 5236 0 1.32342e-05
R5842 5236 5237 1.616 0.8 12.928 37
I5237 5237 0 1.33579e-05
R5843 5237 5238 1.648 0.8 13.184 37
I5238 5238 0 1.29868e-05
R5844 5238 5239 1.744 0.8 13.952 37
I5239 5239 0 1.32342e-05
R5845 5239 5240 1.6 0.8 12.8 37
I5240 5240 0 1.32342e-05
R5846 5240 5241 1.6 0.8 12.8 37
I5241 5241 0 1.29868e-05
R5847 5241 5242 1.712 0.8 13.696 37
I5242 5242 0 1.33579e-05
R5848 5242 5243 1.728 0.8 13.824 37
I5243 5243 0 1.26158e-05
R5849 5243 5244 1.68 0.8 13.44 37
I5244 5244 0 1.24921e-05
R5850 5244 5245 1.68 0.8 13.44 37
I5245 5245 0 1.26158e-05
R5851 5245 5246 1.632 0.8 13.056 37
I5246 5246 0 1.28631e-05
R5852 5246 5247 1.68 0.8 13.44 37
I5247 5247 0 1.29868e-05
R5853 5247 5248 1.632 0.8 13.056 37
I5248 5248 0 1.29868e-05
R5854 5248 5249 1.664 0.8 13.312 37
I5249 5249 0 1.28631e-05
R5855 5249 5250 1.648 0.8 13.184 37
I5250 5250 0 1.29868e-05
R5856 5250 5251 1.68 0.8 13.44 37
I5251 5251 0 1.34816e-05
R5857 5251 5252 1.664 0.8 13.312 37
I5252 5252 0 1.31105e-05
R5858 5252 5253 1.6 0.8 12.8 37
I5253 5253 0 1.32342e-05
R5859 5253 5254 1.664 0.8 13.312 37
I5254 5254 0 1.34816e-05
R5860 5254 5255 1.664 0.8 13.312 37
I5255 5255 0 1.31105e-05
R5861 5255 5256 1.728 0.8 13.824 37
I5256 5256 0 1.32342e-05
R5862 5256 5257 1.648 0.8 13.184 37
I5257 5257 0 1.29868e-05
R5863 5257 5258 1.68 0.8 13.44 37
I5258 5258 0 1.28631e-05
R5864 5258 5259 1.6 0.8 12.8 37
I5259 5259 0 1.26158e-05
R5865 5259 5260 1.68 0.8 13.44 37
I5260 5260 0 1.29868e-05
R5866 5260 5261 1.696 0.8 13.568 37
I5261 5261 0 1.32342e-05
R5867 5261 5262 1.616 0.8 12.928 37
I5262 5262 0 1.27395e-05
R5868 5262 5263 1.68 0.8 13.44 37
I5263 5263 0 1.28631e-05
R5869 5263 5264 1.744 0.8 13.952 37
I5264 5264 0 1.34816e-05
R5870 5264 5265 1.728 0.8 13.824 37
I5265 5265 0 1.28631e-05
R5871 5265 5266 1.664 0.8 13.312 37
I5266 5266 0 1.31105e-05
R5872 5266 5267 1.696 0.8 13.568 37
I5267 5267 0 1.23684e-05
R5873 5267 5268 1.664 0.8 13.312 37
I5268 5268 0 1.31105e-05
R5874 5268 5269 1.712 0.8 13.696 37
I5269 5269 0 1.33579e-05
R5875 5269 5270 1.68 0.8 13.44 37
I5270 5270 0 1.27395e-05
R5876 5270 5271 1.696 0.8 13.568 37
I5271 5271 0 1.29868e-05
R5877 5271 5272 1.632 0.8 13.056 37
I5272 5272 0 1.23684e-05
R5878 5272 5273 1.6 0.8 12.8 37
I5273 5273 0 1.34816e-05
R5879 5273 5274 1.664 0.8 13.312 37
I5274 5274 0 1.26158e-05
R5880 5274 5275 1.648 0.8 13.184 37
I5275 5275 0 1.34816e-05
R5881 5275 5276 1.728 0.8 13.824 37
I5276 5276 0 1.34816e-05
R5882 5276 5277 1.744 0.8 13.952 37
I5277 5277 0 1.24921e-05
R5883 5277 5278 1.648 0.8 13.184 37
I5278 5278 0 1.31105e-05
R5884 5278 5279 1.68 0.8 13.44 37
I5279 5279 0 1.28631e-05
R5885 5279 5280 1.68 0.8 13.44 37
I5280 5280 0 1.31105e-05
R5886 5280 5281 1.6 0.8 12.8 37
I5281 5281 0 1.24921e-05
R5887 5281 5282 1.632 0.8 13.056 37
I5282 5282 0 1.31105e-05
R5888 5282 5283 1.616 0.8 12.928 37
I5283 5283 0 1.33579e-05
R5889 5283 5284 1.632 0.8 13.056 37
I5284 5284 0 1.23684e-05
R5890 5284 5285 1.744 0.8 13.952 37
I5285 5285 0 1.34816e-05
R5891 5285 5286 1.648 0.8 13.184 37
I5286 5286 0 1.29868e-05
R5892 5286 5287 1.664 0.8 13.312 37
I5287 5287 0 1.31105e-05
R5893 5287 5288 1.712 0.8 13.696 37
I5288 5288 0 1.32342e-05
R5894 5288 5289 1.68 0.8 13.44 37
I5289 5289 0 1.24921e-05
R5895 5289 5290 1.744 0.8 13.952 37
I5290 5290 0 1.34816e-05
R5896 5290 5291 1.648 0.8 13.184 37
I5291 5291 0 1.34816e-05
R5897 5291 5292 1.6 0.8 12.8 37
I5292 5292 0 1.28631e-05
R5898 5292 5293 1.616 0.8 12.928 37
I5293 5293 0 1.29868e-05
R5899 5293 5294 1.632 0.8 13.056 37
I5294 5294 0 1.33579e-05
R5900 5294 5295 1.616 0.8 12.928 37
I5295 5295 0 1.32342e-05
R5901 5295 5296 1.696 0.8 13.568 37
I5296 5296 0 1.26158e-05
R5902 5296 5297 1.6 0.8 12.8 37
I5297 5297 0 1.23684e-05
R5903 5297 5298 1.728 0.8 13.824 37
I5298 5298 0 1.27395e-05
R5904 5298 5299 1.744 0.8 13.952 37
I5299 5299 0 1.27395e-05
R5905 5299 5300 1.648 0.8 13.184 37
I5300 5300 0 1.33579e-05
R5906 5300 5301 1.664 0.8 13.312 37
I5301 5301 0 1.31105e-05
R5907 5301 5302 1.648 0.8 13.184 37
I5302 5302 0 1.34816e-05
R5908 5302 5303 1.664 0.8 13.312 37
I5303 5303 0 1.27395e-05
R5909 5303 5304 1.728 0.8 13.824 37
I5304 5304 0 1.26158e-05
R5910 5304 5305 1.696 0.8 13.568 37
I5305 5305 0 1.34816e-05
R5911 5305 5306 1.648 0.8 13.184 37
I5306 5306 0 1.34816e-05
R5912 5306 5307 1.616 0.8 12.928 37
I5307 5307 0 1.27395e-05
R5913 5307 5308 1.68 0.8 13.44 37
I5308 5308 0 1.28631e-05
R5914 5308 5309 1.616 0.8 12.928 37
I5309 5309 0 1.32342e-05
R5915 5309 5310 1.632 0.8 13.056 37
I5310 5310 0 1.26158e-05
R5916 5310 5311 1.696 0.8 13.568 37
I5311 5311 0 1.24921e-05
R5917 5311 5312 1.664 0.8 13.312 37
I5312 5312 0 1.33579e-05
R5918 5312 5313 1.616 0.8 12.928 37
I5313 5313 0 1.29868e-05
R5919 5313 5314 1.616 0.8 12.928 37
I5314 5314 0 1.23684e-05
R5920 5314 5315 1.6 0.8 12.8 37
I5315 5315 0 1.28631e-05
R5921 5315 5316 1.728 0.8 13.824 37
I5316 5316 0 1.28631e-05
R5922 5316 5317 1.648 0.8 13.184 37
I5317 5317 0 1.28631e-05
R5923 5317 5318 1.68 0.8 13.44 37
I5318 5318 0 1.34816e-05
R5924 5318 5319 1.712 0.8 13.696 37
I5319 5319 0 1.27395e-05
R5925 5319 5320 1.616 0.8 12.928 37
I5320 5320 0 1.27395e-05
R5926 5320 5321 1.68 0.8 13.44 37
I5321 5321 0 1.31105e-05
R5927 5321 5322 1.68 0.8 13.44 37
I5322 5322 0 1.31105e-05
R5928 5322 5323 1.632 0.8 13.056 37
I5323 5323 0 1.26158e-05
R5929 5323 5324 1.632 0.8 13.056 37
I5324 5324 0 1.27395e-05
R5930 5324 5325 1.632 0.8 13.056 37
I5325 5325 0 1.31105e-05
R5931 5325 5326 1.68 0.8 13.44 37
I5326 5326 0 1.23684e-05
R5932 5326 5327 1.712 0.8 13.696 37
I5327 5327 0 1.26158e-05
R5933 5327 5328 1.744 0.8 13.952 37
I5328 5328 0 1.34816e-05
R5934 5328 5329 1.744 0.8 13.952 37
I5329 5329 0 1.26158e-05
R5935 5329 5330 1.744 0.8 13.952 37
I5330 5330 0 1.34816e-05
R5936 5330 5331 1.744 0.8 13.952 37
I5331 5331 0 1.23684e-05
R5937 5331 5332 1.648 0.8 13.184 37
I5332 5332 0 1.28631e-05
R5938 5332 5333 1.664 0.8 13.312 37
I5333 5333 0 1.34816e-05
R5939 5333 5334 1.648 0.8 13.184 37
I5334 5334 0 1.27395e-05
R5940 5334 5335 1.664 0.8 13.312 37
I5335 5335 0 1.32342e-05
R5941 5335 5336 1.728 0.8 13.824 37
I5336 5336 0 1.24921e-05
R5942 5336 5337 1.648 0.8 13.184 37
I5337 5337 0 1.29868e-05
R5943 5337 5338 1.744 0.8 13.952 37
I5338 5338 0 1.29868e-05
R5944 5338 5339 1.728 0.8 13.824 37
I5339 5339 0 1.24921e-05
R5945 5339 5340 1.728 0.8 13.824 37
I5340 5340 0 1.26158e-05
R5946 5340 5341 1.728 0.8 13.824 37
I5341 5341 0 1.31105e-05
R5947 5341 5342 1.632 0.8 13.056 37
I5342 5342 0 1.29868e-05
R5948 5342 5343 1.728 0.8 13.824 37
I5343 5343 0 1.27395e-05
R5949 5343 5344 1.664 0.8 13.312 37
I5344 5344 0 1.32342e-05
R5950 5344 5345 1.696 0.8 13.568 37
I5345 5345 0 1.31105e-05
R5951 5345 5346 1.728 0.8 13.824 37
I5346 5346 0 1.29868e-05
R5952 5346 5347 1.696 0.8 13.568 37
I5347 5347 0 1.24921e-05
R5953 5347 5348 1.616 0.8 12.928 37
I5348 5348 0 1.26158e-05
R5954 5348 5349 1.632 0.8 13.056 37
I5349 5349 0 1.28631e-05
R5955 5349 5350 1.68 0.8 13.44 37
I5350 5350 0 1.34816e-05
R5956 5350 5351 1.616 0.8 12.928 37
I5351 5351 0 1.29868e-05
R5957 5351 5352 1.6 0.8 12.8 37
I5352 5352 0 1.32342e-05
R5958 5352 5353 1.616 0.8 12.928 37
I5353 5353 0 1.26158e-05
R5959 5353 5354 1.632 0.8 13.056 37
I5354 5354 0 1.24921e-05
R5960 5354 5355 1.648 0.8 13.184 37
I5355 5355 0 1.27395e-05
R5961 5355 5356 1.648 0.8 13.184 37
I5356 5356 0 1.24921e-05
R5962 5356 5357 1.744 0.8 13.952 37
I5357 5357 0 1.32342e-05
R5963 5357 5358 1.744 0.8 13.952 37
I5358 5358 0 1.34816e-05
R5964 5358 5359 1.616 0.8 12.928 37
I5359 5359 0 1.27395e-05
R5965 5359 5360 1.728 0.8 13.824 37
I5360 5360 0 1.34816e-05
R5966 5360 5361 1.744 0.8 13.952 37
I5361 5361 0 1.31105e-05
R5967 5361 5362 1.696 0.8 13.568 37
I5362 5362 0 1.32342e-05
R5968 5362 5363 1.744 0.8 13.952 37
I5363 5363 0 1.32342e-05
R5969 5363 5364 1.744 0.8 13.952 37
I5364 5364 0 1.26158e-05
R5970 5364 5365 1.648 0.8 13.184 37
I5365 5365 0 1.31105e-05
R5971 5365 5366 1.648 0.8 13.184 37
I5366 5366 0 1.32342e-05
R5972 5366 5367 1.632 0.8 13.056 37
I5367 5367 0 1.29868e-05
R5973 5367 5368 1.664 0.8 13.312 37
I5368 5368 0 1.29868e-05
R5974 5368 5369 1.712 0.8 13.696 37
I5369 5369 0 1.33579e-05
R5975 5369 5370 1.728 0.8 13.824 37
I5370 5370 0 1.24921e-05
R5976 5370 5371 1.616 0.8 12.928 37
I5371 5371 0 1.24921e-05
R5977 5371 5372 1.664 0.8 13.312 37
I5372 5372 0 1.26158e-05
R5978 5372 5373 1.6 0.8 12.8 37
I5373 5373 0 1.27395e-05
R5979 5373 5374 1.648 0.8 13.184 37
I5374 5374 0 1.27395e-05
R5980 5374 5375 1.744 0.8 13.952 37
I5375 5375 0 1.24921e-05
R5981 5375 5376 1.632 0.8 13.056 37
I5376 5376 0 1.23684e-05
R5982 5376 5377 1.712 0.8 13.696 37
I5377 5377 0 1.23684e-05
R5983 5377 5378 1.728 0.8 13.824 37
I5378 5378 0 1.32342e-05
R5984 5378 5379 1.712 0.8 13.696 37
I5379 5379 0 1.34816e-05
R5985 5379 5380 1.616 0.8 12.928 37
I5380 5380 0 1.27395e-05
R5986 5380 5381 1.696 0.8 13.568 37
I5381 5381 0 1.28631e-05
R5987 5381 5382 1.6 0.8 12.8 37
I5382 5382 0 1.23684e-05
R5988 5382 5383 1.616 0.8 12.928 37
I5383 5383 0 1.28631e-05
R5989 5383 5384 1.712 0.8 13.696 37
I5384 5384 0 1.34816e-05
R5990 5384 5385 1.632 0.8 13.056 37
I5385 5385 0 1.29868e-05
R5991 5385 5386 1.632 0.8 13.056 37
I5386 5386 0 1.31105e-05
R5992 5386 5387 1.728 0.8 13.824 37
I5387 5387 0 1.31105e-05
R5993 5387 5388 1.6 0.8 12.8 37
I5388 5388 0 1.23684e-05
R5994 5388 5389 1.6 0.8 12.8 37
I5389 5389 0 1.28631e-05
R5995 5389 5390 1.664 0.8 13.312 37
I5390 5390 0 1.24921e-05
R5996 5390 5391 1.712 0.8 13.696 37
I5391 5391 0 1.33579e-05
R5997 5391 5392 1.616 0.8 12.928 37
I5392 5392 0 1.29868e-05
R5998 5392 5393 1.744 0.8 13.952 37
I5393 5393 0 1.24921e-05
R5999 5393 5394 1.664 0.8 13.312 37
I5394 5394 0 1.33579e-05
R6000 5394 5395 1.616 0.8 12.928 37
I5395 5395 0 1.32342e-05
R6001 5395 5396 1.616 0.8 12.928 37
I5396 5396 0 1.34816e-05
R6002 5396 5397 1.616 0.8 12.928 37
I5397 5397 0 1.27395e-05
R6003 5397 5398 1.616 0.8 12.928 37
I5398 5398 0 1.26158e-05
R6004 5398 5399 1.712 0.8 13.696 37
I5399 5399 0 1.33579e-05
R6005 5399 5400 1.648 0.8 13.184 37
I5400 5400 0 1.26158e-05
R6006 5400 5401 1.68 0.8 13.44 37
I5401 5401 0 1.29868e-05
R6007 5401 5402 1.728 0.8 13.824 37
I5402 5402 0 1.27395e-05
R6008 5402 5403 1.632 0.8 13.056 37
I5403 5403 0 1.23684e-05
R6009 5403 5404 1.68 0.8 13.44 37
I5404 5404 0 1.28631e-05
R6010 5404 5405 1.664 0.8 13.312 37
I5405 5405 0 1.34816e-05
R6011 5405 5406 1.712 0.8 13.696 37
I5406 5406 0 1.26158e-05
R6012 5406 5407 1.6 0.8 12.8 37
I5407 5407 0 1.33579e-05
R6013 5407 5408 1.744 0.8 13.952 37
I5408 5408 0 1.34816e-05
R6014 5408 5409 1.6 0.8 12.8 37
I5409 5409 0 1.29868e-05
R6015 5409 5410 1.744 0.8 13.952 37
I5410 5410 0 1.24921e-05
R6016 5410 5411 1.632 0.8 13.056 37
I5411 5411 0 1.27395e-05
R6017 5411 5412 1.632 0.8 13.056 37
I5412 5412 0 1.29868e-05
R6018 5412 5413 1.696 0.8 13.568 37
I5413 5413 0 1.27395e-05
R6019 5413 5414 1.744 0.8 13.952 37
I5414 5414 0 1.31105e-05
R6020 5414 5415 1.616 0.8 12.928 37
I5415 5415 0 1.27395e-05
R6021 5415 5416 1.728 0.8 13.824 37
I5416 5416 0 1.31105e-05
R6022 5416 5417 1.6 0.8 12.8 37
I5417 5417 0 1.33579e-05
R6023 5417 5418 1.616 0.8 12.928 37
I5418 5418 0 1.28631e-05
R6024 5418 5419 1.6 0.8 12.8 37
I5419 5419 0 1.31105e-05
R6025 5419 5420 1.6 0.8 12.8 37
I5420 5420 0 1.32342e-05
R6026 5420 5421 1.728 0.8 13.824 37
I5421 5421 0 1.32342e-05
R6027 5421 5422 1.616 0.8 12.928 37
I5422 5422 0 1.33579e-05
R6028 5422 5423 1.696 0.8 13.568 37
I5423 5423 0 1.23684e-05
R6029 5423 5424 1.744 0.8 13.952 37
I5424 5424 0 1.33579e-05
R6030 5424 5425 1.712 0.8 13.696 37
I5425 5425 0 1.23684e-05
R6031 5425 5426 1.616 0.8 12.928 37
I5426 5426 0 1.34816e-05
R6032 5426 5427 1.648 0.8 13.184 37
I5427 5427 0 1.27395e-05
R6033 5427 5428 1.696 0.8 13.568 37
I5428 5428 0 1.26158e-05
R6034 5428 5429 1.696 0.8 13.568 37
I5429 5429 0 1.29868e-05
R6035 5429 5430 1.6 0.8 12.8 37
I5430 5430 0 1.32342e-05
R6036 5430 5431 1.6 0.8 12.8 37
I5431 5431 0 1.33579e-05
R6037 5431 5432 1.68 0.8 13.44 37
I5432 5432 0 1.24921e-05
R6038 5432 5433 1.728 0.8 13.824 37
I5433 5433 0 1.33579e-05
R6039 5433 5434 1.712 0.8 13.696 37
I5434 5434 0 1.33579e-05
R6040 5434 5435 1.696 0.8 13.568 37
I5435 5435 0 1.33579e-05
R6041 5435 5436 1.68 0.8 13.44 37
I5436 5436 0 1.31105e-05
R6042 5436 5437 1.68 0.8 13.44 37
I5437 5437 0 1.33579e-05
R6043 5437 5438 1.664 0.8 13.312 37
I5438 5438 0 1.27395e-05
R6044 5438 5439 1.728 0.8 13.824 37
I5439 5439 0 1.29868e-05
R6045 5439 5440 1.616 0.8 12.928 37
I5440 5440 0 1.32342e-05
R6046 5440 5441 1.696 0.8 13.568 37
I5441 5441 0 1.26158e-05
R6047 5441 5442 1.728 0.8 13.824 37
I5442 5442 0 1.24921e-05
R6048 5442 5443 1.68 0.8 13.44 37
I5443 5443 0 1.28631e-05
R6049 5443 5444 1.648 0.8 13.184 37
I5444 5444 0 1.24921e-05
R6050 5444 5445 1.632 0.8 13.056 37
I5445 5445 0 1.27395e-05
R6051 5445 5446 1.6 0.8 12.8 37
I5446 5446 0 1.28631e-05
R6052 5446 5447 1.648 0.8 13.184 37
I5447 5447 0 1.32342e-05
R6053 5447 5448 1.712 0.8 13.696 37
I5448 5448 0 1.27395e-05
R6054 5448 5449 1.712 0.8 13.696 37
I5449 5449 0 1.29868e-05
R6055 5449 5450 1.664 0.8 13.312 37
I5450 5450 0 1.31105e-05
R6056 5450 5451 1.648 0.8 13.184 37
I5451 5451 0 1.24921e-05
R6057 5451 5452 1.632 0.8 13.056 37
I5452 5452 0 1.23684e-05
R6058 5452 5453 1.6 0.8 12.8 37
I5453 5453 0 1.34816e-05
R6059 5453 5454 1.664 0.8 13.312 37
I5454 5454 0 1.23684e-05
R6060 5454 5455 1.664 0.8 13.312 37
I5455 5455 0 1.29868e-05
R6061 5455 5456 1.728 0.8 13.824 37
I5456 5456 0 1.23684e-05
R6062 5456 5457 1.728 0.8 13.824 37
I5457 5457 0 1.31105e-05
R6063 5457 5458 1.632 0.8 13.056 37
I5458 5458 0 1.29868e-05
R6064 5458 5459 1.648 0.8 13.184 37
I5459 5459 0 1.32342e-05
R6065 5459 5460 1.712 0.8 13.696 37
I5460 5460 0 1.29868e-05
R6066 5460 5461 1.648 0.8 13.184 37
I5461 5461 0 1.34816e-05
R6067 5461 5462 1.744 0.8 13.952 37
I5462 5462 0 1.33579e-05
R6068 5462 5463 1.744 0.8 13.952 37
I5463 5463 0 1.32342e-05
R6069 5463 5464 1.632 0.8 13.056 37
I5464 5464 0 1.31105e-05
R6070 5464 5465 1.632 0.8 13.056 37
I5465 5465 0 1.31105e-05
R6071 5465 5466 1.632 0.8 13.056 37
I5466 5466 0 1.32342e-05
R6072 5466 5467 1.744 0.8 13.952 37
I5467 5467 0 1.29868e-05
R6073 5467 5468 1.712 0.8 13.696 37
I5468 5468 0 1.34816e-05
R6074 5468 5469 1.664 0.8 13.312 37
I5469 5469 0 1.24921e-05
R6075 5469 5470 1.6 0.8 12.8 37
I5470 5470 0 1.23684e-05
R6076 5470 5471 1.744 0.8 13.952 37
I5471 5471 0 1.33579e-05
R6077 5471 5472 1.616 0.8 12.928 37
I5472 5472 0 1.32342e-05
R6078 5472 5473 1.696 0.8 13.568 37
I5473 5473 0 1.29868e-05
R6079 5473 5474 1.664 0.8 13.312 37
I5474 5474 0 1.34816e-05
R6080 5474 5475 1.632 0.8 13.056 37
I5475 5475 0 1.27395e-05
R6081 5475 5476 1.664 0.8 13.312 37
I5476 5476 0 1.32342e-05
R6082 5476 5477 1.648 0.8 13.184 37
I5477 5477 0 1.31105e-05
R6083 5477 5478 1.696 0.8 13.568 37
I5478 5478 0 1.26158e-05
R6084 5478 5479 1.648 0.8 13.184 37
I5479 5479 0 1.33579e-05
R6085 5479 5480 1.6 0.8 12.8 37
I5480 5480 0 1.32342e-05
R6086 5480 5481 1.696 0.8 13.568 37
I5481 5481 0 1.27395e-05
R6087 5481 5482 1.664 0.8 13.312 37
I5482 5482 0 1.29868e-05
R6088 5482 5483 1.6 0.8 12.8 37
I5483 5483 0 1.24921e-05
R6089 5483 5484 1.712 0.8 13.696 37
I5484 5484 0 1.31105e-05
R6090 5484 5485 1.68 0.8 13.44 37
I5485 5485 0 1.32342e-05
R6091 5485 5486 1.696 0.8 13.568 37
I5486 5486 0 1.28631e-05
R6092 5486 5487 1.712 0.8 13.696 37
I5487 5487 0 1.34816e-05
R6093 5487 5488 1.648 0.8 13.184 37
I5488 5488 0 1.29868e-05
R6094 5488 5489 1.664 0.8 13.312 37
I5489 5489 0 1.32342e-05
R6095 5489 5490 1.712 0.8 13.696 37
I5490 5490 0 1.34816e-05
R6096 5490 5491 1.616 0.8 12.928 37
I5491 5491 0 1.24921e-05
R6097 5491 5492 1.696 0.8 13.568 37
I5492 5492 0 1.31105e-05
R6098 5492 5493 1.744 0.8 13.952 37
I5493 5493 0 1.28631e-05
R6099 5493 5494 1.728 0.8 13.824 37
I5494 5494 0 1.28631e-05
R6100 5494 5495 1.664 0.8 13.312 37
I5495 5495 0 1.33579e-05
R6101 5495 5496 1.616 0.8 12.928 37
I5496 5496 0 1.26158e-05
R6102 5496 5497 1.648 0.8 13.184 37
I5497 5497 0 1.32342e-05
R6103 5497 5498 1.6 0.8 12.8 37
I5498 5498 0 1.27395e-05
R6104 5498 5499 1.744 0.8 13.952 37
I5499 5499 0 1.32342e-05
R6105 5499 5500 1.616 0.8 12.928 37
I5500 5500 0 1.31105e-05
R6106 5500 5501 1.696 0.8 13.568 37
I5501 5501 0 1.33579e-05
R6107 5501 5502 1.6 0.8 12.8 37
I5502 5502 0 1.29868e-05
R6108 5502 5503 1.744 0.8 13.952 37
I5503 5503 0 1.29868e-05
R6109 5503 5504 1.6 0.8 12.8 37
I5504 5504 0 1.28631e-05
R6110 5504 5505 1.632 0.8 13.056 37
I5505 5505 0 1.32342e-05
R6111 5505 5506 1.68 0.8 13.44 37
I5506 5506 0 1.29868e-05
R6112 5506 5507 1.616 0.8 12.928 37
I5507 5507 0 1.27395e-05
R6113 5507 5508 1.616 0.8 12.928 37
I5508 5508 0 1.26158e-05
R6114 5508 5509 1.6 0.8 12.8 37
I5509 5509 0 1.24921e-05
R6115 5509 5510 1.712 0.8 13.696 37
I5510 5510 0 1.28631e-05
R6116 5510 5511 1.632 0.8 13.056 37
I5511 5511 0 1.33579e-05
R6117 5511 5512 1.712 0.8 13.696 37
I5512 5512 0 1.29868e-05
R6118 5512 5513 1.696 0.8 13.568 37
I5513 5513 0 1.32342e-05
R6119 5513 5514 1.616 0.8 12.928 37
I5514 5514 0 1.32342e-05
R6120 5514 5515 1.664 0.8 13.312 37
I5515 5515 0 1.28631e-05
R6121 5515 5516 1.68 0.8 13.44 37
I5516 5516 0 1.26158e-05
R6122 5516 5517 1.664 0.8 13.312 37
I5517 5517 0 1.32342e-05
R6123 5517 5518 1.712 0.8 13.696 37
I5518 5518 0 1.28631e-05
R6124 5518 5519 1.632 0.8 13.056 37
I5519 5519 0 1.34816e-05
R6125 5519 5520 1.6 0.8 12.8 37
I5520 5520 0 1.31105e-05
R6126 5520 5521 1.744 0.8 13.952 37
I5521 5521 0 1.29868e-05
R6127 5521 5522 1.632 0.8 13.056 37
I5522 5522 0 1.23684e-05
R6128 5522 5523 1.6 0.8 12.8 37
I5523 5523 0 1.29868e-05
R6129 5523 5524 1.632 0.8 13.056 37
I5524 5524 0 1.23684e-05
R6130 5524 5525 1.744 0.8 13.952 37
I5525 5525 0 1.24921e-05
R6131 5525 5526 1.68 0.8 13.44 37
I5526 5526 0 1.24921e-05
R6132 5526 5527 1.6 0.8 12.8 37
I5527 5527 0 1.28631e-05
R6133 5527 5528 1.728 0.8 13.824 37
I5528 5528 0 1.33579e-05
R6134 5528 5529 1.648 0.8 13.184 37
I5529 5529 0 1.34816e-05
R6135 5529 5530 1.68 0.8 13.44 37
I5530 5530 0 1.34816e-05
R6136 5530 5531 1.696 0.8 13.568 37
I5531 5531 0 1.26158e-05
R6137 5531 5532 1.616 0.8 12.928 37
I5532 5532 0 1.23684e-05
R6138 5532 5533 1.744 0.8 13.952 37
I5533 5533 0 1.33579e-05
R6139 5533 5534 1.664 0.8 13.312 37
I5534 5534 0 1.24921e-05
R6140 5534 5535 1.744 0.8 13.952 37
I5535 5535 0 1.28631e-05
R6141 5535 5536 1.744 0.8 13.952 37
I5536 5536 0 1.33579e-05
R6142 5536 5537 1.616 0.8 12.928 37
I5537 5537 0 1.24921e-05
R6143 5537 5538 1.6 0.8 12.8 37
I5538 5538 0 1.28631e-05
R6144 5538 5539 1.744 0.8 13.952 37
I5539 5539 0 1.27395e-05
R6145 5539 5540 1.664 0.8 13.312 37
I5540 5540 0 1.33579e-05
R6146 5540 5541 1.664 0.8 13.312 37
I5541 5541 0 1.24921e-05
R6147 5541 5542 1.616 0.8 12.928 37
I5542 5542 0 1.31105e-05
R6148 5542 5543 1.712 0.8 13.696 37
I5543 5543 0 1.34816e-05
R6149 5543 5544 1.664 0.8 13.312 37
I5544 5544 0 1.23684e-05
R6150 5544 5545 1.616 0.8 12.928 37
I5545 5545 0 1.24921e-05
R6151 5545 5546 1.744 0.8 13.952 37
I5546 5546 0 1.32342e-05
R6152 5546 5547 1.648 0.8 13.184 37
I5547 5547 0 1.23684e-05
R6153 5547 5548 1.712 0.8 13.696 37
I5548 5548 0 1.28631e-05
R6154 5548 5549 1.6 0.8 12.8 37
I5549 5549 0 1.26158e-05
R6155 5549 5550 1.68 0.8 13.44 37
I5550 5550 0 1.23684e-05
R6156 5550 5551 1.728 0.8 13.824 37
I5551 5551 0 1.29868e-05
R6157 5551 5552 1.6 0.8 12.8 37
I5552 5552 0 1.26158e-05
R6158 5552 5553 1.728 0.8 13.824 37
I5553 5553 0 1.24921e-05
R6159 5553 5554 1.696 0.8 13.568 37
I5554 5554 0 1.34816e-05
R6160 5554 5555 1.696 0.8 13.568 37
I5555 5555 0 1.26158e-05
R6161 5555 5556 1.744 0.8 13.952 37
I5556 5556 0 1.26158e-05
R6162 5556 5557 1.696 0.8 13.568 37
I5557 5557 0 1.23684e-05
R6163 5557 5558 1.744 0.8 13.952 37
I5558 5558 0 1.27395e-05
R6164 5558 5559 1.6 0.8 12.8 37
I5559 5559 0 1.29868e-05
R6165 5559 5560 1.664 0.8 13.312 37
I5560 5560 0 1.27395e-05
R6166 5560 5561 1.744 0.8 13.952 37
I5561 5561 0 1.27395e-05
R6167 5561 5562 1.6 0.8 12.8 37
I5562 5562 0 1.28631e-05
R6168 5562 5563 1.696 0.8 13.568 37
I5563 5563 0 1.32342e-05
R6169 5563 5564 1.744 0.8 13.952 37
I5564 5564 0 1.33579e-05
R6170 5564 5565 1.616 0.8 12.928 37
I5565 5565 0 1.31105e-05
R6171 5565 5566 1.728 0.8 13.824 37
I5566 5566 0 1.26158e-05
R6172 5566 5567 1.648 0.8 13.184 37
I5567 5567 0 1.24921e-05
R6173 5567 5568 1.664 0.8 13.312 37
I5568 5568 0 1.28631e-05
R6174 5568 5569 1.632 0.8 13.056 37
I5569 5569 0 1.26158e-05
R6175 5569 5570 1.648 0.8 13.184 37
I5570 5570 0 1.33579e-05
R6176 5570 5571 1.664 0.8 13.312 37
I5571 5571 0 1.29868e-05
R6177 5571 5572 1.6 0.8 12.8 37
I5572 5572 0 1.23684e-05
R6178 5572 5573 1.68 0.8 13.44 37
I5573 5573 0 1.24921e-05
R6179 5573 5574 1.696 0.8 13.568 37
I5574 5574 0 1.32342e-05
R6180 5574 5575 1.712 0.8 13.696 37
I5575 5575 0 1.23684e-05
R6181 5575 5576 1.6 0.8 12.8 37
I5576 5576 0 1.33579e-05
R6182 5576 5577 1.68 0.8 13.44 37
I5577 5577 0 1.26158e-05
R6183 5577 5578 1.632 0.8 13.056 37
I5578 5578 0 1.27395e-05
R6184 5578 5579 1.632 0.8 13.056 37
I5579 5579 0 1.27395e-05
R6185 5579 5580 1.632 0.8 13.056 37
I5580 5580 0 1.27395e-05
R6186 5580 5581 1.6 0.8 12.8 37
I5581 5581 0 1.26158e-05
R6187 5581 5582 1.712 0.8 13.696 37
I5582 5582 0 1.29868e-05
R6188 5582 5583 1.648 0.8 13.184 37
I5583 5583 0 1.27395e-05
R6189 5583 5584 1.744 0.8 13.952 37
I5584 5584 0 1.32342e-05
R6190 5584 5585 1.68 0.8 13.44 37
I5585 5585 0 1.29868e-05
R6191 5585 5586 1.68 0.8 13.44 37
I5586 5586 0 1.26158e-05
R6192 5586 5587 1.6 0.8 12.8 37
I5587 5587 0 1.31105e-05
R6193 5587 5588 1.664 0.8 13.312 37
I5588 5588 0 1.32342e-05
R6194 5588 5589 1.744 0.8 13.952 37
I5589 5589 0 1.23684e-05
R6195 5589 5590 1.712 0.8 13.696 37
I5590 5590 0 1.31105e-05
R6196 5590 5591 1.632 0.8 13.056 37
I5591 5591 0 1.32342e-05
R6197 5591 5592 1.696 0.8 13.568 37
I5592 5592 0 1.23684e-05
R6198 5592 5593 1.6 0.8 12.8 37
I5593 5593 0 1.34816e-05
R6199 5593 5594 1.648 0.8 13.184 37
I5594 5594 0 1.26158e-05
R6200 5594 5595 1.664 0.8 13.312 37
I5595 5595 0 1.32342e-05
R6201 5595 5596 1.712 0.8 13.696 37
I5596 5596 0 1.28631e-05
R6202 5596 5597 1.632 0.8 13.056 37
I5597 5597 0 1.32342e-05
R6203 5597 5598 1.632 0.8 13.056 37
I5598 5598 0 1.32342e-05
R6204 5598 5599 1.6 0.8 12.8 37
I5599 5599 0 1.24921e-05
R6205 5599 5600 1.68 0.8 13.44 37
I5600 5600 0 1.33579e-05
R6206 5600 5601 1.728 0.8 13.824 37
I5601 5601 0 1.23684e-05
R6207 5601 5602 1.632 0.8 13.056 37
I5602 5602 0 1.23684e-05
R6208 5602 5603 1.728 0.8 13.824 37
I5603 5603 0 1.31105e-05
R6209 5603 5604 1.728 0.8 13.824 37
I5604 5604 0 1.33579e-05
R6210 5604 5605 1.712 0.8 13.696 37
I5605 5605 0 1.29868e-05
R6211 5605 5606 1.696 0.8 13.568 37
I5606 5606 0 1.24921e-05
R6212 5606 5607 1.664 0.8 13.312 37
I5607 5607 0 1.27395e-05
R6213 5607 5608 1.616 0.8 12.928 37
I5608 5608 0 1.31105e-05
R6214 5608 5609 1.664 0.8 13.312 37
I5609 5609 0 1.32342e-05
R6215 5609 5610 1.6 0.8 12.8 37
I5610 5610 0 1.33579e-05
R6216 5610 5611 1.696 0.8 13.568 37
I5611 5611 0 1.23684e-05
R6217 5611 5612 1.68 0.8 13.44 37
I5612 5612 0 1.33579e-05
R6218 5612 5613 1.712 0.8 13.696 37
I5613 5613 0 1.32342e-05
R6219 5613 5614 1.696 0.8 13.568 37
I5614 5614 0 1.34816e-05
R6220 5614 5615 1.6 0.8 12.8 37
I5615 5615 0 1.24921e-05
R6221 5615 5616 1.744 0.8 13.952 37
I5616 5616 0 1.34816e-05
R6222 5616 5617 1.648 0.8 13.184 37
I5617 5617 0 1.24921e-05
R6223 5617 5618 1.744 0.8 13.952 37
I5618 5618 0 1.26158e-05
R6224 5618 5619 1.728 0.8 13.824 37
I5619 5619 0 1.34816e-05
R6225 5619 5620 1.6 0.8 12.8 37
I5620 5620 0 1.32342e-05
R6226 5620 5621 1.696 0.8 13.568 37
I5621 5621 0 1.33579e-05
R6227 5621 5622 1.728 0.8 13.824 37
I5622 5622 0 1.27395e-05
R6228 5622 5623 1.616 0.8 12.928 37
I5623 5623 0 1.26158e-05
R6229 5623 5624 1.744 0.8 13.952 37
I5624 5624 0 1.32342e-05
R6230 5624 5625 1.744 0.8 13.952 37
I5625 5625 0 1.23684e-05
R6231 5625 5626 1.696 0.8 13.568 37
I5626 5626 0 1.29868e-05
R6232 5626 5627 1.632 0.8 13.056 37
I5627 5627 0 1.24921e-05
R6233 5627 5628 1.696 0.8 13.568 37
I5628 5628 0 1.24921e-05
R6234 5628 5629 1.728 0.8 13.824 37
I5629 5629 0 1.26158e-05
R6235 5629 5630 1.6 0.8 12.8 37
I5630 5630 0 1.33579e-05
R6236 5630 5631 1.68 0.8 13.44 37
I5631 5631 0 1.26158e-05
R6237 5631 5632 1.744 0.8 13.952 37
I5632 5632 0 1.33579e-05
R6238 5632 5633 1.648 0.8 13.184 37
I5633 5633 0 1.24921e-05
R6239 5633 5634 1.6 0.8 12.8 37
I5634 5634 0 1.27395e-05
R6240 5634 5635 1.6 0.8 12.8 37
I5635 5635 0 1.26158e-05
R6241 5635 5636 1.6 0.8 12.8 37
I5636 5636 0 1.32342e-05
R6242 5636 5637 1.648 0.8 13.184 37
I5637 5637 0 1.24921e-05
R6243 5637 5638 1.6 0.8 12.8 37
I5638 5638 0 1.31105e-05
R6244 5638 5639 1.648 0.8 13.184 37
I5639 5639 0 1.24921e-05
R6245 5639 5640 1.664 0.8 13.312 37
I5640 5640 0 1.28631e-05
R6246 5640 5641 1.648 0.8 13.184 37
I5641 5641 0 1.23684e-05
R6247 5641 5642 1.616 0.8 12.928 37
I5642 5642 0 1.29868e-05
R6248 5642 5643 1.648 0.8 13.184 37
I5643 5643 0 1.32342e-05
R6249 5643 5644 1.696 0.8 13.568 37
I5644 5644 0 1.27395e-05
R6250 5644 5645 1.616 0.8 12.928 37
I5645 5645 0 1.34816e-05
R6251 5645 5646 1.648 0.8 13.184 37
I5646 5646 0 1.33579e-05
R6252 5646 5647 1.616 0.8 12.928 37
I5647 5647 0 1.27395e-05
R6253 5647 5648 1.712 0.8 13.696 37
I5648 5648 0 1.28631e-05
R6254 5648 5649 1.664 0.8 13.312 37
I5649 5649 0 1.34816e-05
R6255 5649 5650 1.728 0.8 13.824 37
I5650 5650 0 1.31105e-05
R6256 5650 5651 1.664 0.8 13.312 37
I5651 5651 0 1.23684e-05
R6257 5651 5652 1.68 0.8 13.44 37
I5652 5652 0 1.32342e-05
R6258 5652 5653 1.616 0.8 12.928 37
I5653 5653 0 1.32342e-05
R6259 5653 5654 1.648 0.8 13.184 37
I5654 5654 0 1.31105e-05
R6260 5654 5655 1.744 0.8 13.952 37
I5655 5655 0 1.32342e-05
R6261 5655 5656 1.632 0.8 13.056 37
I5656 5656 0 1.26158e-05
R6262 5656 5657 1.744 0.8 13.952 37
I5657 5657 0 1.31105e-05
R6263 5657 5658 1.6 0.8 12.8 37
I5658 5658 0 1.28631e-05
R6264 5658 5659 1.68 0.8 13.44 37
I5659 5659 0 1.31105e-05
R6265 5659 5660 1.744 0.8 13.952 37
I5660 5660 0 1.32342e-05
R6266 5660 5661 1.712 0.8 13.696 37
I5661 5661 0 1.27395e-05
R6267 5661 5662 1.712 0.8 13.696 37
I5662 5662 0 1.33579e-05
R6268 5662 5663 1.728 0.8 13.824 37
I5663 5663 0 1.28631e-05
R6269 5663 5664 1.68 0.8 13.44 37
I5664 5664 0 1.28631e-05
R6270 5664 5665 1.664 0.8 13.312 37
I5665 5665 0 1.27395e-05
R6271 5665 5666 1.6 0.8 12.8 37
I5666 5666 0 1.33579e-05
R6272 5666 5667 1.68 0.8 13.44 37
I5667 5667 0 1.31105e-05
R6273 5667 5668 1.712 0.8 13.696 37
I5668 5668 0 1.34816e-05
R6274 5668 5669 1.648 0.8 13.184 37
I5669 5669 0 1.23684e-05
R6275 5669 5670 1.712 0.8 13.696 37
I5670 5670 0 1.28631e-05
R6276 5670 5671 1.6 0.8 12.8 37
I5671 5671 0 1.23684e-05
R6277 5671 5672 1.712 0.8 13.696 37
I5672 5672 0 1.24921e-05
R6278 5672 5673 1.696 0.8 13.568 37
I5673 5673 0 1.34816e-05
R6279 5673 5674 1.696 0.8 13.568 37
I5674 5674 0 1.24921e-05
R6280 5674 5675 1.68 0.8 13.44 37
I5675 5675 0 1.32342e-05
R6281 5675 5676 1.6 0.8 12.8 37
I5676 5676 0 1.27395e-05
R6282 5676 5677 1.6 0.8 12.8 37
I5677 5677 0 1.33579e-05
R6283 5677 5678 1.648 0.8 13.184 37
I5678 5678 0 1.33579e-05
R6284 5678 5679 1.664 0.8 13.312 37
I5679 5679 0 1.33579e-05
R6285 5679 5680 1.664 0.8 13.312 37
I5680 5680 0 1.23684e-05
R6286 5680 5681 1.648 0.8 13.184 37
I5681 5681 0 1.29868e-05
R6287 5681 5682 1.728 0.8 13.824 37
I5682 5682 0 1.34816e-05
R6288 5682 5683 1.648 0.8 13.184 37
I5683 5683 0 1.32342e-05
R6289 5683 5684 1.728 0.8 13.824 37
I5684 5684 0 1.31105e-05
R6290 5684 5685 1.728 0.8 13.824 37
I5685 5685 0 1.32342e-05
R6291 5685 5686 1.648 0.8 13.184 37
I5686 5686 0 1.23684e-05
R6292 5686 5687 1.712 0.8 13.696 37
I5687 5687 0 1.23684e-05
R6293 5687 5688 1.616 0.8 12.928 37
I5688 5688 0 1.29868e-05
R6294 5688 5689 1.616 0.8 12.928 37
I5689 5689 0 1.34816e-05
R6295 5689 5690 1.744 0.8 13.952 37
I5690 5690 0 1.31105e-05
R6296 5690 5691 1.712 0.8 13.696 37
I5691 5691 0 1.34816e-05
R6297 5691 5692 1.616 0.8 12.928 37
I5692 5692 0 1.34816e-05
R6298 5692 5693 1.744 0.8 13.952 37
I5693 5693 0 1.32342e-05
R6299 5693 5694 1.6 0.8 12.8 37
I5694 5694 0 1.28631e-05
R6300 5694 5695 1.68 0.8 13.44 37
I5695 5695 0 1.28631e-05
R6301 5695 5696 1.664 0.8 13.312 37
I5696 5696 0 1.34816e-05
R6302 5696 5697 1.744 0.8 13.952 37
I5697 5697 0 1.29868e-05
R6303 5697 5698 1.6 0.8 12.8 37
I5698 5698 0 1.26158e-05
R6304 5698 5699 1.632 0.8 13.056 37
I5699 5699 0 1.23684e-05
R6305 5699 5700 1.616 0.8 12.928 37
I5700 5700 0 1.26158e-05
R6306 5700 5701 1.712 0.8 13.696 37
I5701 5701 0 1.28631e-05
R6307 5701 5702 1.632 0.8 13.056 37
I5702 5702 0 1.32342e-05
R6308 5702 5703 1.696 0.8 13.568 37
I5703 5703 0 1.31105e-05
R6309 5703 5704 1.632 0.8 13.056 37
I5704 5704 0 1.34816e-05
R6310 5704 5705 1.712 0.8 13.696 37
I5705 5705 0 1.24921e-05
R6311 5705 5706 1.68 0.8 13.44 37
I5706 5706 0 1.28631e-05
R6312 5706 5707 1.648 0.8 13.184 37
I5707 5707 0 1.34816e-05
R6313 5707 5708 1.664 0.8 13.312 37
I5708 5708 0 1.28631e-05
R6314 5708 5709 1.696 0.8 13.568 37
I5709 5709 0 1.28631e-05
R6315 5709 5710 1.6 0.8 12.8 37
I5710 5710 0 1.27395e-05
R6316 5710 5711 1.6 0.8 12.8 37
I5711 5711 0 1.29868e-05
R6317 5711 5712 1.664 0.8 13.312 37
I5712 5712 0 1.23684e-05
R6318 5712 5713 1.632 0.8 13.056 37
I5713 5713 0 1.28631e-05
R6319 5713 5714 1.664 0.8 13.312 37
I5714 5714 0 1.31105e-05
R6320 5714 5715 1.696 0.8 13.568 37
I5715 5715 0 1.32342e-05
R6321 5715 5716 1.616 0.8 12.928 37
I5716 5716 0 1.28631e-05
R6322 5716 5717 1.648 0.8 13.184 37
I5717 5717 0 1.27395e-05
R6323 5717 5718 1.616 0.8 12.928 37
I5718 5718 0 1.24921e-05
R6324 5718 5719 1.616 0.8 12.928 37
I5719 5719 0 1.29868e-05
R6325 5719 5720 1.6 0.8 12.8 37
I5720 5720 0 1.34816e-05
R6326 5720 5721 1.712 0.8 13.696 37
I5721 5721 0 1.33579e-05
R6327 5721 5722 1.648 0.8 13.184 37
I5722 5722 0 1.26158e-05
R6328 5722 5723 1.744 0.8 13.952 37
I5723 5723 0 1.34816e-05
R6329 5723 5724 1.696 0.8 13.568 37
I5724 5724 0 1.32342e-05
R6330 5724 5725 1.68 0.8 13.44 37
I5725 5725 0 1.32342e-05
R6331 5725 5726 1.6 0.8 12.8 37
I5726 5726 0 1.31105e-05
R6332 5726 5727 1.664 0.8 13.312 37
I5727 5727 0 1.29868e-05
R6333 5727 5728 1.728 0.8 13.824 37
I5728 5728 0 1.33579e-05
R6334 5728 5729 1.616 0.8 12.928 37
I5729 5729 0 1.26158e-05
R6335 5729 5730 1.664 0.8 13.312 37
I5730 5730 0 1.33579e-05
R6336 5730 5731 1.632 0.8 13.056 37
I5731 5731 0 1.29868e-05
R6337 5731 5732 1.632 0.8 13.056 37
I5732 5732 0 1.29868e-05
R6338 5732 5733 1.616 0.8 12.928 37
I5733 5733 0 1.29868e-05
R6339 5733 5734 1.744 0.8 13.952 37
I5734 5734 0 1.26158e-05
R6340 5734 5735 1.6 0.8 12.8 37
I5735 5735 0 1.34816e-05
R6341 5735 5736 1.616 0.8 12.928 37
I5736 5736 0 1.34816e-05
R6342 5736 5737 1.744 0.8 13.952 37
I5737 5737 0 1.32342e-05
R6343 5737 5738 1.648 0.8 13.184 37
I5738 5738 0 1.33579e-05
R6344 5738 5739 1.728 0.8 13.824 37
I5739 5739 0 1.23684e-05
R6345 5739 5740 1.68 0.8 13.44 37
I5740 5740 0 1.28631e-05
R6346 5740 5741 1.744 0.8 13.952 37
I5741 5741 0 1.31105e-05
R6347 5741 5742 1.632 0.8 13.056 37
I5742 5742 0 1.27395e-05
R6348 5742 5743 1.648 0.8 13.184 37
I5743 5743 0 1.23684e-05
R6349 5743 5744 1.648 0.8 13.184 37
I5744 5744 0 1.31105e-05
R6350 5744 5745 1.664 0.8 13.312 37
I5745 5745 0 1.32342e-05
R6351 5745 5746 1.664 0.8 13.312 37
I5746 5746 0 1.31105e-05
R6352 5746 5747 1.68 0.8 13.44 37
I5747 5747 0 1.33579e-05
R6353 5747 5748 1.664 0.8 13.312 37
I5748 5748 0 1.33579e-05
R6354 5748 5749 1.648 0.8 13.184 37
I5749 5749 0 1.27395e-05
R6355 5749 5750 1.6 0.8 12.8 37
I5750 5750 0 1.31105e-05
R6356 5750 5751 1.664 0.8 13.312 37
I5751 5751 0 1.28631e-05
R6357 5751 5752 1.712 0.8 13.696 37
I5752 5752 0 1.28631e-05
R6358 5752 5753 1.648 0.8 13.184 37
I5753 5753 0 1.24921e-05
R6359 5753 5754 1.632 0.8 13.056 37
I5754 5754 0 1.24921e-05
R6360 5754 5755 1.648 0.8 13.184 37
I5755 5755 0 1.23684e-05
R6361 5755 5756 1.712 0.8 13.696 37
I5756 5756 0 1.26158e-05
R6362 5756 5757 1.728 0.8 13.824 37
I5757 5757 0 1.34816e-05
R6363 5757 5758 1.712 0.8 13.696 37
I5758 5758 0 1.24921e-05
R6364 5758 5759 1.744 0.8 13.952 37
I5759 5759 0 1.23684e-05
R6365 5759 5760 1.712 0.8 13.696 37
I5760 5760 0 1.28631e-05
R6366 5760 5761 1.744 0.8 13.952 37
I5761 5761 0 1.28631e-05
R6367 5761 5762 1.632 0.8 13.056 37
I5762 5762 0 1.28631e-05
R6368 5762 5763 1.632 0.8 13.056 37
I5763 5763 0 1.31105e-05
R6369 5763 5764 1.632 0.8 13.056 37
I5764 5764 0 1.33579e-05
R6370 5764 5765 1.616 0.8 12.928 37
I5765 5765 0 1.29868e-05
R6371 5765 5766 1.696 0.8 13.568 37
I5766 5766 0 1.31105e-05
R6372 5766 5767 1.616 0.8 12.928 37
I5767 5767 0 1.29868e-05
R6373 5767 5768 1.632 0.8 13.056 37
I5768 5768 0 1.28631e-05
R6374 5768 5769 1.696 0.8 13.568 37
I5769 5769 0 1.28631e-05
R6375 5769 5770 1.68 0.8 13.44 37
I5770 5770 0 1.34816e-05
R6376 5770 5771 1.696 0.8 13.568 37
I5771 5771 0 1.29868e-05
R6377 5771 5772 1.648 0.8 13.184 37
I5772 5772 0 1.28631e-05
R6378 5772 5773 1.664 0.8 13.312 37
I5773 5773 0 1.23684e-05
R6379 5773 5774 1.712 0.8 13.696 37
I5774 5774 0 1.31105e-05
R6380 5774 5775 1.632 0.8 13.056 37
I5775 5775 0 1.32342e-05
R6381 5775 5776 1.632 0.8 13.056 37
I5776 5776 0 1.26158e-05
R6382 5776 5777 1.616 0.8 12.928 37
I5777 5777 0 1.28631e-05
R6383 5777 5778 1.728 0.8 13.824 37
I5778 5778 0 1.29868e-05
R6384 5778 5779 1.648 0.8 13.184 37
I5779 5779 0 1.27395e-05
R6385 5779 5780 1.68 0.8 13.44 37
I5780 5780 0 1.28631e-05
R6386 5780 5781 1.728 0.8 13.824 37
I5781 5781 0 1.24921e-05
R6387 5781 5782 1.632 0.8 13.056 37
I5782 5782 0 1.24921e-05
R6388 5782 5783 1.712 0.8 13.696 37
I5783 5783 0 1.28631e-05
R6389 5783 5784 1.68 0.8 13.44 37
I5784 5784 0 1.29868e-05
R6390 5784 5785 1.616 0.8 12.928 37
I5785 5785 0 1.26158e-05
R6391 5785 5786 1.712 0.8 13.696 37
I5786 5786 0 1.34816e-05
R6392 5786 5787 1.712 0.8 13.696 37
I5787 5787 0 1.23684e-05
R6393 5787 5788 1.664 0.8 13.312 37
I5788 5788 0 1.28631e-05
R6394 5788 5789 1.648 0.8 13.184 37
I5789 5789 0 1.24921e-05
R6395 5789 5790 1.6 0.8 12.8 37
I5790 5790 0 1.29868e-05
R6396 5790 5791 1.728 0.8 13.824 37
I5791 5791 0 1.26158e-05
R6397 5791 5792 1.744 0.8 13.952 37
I5792 5792 0 1.24921e-05
R6398 5792 5793 1.696 0.8 13.568 37
I5793 5793 0 1.33579e-05
R6399 5793 5794 1.712 0.8 13.696 37
I5794 5794 0 1.24921e-05
R6400 5794 5795 1.616 0.8 12.928 37
I5795 5795 0 1.26158e-05
R6401 5795 5796 1.696 0.8 13.568 37
I5796 5796 0 1.24921e-05
R6402 5796 5797 1.696 0.8 13.568 37
I5797 5797 0 1.23684e-05
R6403 5797 5798 1.632 0.8 13.056 37
I5798 5798 0 1.29868e-05
R6404 5798 5799 1.712 0.8 13.696 37
I5799 5799 0 1.32342e-05
R6405 5799 5800 1.6 0.8 12.8 37
I5800 5800 0 1.23684e-05
R6406 5800 5801 1.616 0.8 12.928 37
I5801 5801 0 1.34816e-05
R6407 5801 5802 1.744 0.8 13.952 37
I5802 5802 0 1.34816e-05
R6408 5802 5803 1.632 0.8 13.056 37
I5803 5803 0 1.29868e-05
R6409 5803 5804 1.648 0.8 13.184 37
I5804 5804 0 1.29868e-05
R6410 5804 5805 1.712 0.8 13.696 37
I5805 5805 0 1.27395e-05
R6411 5805 5806 1.632 0.8 13.056 37
I5806 5806 0 1.32342e-05
R6412 5806 5807 1.712 0.8 13.696 37
I5807 5807 0 1.26158e-05
R6413 5807 5808 1.744 0.8 13.952 37
I5808 5808 0 1.27395e-05
R6414 5808 5809 1.632 0.8 13.056 37
I5809 5809 0 1.31105e-05
R6415 5809 5810 1.68 0.8 13.44 37
I5810 5810 0 1.27395e-05
R6416 5810 5811 1.6 0.8 12.8 37
I5811 5811 0 1.27395e-05
R6417 5811 5812 1.664 0.8 13.312 37
I5812 5812 0 1.31105e-05
R6418 5812 5813 1.68 0.8 13.44 37
I5813 5813 0 1.31105e-05
R6419 5813 5814 1.616 0.8 12.928 37
I5814 5814 0 1.28631e-05
R6420 5814 5815 1.68 0.8 13.44 37
I5815 5815 0 1.28631e-05
R6421 5815 5816 1.664 0.8 13.312 37
I5816 5816 0 1.31105e-05
R6422 5816 5817 1.648 0.8 13.184 37
I5817 5817 0 1.31105e-05
R6423 5817 5818 1.712 0.8 13.696 37
I5818 5818 0 1.29868e-05
R6424 5818 5819 1.616 0.8 12.928 37
I5819 5819 0 1.26158e-05
R6425 5819 5820 1.632 0.8 13.056 37
I5820 5820 0 1.33579e-05
R6426 5820 5821 1.712 0.8 13.696 37
I5821 5821 0 1.32342e-05
R6427 5821 5822 1.696 0.8 13.568 37
I5822 5822 0 1.28631e-05
R6428 5822 5823 1.616 0.8 12.928 37
I5823 5823 0 1.32342e-05
R6429 5823 5824 1.6 0.8 12.8 37
I5824 5824 0 1.27395e-05
R6430 5824 5825 1.648 0.8 13.184 37
I5825 5825 0 1.32342e-05
R6431 5825 5826 1.696 0.8 13.568 37
I5826 5826 0 1.27395e-05
R6432 5826 5827 1.6 0.8 12.8 37
I5827 5827 0 1.26158e-05
R6433 5827 5828 1.632 0.8 13.056 37
I5828 5828 0 1.32342e-05
R6434 5828 5829 1.728 0.8 13.824 37
I5829 5829 0 1.29868e-05
R6435 5829 5830 1.632 0.8 13.056 37
I5830 5830 0 1.29868e-05
R6436 5830 5831 1.744 0.8 13.952 37
I5831 5831 0 1.33579e-05
R6437 5831 5832 1.616 0.8 12.928 37
I5832 5832 0 1.29868e-05
R6438 5832 5833 1.664 0.8 13.312 37
I5833 5833 0 1.24921e-05
R6439 5833 5834 1.6 0.8 12.8 37
I5834 5834 0 1.33579e-05
R6440 5834 5835 1.648 0.8 13.184 37
I5835 5835 0 1.29868e-05
R6441 5835 5836 1.696 0.8 13.568 37
I5836 5836 0 1.24921e-05
R6442 5836 5837 1.632 0.8 13.056 37
I5837 5837 0 1.28631e-05
R6443 5837 5838 1.68 0.8 13.44 37
I5838 5838 0 1.27395e-05
R6444 5838 5839 1.616 0.8 12.928 37
I5839 5839 0 1.29868e-05
R6445 5839 5840 1.696 0.8 13.568 37
I5840 5840 0 1.31105e-05
R6446 5840 5841 1.664 0.8 13.312 37
I5841 5841 0 1.28631e-05
R6447 5841 5842 1.632 0.8 13.056 37
I5842 5842 0 1.31105e-05
R6448 5842 5843 1.696 0.8 13.568 37
I5843 5843 0 1.28631e-05
R6449 5843 5844 1.664 0.8 13.312 37
I5844 5844 0 1.31105e-05
R6450 5844 5845 1.744 0.8 13.952 37
I5845 5845 0 1.33579e-05
R6451 5845 5846 1.616 0.8 12.928 37
I5846 5846 0 1.24921e-05
R6452 5846 5847 1.696 0.8 13.568 37
I5847 5847 0 1.28631e-05
R6453 5847 5848 1.696 0.8 13.568 37
I5848 5848 0 1.27395e-05
R6454 5848 5849 1.68 0.8 13.44 37
I5849 5849 0 1.33579e-05
R6455 5849 5850 1.616 0.8 12.928 37
I5850 5850 0 1.34816e-05
R6456 5850 5851 1.68 0.8 13.44 37
I5851 5851 0 1.34816e-05
R6457 5851 5852 1.632 0.8 13.056 37
I5852 5852 0 1.32342e-05
R6458 5852 5853 1.696 0.8 13.568 37
I5853 5853 0 1.34816e-05
R6459 5853 5854 1.632 0.8 13.056 37
I5854 5854 0 1.34816e-05
R6460 5854 5855 1.712 0.8 13.696 37
I5855 5855 0 1.23684e-05
R6461 5855 5856 1.696 0.8 13.568 37
I5856 5856 0 1.24921e-05
R6462 5856 5857 1.664 0.8 13.312 37
I5857 5857 0 1.23684e-05
R6463 5857 5858 1.728 0.8 13.824 37
I5858 5858 0 1.26158e-05
R6464 5858 5859 1.664 0.8 13.312 37
I5859 5859 0 1.26158e-05
R6465 5859 5860 1.728 0.8 13.824 37
I5860 5860 0 1.29868e-05
R6466 5860 5861 1.6 0.8 12.8 37
I5861 5861 0 1.24921e-05
R6467 5861 5862 1.728 0.8 13.824 37
I5862 5862 0 1.33579e-05
R6468 5862 5863 1.696 0.8 13.568 37
I5863 5863 0 1.28631e-05
R6469 5863 5864 1.616 0.8 12.928 37
I5864 5864 0 1.27395e-05
R6470 5864 5865 1.68 0.8 13.44 37
I5865 5865 0 1.28631e-05
R6471 5865 5866 1.632 0.8 13.056 37
I5866 5866 0 1.23684e-05
R6472 5866 5867 1.664 0.8 13.312 37
I5867 5867 0 1.31105e-05
R6473 5867 5868 1.6 0.8 12.8 37
I5868 5868 0 1.23684e-05
R6474 5868 5869 1.696 0.8 13.568 37
I5869 5869 0 1.28631e-05
R6475 5869 5870 1.744 0.8 13.952 37
I5870 5870 0 1.27395e-05
R6476 5870 5871 1.68 0.8 13.44 37
I5871 5871 0 1.32342e-05
R6477 5871 5872 1.664 0.8 13.312 37
I5872 5872 0 1.34816e-05
R6478 5872 5873 1.712 0.8 13.696 37
I5873 5873 0 1.26158e-05
R6479 5873 5874 1.664 0.8 13.312 37
I5874 5874 0 1.24921e-05
R6480 5874 5875 1.696 0.8 13.568 37
I5875 5875 0 1.26158e-05
R6481 5875 5876 1.744 0.8 13.952 37
I5876 5876 0 1.33579e-05
R6482 5876 5877 1.696 0.8 13.568 37
I5877 5877 0 1.32342e-05
R6483 5877 5878 1.712 0.8 13.696 37
I5878 5878 0 1.26158e-05
R6484 5878 5879 1.664 0.8 13.312 37
I5879 5879 0 1.23684e-05
R6485 5879 5880 1.712 0.8 13.696 37
I5880 5880 0 1.24921e-05
R6486 5880 5881 1.68 0.8 13.44 37
I5881 5881 0 1.26158e-05
R6487 5881 5882 1.648 0.8 13.184 37
I5882 5882 0 1.34816e-05
R6488 5882 5883 1.728 0.8 13.824 37
I5883 5883 0 1.29868e-05
R6489 5883 5884 1.616 0.8 12.928 37
I5884 5884 0 1.28631e-05
R6490 5884 5885 1.6 0.8 12.8 37
I5885 5885 0 1.23684e-05
R6491 5885 5886 1.712 0.8 13.696 37
I5886 5886 0 1.29868e-05
R6492 5886 5887 1.728 0.8 13.824 37
I5887 5887 0 1.28631e-05
R6493 5887 5888 1.696 0.8 13.568 37
I5888 5888 0 1.32342e-05
R6494 5888 5889 1.696 0.8 13.568 37
I5889 5889 0 1.23684e-05
R6495 5889 5890 1.616 0.8 12.928 37
I5890 5890 0 1.29868e-05
R6496 5890 5891 1.68 0.8 13.44 37
I5891 5891 0 1.23684e-05
R6497 5891 5892 1.648 0.8 13.184 37
I5892 5892 0 1.24921e-05
R6498 5892 5893 1.744 0.8 13.952 37
I5893 5893 0 1.26158e-05
R6499 5893 5894 1.68 0.8 13.44 37
I5894 5894 0 1.29868e-05
R6500 5894 5895 1.648 0.8 13.184 37
I5895 5895 0 1.26158e-05
R6501 5895 5896 1.728 0.8 13.824 37
I5896 5896 0 1.23684e-05
R6502 5896 5897 1.696 0.8 13.568 37
I5897 5897 0 1.26158e-05
R6503 5897 5898 1.744 0.8 13.952 37
I5898 5898 0 1.29868e-05
R6504 5898 5899 1.712 0.8 13.696 37
I5899 5899 0 1.26158e-05
R6505 5899 5900 1.744 0.8 13.952 37
I5900 5900 0 1.34816e-05
R6506 5900 5901 1.664 0.8 13.312 37
I5901 5901 0 1.34816e-05
R6507 5901 5902 1.664 0.8 13.312 37
I5902 5902 0 1.26158e-05
R6508 5902 5903 1.648 0.8 13.184 37
I5903 5903 0 1.27395e-05
R6509 5903 5904 1.632 0.8 13.056 37
I5904 5904 0 1.24921e-05
R6510 5904 5905 1.648 0.8 13.184 37
I5905 5905 0 1.27395e-05
R6511 5905 5906 1.696 0.8 13.568 37
I5906 5906 0 1.23684e-05
R6512 5906 5907 1.648 0.8 13.184 37
I5907 5907 0 1.23684e-05
R6513 5907 5908 1.648 0.8 13.184 37
I5908 5908 0 1.28631e-05
R6514 5908 5909 1.632 0.8 13.056 37
I5909 5909 0 1.23684e-05
R6515 5909 5910 1.632 0.8 13.056 37
I5910 5910 0 1.32342e-05
R6516 5910 5911 1.648 0.8 13.184 37
I5911 5911 0 1.23684e-05
R6517 5911 5912 1.712 0.8 13.696 37
I5912 5912 0 1.34816e-05
R6518 5912 5913 1.632 0.8 13.056 37
I5913 5913 0 1.33579e-05
R6519 5913 5914 1.696 0.8 13.568 37
I5914 5914 0 1.26158e-05
R6520 5914 5915 1.6 0.8 12.8 37
I5915 5915 0 1.31105e-05
R6521 5915 5916 1.616 0.8 12.928 37
I5916 5916 0 1.29868e-05
R6522 5916 5917 1.712 0.8 13.696 37
I5917 5917 0 1.33579e-05
R6523 5917 5918 1.744 0.8 13.952 37
I5918 5918 0 1.23684e-05
R6524 5918 5919 1.616 0.8 12.928 37
I5919 5919 0 1.24921e-05
R6525 5919 5920 1.616 0.8 12.928 37
I5920 5920 0 1.31105e-05
R6526 5920 5921 1.664 0.8 13.312 37
I5921 5921 0 1.33579e-05
R6527 5921 5922 1.712 0.8 13.696 37
I5922 5922 0 1.34816e-05
R6528 5922 5923 1.6 0.8 12.8 37
I5923 5923 0 1.23684e-05
R6529 5923 5924 1.664 0.8 13.312 37
I5924 5924 0 1.26158e-05
R6530 5924 5925 1.616 0.8 12.928 37
I5925 5925 0 1.31105e-05
R6531 5925 5926 1.6 0.8 12.8 37
I5926 5926 0 1.31105e-05
R6532 5926 5927 1.696 0.8 13.568 37
I5927 5927 0 1.32342e-05
R6533 5927 5928 1.712 0.8 13.696 37
I5928 5928 0 1.24921e-05
R6534 5928 5929 1.696 0.8 13.568 37
I5929 5929 0 1.31105e-05
R6535 5929 5930 1.68 0.8 13.44 37
I5930 5930 0 1.33579e-05
R6536 5930 5931 1.632 0.8 13.056 37
I5931 5931 0 1.33579e-05
R6537 5931 5932 1.648 0.8 13.184 37
I5932 5932 0 1.24921e-05
R6538 5932 5933 1.696 0.8 13.568 37
I5933 5933 0 1.27395e-05
R6539 5933 5934 1.616 0.8 12.928 37
I5934 5934 0 1.32342e-05
R6540 5934 5935 1.696 0.8 13.568 37
I5935 5935 0 1.28631e-05
R6541 5935 5936 1.696 0.8 13.568 37
I5936 5936 0 1.24921e-05
R6542 5936 5937 1.632 0.8 13.056 37
I5937 5937 0 1.27395e-05
R6543 5937 5938 1.6 0.8 12.8 37
I5938 5938 0 1.26158e-05
R6544 5938 5939 1.68 0.8 13.44 37
I5939 5939 0 1.31105e-05
R6545 5939 5940 1.712 0.8 13.696 37
I5940 5940 0 1.33579e-05
R6546 5940 5941 1.664 0.8 13.312 37
I5941 5941 0 1.32342e-05
R6547 5941 5942 1.696 0.8 13.568 37
I5942 5942 0 1.27395e-05
R6548 5942 5943 1.696 0.8 13.568 37
I5943 5943 0 1.31105e-05
R6549 5943 5944 1.664 0.8 13.312 37
I5944 5944 0 1.28631e-05
R6550 5944 5945 1.632 0.8 13.056 37
I5945 5945 0 1.24921e-05
R6551 5945 5946 1.648 0.8 13.184 37
I5946 5946 0 1.28631e-05
R6552 5946 5947 1.744 0.8 13.952 37
I5947 5947 0 1.31105e-05
R6553 5947 5948 1.68 0.8 13.44 37
I5948 5948 0 1.31105e-05
R6554 5948 5949 1.616 0.8 12.928 37
I5949 5949 0 1.33579e-05
R6555 5949 5950 1.68 0.8 13.44 37
I5950 5950 0 1.33579e-05
R6556 5950 5951 1.632 0.8 13.056 37
I5951 5951 0 1.24921e-05
R6557 5951 5952 1.616 0.8 12.928 37
I5952 5952 0 1.32342e-05
R6558 5952 5953 1.696 0.8 13.568 37
I5953 5953 0 1.24921e-05
R6559 5953 5954 1.616 0.8 12.928 37
I5954 5954 0 1.28631e-05
R6560 5954 5955 1.6 0.8 12.8 37
I5955 5955 0 1.33579e-05
R6561 5955 5956 1.632 0.8 13.056 37
I5956 5956 0 1.28631e-05
R6562 5956 5957 1.712 0.8 13.696 37
I5957 5957 0 1.24921e-05
R6563 5957 5958 1.712 0.8 13.696 37
I5958 5958 0 1.28631e-05
R6564 5958 5959 1.712 0.8 13.696 37
I5959 5959 0 1.27395e-05
R6565 5959 5960 1.6 0.8 12.8 37
I5960 5960 0 1.34816e-05
R6566 5960 5961 1.664 0.8 13.312 37
I5961 5961 0 1.27395e-05
R6567 5961 5962 1.68 0.8 13.44 37
I5962 5962 0 1.28631e-05
R6568 5962 5963 1.632 0.8 13.056 37
I5963 5963 0 1.26158e-05
R6569 5963 5964 1.632 0.8 13.056 37
I5964 5964 0 1.29868e-05
R6570 5964 5965 1.6 0.8 12.8 37
I5965 5965 0 1.32342e-05
R6571 5965 5966 1.648 0.8 13.184 37
I5966 5966 0 1.28631e-05
R6572 5966 5967 1.616 0.8 12.928 37
I5967 5967 0 1.31105e-05
R6573 5967 5968 1.616 0.8 12.928 37
I5968 5968 0 1.32342e-05
R6574 5968 5969 1.6 0.8 12.8 37
I5969 5969 0 1.29868e-05
R6575 5969 5970 1.648 0.8 13.184 37
I5970 5970 0 1.23684e-05
R6576 5970 5971 1.648 0.8 13.184 37
I5971 5971 0 1.33579e-05
R6577 5971 5972 1.664 0.8 13.312 37
I5972 5972 0 1.27395e-05
R6578 5972 5973 1.744 0.8 13.952 37
I5973 5973 0 1.28631e-05
R6579 5973 5974 1.744 0.8 13.952 37
I5974 5974 0 1.31105e-05
R6580 5974 5975 1.744 0.8 13.952 37
I5975 5975 0 1.34816e-05
R6581 5975 5976 1.68 0.8 13.44 37
I5976 5976 0 1.28631e-05
R6582 5976 5977 1.68 0.8 13.44 37
I5977 5977 0 1.26158e-05
R6583 5977 5978 1.6 0.8 12.8 37
I5978 5978 0 1.32342e-05
R6584 5978 5979 1.664 0.8 13.312 37
I5979 5979 0 1.26158e-05
R6585 5979 5980 1.664 0.8 13.312 37
I5980 5980 0 1.31105e-05
R6586 5980 5981 1.744 0.8 13.952 37
I5981 5981 0 1.23684e-05
R6587 5981 5982 1.6 0.8 12.8 37
I5982 5982 0 1.26158e-05
R6588 5982 5983 1.696 0.8 13.568 37
I5983 5983 0 1.28631e-05
R6589 5983 5984 1.632 0.8 13.056 37
I5984 5984 0 1.31105e-05
R6590 5984 5985 1.744 0.8 13.952 37
I5985 5985 0 1.29868e-05
R6591 5985 5986 1.696 0.8 13.568 37
I5986 5986 0 1.28631e-05
R6592 5986 5987 1.648 0.8 13.184 37
I5987 5987 0 1.27395e-05
R6593 5987 5988 1.744 0.8 13.952 37
I5988 5988 0 1.26158e-05
R6594 5988 5989 1.744 0.8 13.952 37
I5989 5989 0 1.33579e-05
R6595 5989 5990 1.6 0.8 12.8 37
I5990 5990 0 1.33579e-05
R6596 5990 5991 1.728 0.8 13.824 37
I5991 5991 0 1.32342e-05
R6597 5991 5992 1.632 0.8 13.056 37
I5992 5992 0 1.29868e-05
R6598 5992 5993 1.744 0.8 13.952 37
I5993 5993 0 1.28631e-05
R6599 5993 5994 1.664 0.8 13.312 37
I5994 5994 0 1.27395e-05
R6600 5994 5995 1.696 0.8 13.568 37
I5995 5995 0 1.33579e-05
R6601 5995 5996 1.744 0.8 13.952 37
I5996 5996 0 1.33579e-05
R6602 5996 5997 1.728 0.8 13.824 37
I5997 5997 0 1.26158e-05
R6603 5997 5998 1.6 0.8 12.8 37
I5998 5998 0 1.29868e-05
R6604 5998 5999 1.728 0.8 13.824 37
I5999 5999 0 1.28631e-05
R6605 5999 6000 1.648 0.8 13.184 37
I6000 6000 0 1.23684e-05
R6606 6000 10001 0.5 10 50 37
*seg: 7
* inter-segment connection
R6607 6010 7010 6.16 0.8 49.28 37
R6608 6020 7020 6.16 0.8 49.28 37
R6609 6030 7030 6.16 0.8 49.28 37
R6610 6040 7040 6.16 0.8 49.28 37
R6611 6050 7050 6.16 0.8 49.28 37
R6612 6060 7060 6.16 0.8 49.28 37
R6613 6070 7070 6.16 0.8 49.28 37
R6614 6080 7080 6.16 0.8 49.28 37
R6615 6090 7090 6.16 0.8 49.28 37
R6616 6100 7100 6.16 0.8 49.28 37
R6617 6110 7110 6.16 0.8 49.28 37
R6618 6120 7120 6.16 0.8 49.28 37
R6619 6130 7130 6.16 0.8 49.28 37
R6620 6140 7140 6.16 0.8 49.28 37
R6621 6150 7150 6.16 0.8 49.28 37
R6622 6160 7160 6.16 0.8 49.28 37
R6623 6170 7170 6.16 0.8 49.28 37
R6624 6180 7180 6.16 0.8 49.28 37
R6625 6190 7190 6.16 0.8 49.28 37
R6626 6200 7200 6.16 0.8 49.28 37
R6627 6210 7210 6.16 0.8 49.28 37
R6628 6220 7220 6.16 0.8 49.28 37
R6629 6230 7230 6.16 0.8 49.28 37
R6630 6240 7240 6.16 0.8 49.28 37
R6631 6250 7250 6.16 0.8 49.28 37
R6632 6260 7260 6.16 0.8 49.28 37
R6633 6270 7270 6.16 0.8 49.28 37
R6634 6280 7280 6.16 0.8 49.28 37
R6635 6290 7290 6.16 0.8 49.28 37
R6636 6300 7300 6.16 0.8 49.28 37
R6637 6310 7310 6.16 0.8 49.28 37
R6638 6320 7320 6.16 0.8 49.28 37
R6639 6330 7330 6.16 0.8 49.28 37
R6640 6340 7340 6.16 0.8 49.28 37
R6641 6350 7350 6.16 0.8 49.28 37
R6642 6360 7360 6.16 0.8 49.28 37
R6643 6370 7370 6.16 0.8 49.28 37
R6644 6380 7380 6.16 0.8 49.28 37
R6645 6390 7390 6.16 0.8 49.28 37
R6646 6400 7400 6.16 0.8 49.28 37
R6647 6410 7410 6.16 0.8 49.28 37
R6648 6420 7420 6.16 0.8 49.28 37
R6649 6430 7430 6.16 0.8 49.28 37
R6650 6440 7440 6.16 0.8 49.28 37
R6651 6450 7450 6.16 0.8 49.28 37
R6652 6460 7460 6.16 0.8 49.28 37
R6653 6470 7470 6.16 0.8 49.28 37
R6654 6480 7480 6.16 0.8 49.28 37
R6655 6490 7490 6.16 0.8 49.28 37
R6656 6500 7500 6.16 0.8 49.28 37
R6657 6510 7510 6.16 0.8 49.28 37
R6658 6520 7520 6.16 0.8 49.28 37
R6659 6530 7530 6.16 0.8 49.28 37
R6660 6540 7540 6.16 0.8 49.28 37
R6661 6550 7550 6.16 0.8 49.28 37
R6662 6560 7560 6.16 0.8 49.28 37
R6663 6570 7570 6.16 0.8 49.28 37
R6664 6580 7580 6.16 0.8 49.28 37
R6665 6590 7590 6.16 0.8 49.28 37
R6666 6600 7600 6.16 0.8 49.28 37
R6667 6610 7610 6.16 0.8 49.28 37
R6668 6620 7620 6.16 0.8 49.28 37
R6669 6630 7630 6.16 0.8 49.28 37
R6670 6640 7640 6.16 0.8 49.28 37
R6671 6650 7650 6.16 0.8 49.28 37
R6672 6660 7660 6.16 0.8 49.28 37
R6673 6670 7670 6.16 0.8 49.28 37
R6674 6680 7680 6.16 0.8 49.28 37
R6675 6690 7690 6.16 0.8 49.28 37
R6676 6700 7700 6.16 0.8 49.28 37
R6677 6710 7710 6.16 0.8 49.28 37
R6678 6720 7720 6.16 0.8 49.28 37
R6679 6730 7730 6.16 0.8 49.28 37
R6680 6740 7740 6.16 0.8 49.28 37
R6681 6750 7750 6.16 0.8 49.28 37
R6682 6760 7760 6.16 0.8 49.28 37
R6683 6770 7770 6.16 0.8 49.28 37
R6684 6780 7780 6.16 0.8 49.28 37
R6685 6790 7790 6.16 0.8 49.28 37
R6686 6800 7800 6.16 0.8 49.28 37
R6687 6810 7810 6.16 0.8 49.28 37
R6688 6820 7820 6.16 0.8 49.28 37
R6689 6830 7830 6.16 0.8 49.28 37
R6690 6840 7840 6.16 0.8 49.28 37
R6691 6850 7850 6.16 0.8 49.28 37
R6692 6860 7860 6.16 0.8 49.28 37
R6693 6870 7870 6.16 0.8 49.28 37
R6694 6880 7880 6.16 0.8 49.28 37
R6695 6890 7890 6.16 0.8 49.28 37
R6696 6900 7900 6.16 0.8 49.28 37
R6697 6910 7910 6.16 0.8 49.28 37
R6698 6920 7920 6.16 0.8 49.28 37
R6699 6930 7930 6.16 0.8 49.28 37
R6700 6940 7940 6.16 0.8 49.28 37
R6701 6950 7950 6.16 0.8 49.28 37
R6702 6960 7960 6.16 0.8 49.28 37
R6703 6970 7970 6.16 0.8 49.28 37
R6704 6980 7980 6.16 0.8 49.28 37
R6705 6990 7990 6.16 0.8 49.28 37
R6706 7000 8000 6.16 0.8 49.28 37
R6707 10001 6001 0.4 20 80 37
I6001 6001 0 1.34816e-05
R6708 6001 6002 1.6 0.8 12.8 37
I6002 6002 0 1.23684e-05
R6709 6002 6003 1.648 0.8 13.184 37
I6003 6003 0 1.29868e-05
R6710 6003 6004 1.68 0.8 13.44 37
I6004 6004 0 1.29868e-05
R6711 6004 6005 1.6 0.8 12.8 37
I6005 6005 0 1.28631e-05
R6712 6005 6006 1.648 0.8 13.184 37
I6006 6006 0 1.23684e-05
R6713 6006 6007 1.664 0.8 13.312 37
I6007 6007 0 1.27395e-05
R6714 6007 6008 1.728 0.8 13.824 37
I6008 6008 0 1.34816e-05
R6715 6008 6009 1.728 0.8 13.824 37
I6009 6009 0 1.32342e-05
R6716 6009 6010 1.648 0.8 13.184 37
I6010 6010 0 1.26158e-05
R6717 6010 6011 1.648 0.8 13.184 37
I6011 6011 0 1.23684e-05
R6718 6011 6012 1.648 0.8 13.184 37
I6012 6012 0 1.28631e-05
R6719 6012 6013 1.6 0.8 12.8 37
I6013 6013 0 1.24921e-05
R6720 6013 6014 1.696 0.8 13.568 37
I6014 6014 0 1.26158e-05
R6721 6014 6015 1.728 0.8 13.824 37
I6015 6015 0 1.31105e-05
R6722 6015 6016 1.712 0.8 13.696 37
I6016 6016 0 1.26158e-05
R6723 6016 6017 1.68 0.8 13.44 37
I6017 6017 0 1.34816e-05
R6724 6017 6018 1.664 0.8 13.312 37
I6018 6018 0 1.24921e-05
R6725 6018 6019 1.664 0.8 13.312 37
I6019 6019 0 1.34816e-05
R6726 6019 6020 1.696 0.8 13.568 37
I6020 6020 0 1.31105e-05
R6727 6020 6021 1.68 0.8 13.44 37
I6021 6021 0 1.34816e-05
R6728 6021 6022 1.712 0.8 13.696 37
I6022 6022 0 1.34816e-05
R6729 6022 6023 1.68 0.8 13.44 37
I6023 6023 0 1.32342e-05
R6730 6023 6024 1.728 0.8 13.824 37
I6024 6024 0 1.27395e-05
R6731 6024 6025 1.696 0.8 13.568 37
I6025 6025 0 1.26158e-05
R6732 6025 6026 1.728 0.8 13.824 37
I6026 6026 0 1.34816e-05
R6733 6026 6027 1.664 0.8 13.312 37
I6027 6027 0 1.24921e-05
R6734 6027 6028 1.696 0.8 13.568 37
I6028 6028 0 1.31105e-05
R6735 6028 6029 1.632 0.8 13.056 37
I6029 6029 0 1.28631e-05
R6736 6029 6030 1.728 0.8 13.824 37
I6030 6030 0 1.27395e-05
R6737 6030 6031 1.616 0.8 12.928 37
I6031 6031 0 1.32342e-05
R6738 6031 6032 1.68 0.8 13.44 37
I6032 6032 0 1.31105e-05
R6739 6032 6033 1.696 0.8 13.568 37
I6033 6033 0 1.34816e-05
R6740 6033 6034 1.744 0.8 13.952 37
I6034 6034 0 1.27395e-05
R6741 6034 6035 1.728 0.8 13.824 37
I6035 6035 0 1.29868e-05
R6742 6035 6036 1.744 0.8 13.952 37
I6036 6036 0 1.29868e-05
R6743 6036 6037 1.712 0.8 13.696 37
I6037 6037 0 1.33579e-05
R6744 6037 6038 1.664 0.8 13.312 37
I6038 6038 0 1.26158e-05
R6745 6038 6039 1.68 0.8 13.44 37
I6039 6039 0 1.27395e-05
R6746 6039 6040 1.712 0.8 13.696 37
I6040 6040 0 1.28631e-05
R6747 6040 6041 1.712 0.8 13.696 37
I6041 6041 0 1.29868e-05
R6748 6041 6042 1.68 0.8 13.44 37
I6042 6042 0 1.27395e-05
R6749 6042 6043 1.728 0.8 13.824 37
I6043 6043 0 1.24921e-05
R6750 6043 6044 1.744 0.8 13.952 37
I6044 6044 0 1.27395e-05
R6751 6044 6045 1.696 0.8 13.568 37
I6045 6045 0 1.32342e-05
R6752 6045 6046 1.696 0.8 13.568 37
I6046 6046 0 1.32342e-05
R6753 6046 6047 1.68 0.8 13.44 37
I6047 6047 0 1.27395e-05
R6754 6047 6048 1.68 0.8 13.44 37
I6048 6048 0 1.27395e-05
R6755 6048 6049 1.632 0.8 13.056 37
I6049 6049 0 1.29868e-05
R6756 6049 6050 1.696 0.8 13.568 37
I6050 6050 0 1.26158e-05
R6757 6050 6051 1.632 0.8 13.056 37
I6051 6051 0 1.33579e-05
R6758 6051 6052 1.712 0.8 13.696 37
I6052 6052 0 1.24921e-05
R6759 6052 6053 1.728 0.8 13.824 37
I6053 6053 0 1.24921e-05
R6760 6053 6054 1.648 0.8 13.184 37
I6054 6054 0 1.28631e-05
R6761 6054 6055 1.696 0.8 13.568 37
I6055 6055 0 1.27395e-05
R6762 6055 6056 1.6 0.8 12.8 37
I6056 6056 0 1.29868e-05
R6763 6056 6057 1.6 0.8 12.8 37
I6057 6057 0 1.29868e-05
R6764 6057 6058 1.728 0.8 13.824 37
I6058 6058 0 1.34816e-05
R6765 6058 6059 1.712 0.8 13.696 37
I6059 6059 0 1.32342e-05
R6766 6059 6060 1.664 0.8 13.312 37
I6060 6060 0 1.27395e-05
R6767 6060 6061 1.68 0.8 13.44 37
I6061 6061 0 1.23684e-05
R6768 6061 6062 1.632 0.8 13.056 37
I6062 6062 0 1.26158e-05
R6769 6062 6063 1.648 0.8 13.184 37
I6063 6063 0 1.32342e-05
R6770 6063 6064 1.712 0.8 13.696 37
I6064 6064 0 1.32342e-05
R6771 6064 6065 1.664 0.8 13.312 37
I6065 6065 0 1.28631e-05
R6772 6065 6066 1.744 0.8 13.952 37
I6066 6066 0 1.32342e-05
R6773 6066 6067 1.664 0.8 13.312 37
I6067 6067 0 1.33579e-05
R6774 6067 6068 1.728 0.8 13.824 37
I6068 6068 0 1.26158e-05
R6775 6068 6069 1.616 0.8 12.928 37
I6069 6069 0 1.28631e-05
R6776 6069 6070 1.728 0.8 13.824 37
I6070 6070 0 1.23684e-05
R6777 6070 6071 1.744 0.8 13.952 37
I6071 6071 0 1.33579e-05
R6778 6071 6072 1.68 0.8 13.44 37
I6072 6072 0 1.34816e-05
R6779 6072 6073 1.696 0.8 13.568 37
I6073 6073 0 1.28631e-05
R6780 6073 6074 1.6 0.8 12.8 37
I6074 6074 0 1.27395e-05
R6781 6074 6075 1.616 0.8 12.928 37
I6075 6075 0 1.28631e-05
R6782 6075 6076 1.728 0.8 13.824 37
I6076 6076 0 1.33579e-05
R6783 6076 6077 1.696 0.8 13.568 37
I6077 6077 0 1.26158e-05
R6784 6077 6078 1.6 0.8 12.8 37
I6078 6078 0 1.24921e-05
R6785 6078 6079 1.744 0.8 13.952 37
I6079 6079 0 1.33579e-05
R6786 6079 6080 1.728 0.8 13.824 37
I6080 6080 0 1.31105e-05
R6787 6080 6081 1.664 0.8 13.312 37
I6081 6081 0 1.34816e-05
R6788 6081 6082 1.68 0.8 13.44 37
I6082 6082 0 1.23684e-05
R6789 6082 6083 1.744 0.8 13.952 37
I6083 6083 0 1.27395e-05
R6790 6083 6084 1.632 0.8 13.056 37
I6084 6084 0 1.24921e-05
R6791 6084 6085 1.744 0.8 13.952 37
I6085 6085 0 1.27395e-05
R6792 6085 6086 1.616 0.8 12.928 37
I6086 6086 0 1.23684e-05
R6793 6086 6087 1.648 0.8 13.184 37
I6087 6087 0 1.31105e-05
R6794 6087 6088 1.6 0.8 12.8 37
I6088 6088 0 1.34816e-05
R6795 6088 6089 1.6 0.8 12.8 37
I6089 6089 0 1.26158e-05
R6796 6089 6090 1.632 0.8 13.056 37
I6090 6090 0 1.28631e-05
R6797 6090 6091 1.744 0.8 13.952 37
I6091 6091 0 1.26158e-05
R6798 6091 6092 1.632 0.8 13.056 37
I6092 6092 0 1.29868e-05
R6799 6092 6093 1.664 0.8 13.312 37
I6093 6093 0 1.29868e-05
R6800 6093 6094 1.744 0.8 13.952 37
I6094 6094 0 1.31105e-05
R6801 6094 6095 1.68 0.8 13.44 37
I6095 6095 0 1.32342e-05
R6802 6095 6096 1.632 0.8 13.056 37
I6096 6096 0 1.24921e-05
R6803 6096 6097 1.744 0.8 13.952 37
I6097 6097 0 1.32342e-05
R6804 6097 6098 1.616 0.8 12.928 37
I6098 6098 0 1.33579e-05
R6805 6098 6099 1.632 0.8 13.056 37
I6099 6099 0 1.29868e-05
R6806 6099 6100 1.616 0.8 12.928 37
I6100 6100 0 1.28631e-05
R6807 6100 6101 1.728 0.8 13.824 37
I6101 6101 0 1.26158e-05
R6808 6101 6102 1.664 0.8 13.312 37
I6102 6102 0 1.26158e-05
R6809 6102 6103 1.616 0.8 12.928 37
I6103 6103 0 1.31105e-05
R6810 6103 6104 1.616 0.8 12.928 37
I6104 6104 0 1.27395e-05
R6811 6104 6105 1.616 0.8 12.928 37
I6105 6105 0 1.31105e-05
R6812 6105 6106 1.712 0.8 13.696 37
I6106 6106 0 1.23684e-05
R6813 6106 6107 1.6 0.8 12.8 37
I6107 6107 0 1.23684e-05
R6814 6107 6108 1.712 0.8 13.696 37
I6108 6108 0 1.29868e-05
R6815 6108 6109 1.68 0.8 13.44 37
I6109 6109 0 1.31105e-05
R6816 6109 6110 1.648 0.8 13.184 37
I6110 6110 0 1.26158e-05
R6817 6110 6111 1.696 0.8 13.568 37
I6111 6111 0 1.29868e-05
R6818 6111 6112 1.648 0.8 13.184 37
I6112 6112 0 1.32342e-05
R6819 6112 6113 1.664 0.8 13.312 37
I6113 6113 0 1.28631e-05
R6820 6113 6114 1.68 0.8 13.44 37
I6114 6114 0 1.31105e-05
R6821 6114 6115 1.616 0.8 12.928 37
I6115 6115 0 1.34816e-05
R6822 6115 6116 1.6 0.8 12.8 37
I6116 6116 0 1.23684e-05
R6823 6116 6117 1.616 0.8 12.928 37
I6117 6117 0 1.32342e-05
R6824 6117 6118 1.664 0.8 13.312 37
I6118 6118 0 1.28631e-05
R6825 6118 6119 1.648 0.8 13.184 37
I6119 6119 0 1.29868e-05
R6826 6119 6120 1.728 0.8 13.824 37
I6120 6120 0 1.28631e-05
R6827 6120 6121 1.648 0.8 13.184 37
I6121 6121 0 1.29868e-05
R6828 6121 6122 1.696 0.8 13.568 37
I6122 6122 0 1.28631e-05
R6829 6122 6123 1.712 0.8 13.696 37
I6123 6123 0 1.28631e-05
R6830 6123 6124 1.616 0.8 12.928 37
I6124 6124 0 1.28631e-05
R6831 6124 6125 1.632 0.8 13.056 37
I6125 6125 0 1.28631e-05
R6832 6125 6126 1.696 0.8 13.568 37
I6126 6126 0 1.23684e-05
R6833 6126 6127 1.616 0.8 12.928 37
I6127 6127 0 1.34816e-05
R6834 6127 6128 1.712 0.8 13.696 37
I6128 6128 0 1.29868e-05
R6835 6128 6129 1.68 0.8 13.44 37
I6129 6129 0 1.29868e-05
R6836 6129 6130 1.616 0.8 12.928 37
I6130 6130 0 1.32342e-05
R6837 6130 6131 1.664 0.8 13.312 37
I6131 6131 0 1.28631e-05
R6838 6131 6132 1.744 0.8 13.952 37
I6132 6132 0 1.32342e-05
R6839 6132 6133 1.616 0.8 12.928 37
I6133 6133 0 1.27395e-05
R6840 6133 6134 1.632 0.8 13.056 37
I6134 6134 0 1.31105e-05
R6841 6134 6135 1.6 0.8 12.8 37
I6135 6135 0 1.26158e-05
R6842 6135 6136 1.616 0.8 12.928 37
I6136 6136 0 1.28631e-05
R6843 6136 6137 1.712 0.8 13.696 37
I6137 6137 0 1.34816e-05
R6844 6137 6138 1.6 0.8 12.8 37
I6138 6138 0 1.29868e-05
R6845 6138 6139 1.648 0.8 13.184 37
I6139 6139 0 1.24921e-05
R6846 6139 6140 1.616 0.8 12.928 37
I6140 6140 0 1.31105e-05
R6847 6140 6141 1.712 0.8 13.696 37
I6141 6141 0 1.33579e-05
R6848 6141 6142 1.728 0.8 13.824 37
I6142 6142 0 1.33579e-05
R6849 6142 6143 1.744 0.8 13.952 37
I6143 6143 0 1.31105e-05
R6850 6143 6144 1.648 0.8 13.184 37
I6144 6144 0 1.29868e-05
R6851 6144 6145 1.616 0.8 12.928 37
I6145 6145 0 1.31105e-05
R6852 6145 6146 1.664 0.8 13.312 37
I6146 6146 0 1.32342e-05
R6853 6146 6147 1.6 0.8 12.8 37
I6147 6147 0 1.27395e-05
R6854 6147 6148 1.664 0.8 13.312 37
I6148 6148 0 1.27395e-05
R6855 6148 6149 1.696 0.8 13.568 37
I6149 6149 0 1.33579e-05
R6856 6149 6150 1.632 0.8 13.056 37
I6150 6150 0 1.31105e-05
R6857 6150 6151 1.6 0.8 12.8 37
I6151 6151 0 1.29868e-05
R6858 6151 6152 1.632 0.8 13.056 37
I6152 6152 0 1.33579e-05
R6859 6152 6153 1.664 0.8 13.312 37
I6153 6153 0 1.28631e-05
R6860 6153 6154 1.68 0.8 13.44 37
I6154 6154 0 1.33579e-05
R6861 6154 6155 1.68 0.8 13.44 37
I6155 6155 0 1.33579e-05
R6862 6155 6156 1.696 0.8 13.568 37
I6156 6156 0 1.28631e-05
R6863 6156 6157 1.696 0.8 13.568 37
I6157 6157 0 1.28631e-05
R6864 6157 6158 1.632 0.8 13.056 37
I6158 6158 0 1.31105e-05
R6865 6158 6159 1.632 0.8 13.056 37
I6159 6159 0 1.32342e-05
R6866 6159 6160 1.648 0.8 13.184 37
I6160 6160 0 1.29868e-05
R6867 6160 6161 1.664 0.8 13.312 37
I6161 6161 0 1.34816e-05
R6868 6161 6162 1.632 0.8 13.056 37
I6162 6162 0 1.31105e-05
R6869 6162 6163 1.632 0.8 13.056 37
I6163 6163 0 1.32342e-05
R6870 6163 6164 1.6 0.8 12.8 37
I6164 6164 0 1.23684e-05
R6871 6164 6165 1.712 0.8 13.696 37
I6165 6165 0 1.26158e-05
R6872 6165 6166 1.728 0.8 13.824 37
I6166 6166 0 1.33579e-05
R6873 6166 6167 1.712 0.8 13.696 37
I6167 6167 0 1.24921e-05
R6874 6167 6168 1.728 0.8 13.824 37
I6168 6168 0 1.27395e-05
R6875 6168 6169 1.68 0.8 13.44 37
I6169 6169 0 1.27395e-05
R6876 6169 6170 1.616 0.8 12.928 37
I6170 6170 0 1.27395e-05
R6877 6170 6171 1.648 0.8 13.184 37
I6171 6171 0 1.34816e-05
R6878 6171 6172 1.744 0.8 13.952 37
I6172 6172 0 1.23684e-05
R6879 6172 6173 1.696 0.8 13.568 37
I6173 6173 0 1.26158e-05
R6880 6173 6174 1.728 0.8 13.824 37
I6174 6174 0 1.33579e-05
R6881 6174 6175 1.744 0.8 13.952 37
I6175 6175 0 1.27395e-05
R6882 6175 6176 1.664 0.8 13.312 37
I6176 6176 0 1.29868e-05
R6883 6176 6177 1.632 0.8 13.056 37
I6177 6177 0 1.33579e-05
R6884 6177 6178 1.632 0.8 13.056 37
I6178 6178 0 1.31105e-05
R6885 6178 6179 1.68 0.8 13.44 37
I6179 6179 0 1.28631e-05
R6886 6179 6180 1.696 0.8 13.568 37
I6180 6180 0 1.27395e-05
R6887 6180 6181 1.728 0.8 13.824 37
I6181 6181 0 1.28631e-05
R6888 6181 6182 1.648 0.8 13.184 37
I6182 6182 0 1.32342e-05
R6889 6182 6183 1.712 0.8 13.696 37
I6183 6183 0 1.24921e-05
R6890 6183 6184 1.6 0.8 12.8 37
I6184 6184 0 1.29868e-05
R6891 6184 6185 1.696 0.8 13.568 37
I6185 6185 0 1.26158e-05
R6892 6185 6186 1.6 0.8 12.8 37
I6186 6186 0 1.34816e-05
R6893 6186 6187 1.648 0.8 13.184 37
I6187 6187 0 1.34816e-05
R6894 6187 6188 1.616 0.8 12.928 37
I6188 6188 0 1.34816e-05
R6895 6188 6189 1.616 0.8 12.928 37
I6189 6189 0 1.34816e-05
R6896 6189 6190 1.6 0.8 12.8 37
I6190 6190 0 1.27395e-05
R6897 6190 6191 1.664 0.8 13.312 37
I6191 6191 0 1.31105e-05
R6898 6191 6192 1.728 0.8 13.824 37
I6192 6192 0 1.31105e-05
R6899 6192 6193 1.664 0.8 13.312 37
I6193 6193 0 1.26158e-05
R6900 6193 6194 1.632 0.8 13.056 37
I6194 6194 0 1.26158e-05
R6901 6194 6195 1.696 0.8 13.568 37
I6195 6195 0 1.23684e-05
R6902 6195 6196 1.712 0.8 13.696 37
I6196 6196 0 1.28631e-05
R6903 6196 6197 1.68 0.8 13.44 37
I6197 6197 0 1.23684e-05
R6904 6197 6198 1.616 0.8 12.928 37
I6198 6198 0 1.28631e-05
R6905 6198 6199 1.616 0.8 12.928 37
I6199 6199 0 1.26158e-05
R6906 6199 6200 1.744 0.8 13.952 37
I6200 6200 0 1.34816e-05
R6907 6200 6201 1.696 0.8 13.568 37
I6201 6201 0 1.34816e-05
R6908 6201 6202 1.728 0.8 13.824 37
I6202 6202 0 1.34816e-05
R6909 6202 6203 1.616 0.8 12.928 37
I6203 6203 0 1.23684e-05
R6910 6203 6204 1.616 0.8 12.928 37
I6204 6204 0 1.26158e-05
R6911 6204 6205 1.616 0.8 12.928 37
I6205 6205 0 1.27395e-05
R6912 6205 6206 1.712 0.8 13.696 37
I6206 6206 0 1.31105e-05
R6913 6206 6207 1.744 0.8 13.952 37
I6207 6207 0 1.33579e-05
R6914 6207 6208 1.632 0.8 13.056 37
I6208 6208 0 1.29868e-05
R6915 6208 6209 1.6 0.8 12.8 37
I6209 6209 0 1.32342e-05
R6916 6209 6210 1.712 0.8 13.696 37
I6210 6210 0 1.32342e-05
R6917 6210 6211 1.712 0.8 13.696 37
I6211 6211 0 1.31105e-05
R6918 6211 6212 1.616 0.8 12.928 37
I6212 6212 0 1.28631e-05
R6919 6212 6213 1.696 0.8 13.568 37
I6213 6213 0 1.27395e-05
R6920 6213 6214 1.616 0.8 12.928 37
I6214 6214 0 1.34816e-05
R6921 6214 6215 1.712 0.8 13.696 37
I6215 6215 0 1.23684e-05
R6922 6215 6216 1.728 0.8 13.824 37
I6216 6216 0 1.27395e-05
R6923 6216 6217 1.632 0.8 13.056 37
I6217 6217 0 1.34816e-05
R6924 6217 6218 1.664 0.8 13.312 37
I6218 6218 0 1.27395e-05
R6925 6218 6219 1.744 0.8 13.952 37
I6219 6219 0 1.32342e-05
R6926 6219 6220 1.712 0.8 13.696 37
I6220 6220 0 1.23684e-05
R6927 6220 6221 1.6 0.8 12.8 37
I6221 6221 0 1.32342e-05
R6928 6221 6222 1.728 0.8 13.824 37
I6222 6222 0 1.24921e-05
R6929 6222 6223 1.68 0.8 13.44 37
I6223 6223 0 1.27395e-05
R6930 6223 6224 1.712 0.8 13.696 37
I6224 6224 0 1.29868e-05
R6931 6224 6225 1.6 0.8 12.8 37
I6225 6225 0 1.31105e-05
R6932 6225 6226 1.632 0.8 13.056 37
I6226 6226 0 1.34816e-05
R6933 6226 6227 1.648 0.8 13.184 37
I6227 6227 0 1.31105e-05
R6934 6227 6228 1.696 0.8 13.568 37
I6228 6228 0 1.24921e-05
R6935 6228 6229 1.616 0.8 12.928 37
I6229 6229 0 1.32342e-05
R6936 6229 6230 1.616 0.8 12.928 37
I6230 6230 0 1.33579e-05
R6937 6230 6231 1.744 0.8 13.952 37
I6231 6231 0 1.24921e-05
R6938 6231 6232 1.616 0.8 12.928 37
I6232 6232 0 1.24921e-05
R6939 6232 6233 1.6 0.8 12.8 37
I6233 6233 0 1.32342e-05
R6940 6233 6234 1.696 0.8 13.568 37
I6234 6234 0 1.24921e-05
R6941 6234 6235 1.68 0.8 13.44 37
I6235 6235 0 1.31105e-05
R6942 6235 6236 1.664 0.8 13.312 37
I6236 6236 0 1.32342e-05
R6943 6236 6237 1.648 0.8 13.184 37
I6237 6237 0 1.26158e-05
R6944 6237 6238 1.744 0.8 13.952 37
I6238 6238 0 1.33579e-05
R6945 6238 6239 1.68 0.8 13.44 37
I6239 6239 0 1.33579e-05
R6946 6239 6240 1.648 0.8 13.184 37
I6240 6240 0 1.32342e-05
R6947 6240 6241 1.696 0.8 13.568 37
I6241 6241 0 1.33579e-05
R6948 6241 6242 1.712 0.8 13.696 37
I6242 6242 0 1.34816e-05
R6949 6242 6243 1.664 0.8 13.312 37
I6243 6243 0 1.27395e-05
R6950 6243 6244 1.648 0.8 13.184 37
I6244 6244 0 1.29868e-05
R6951 6244 6245 1.6 0.8 12.8 37
I6245 6245 0 1.31105e-05
R6952 6245 6246 1.68 0.8 13.44 37
I6246 6246 0 1.34816e-05
R6953 6246 6247 1.712 0.8 13.696 37
I6247 6247 0 1.33579e-05
R6954 6247 6248 1.648 0.8 13.184 37
I6248 6248 0 1.23684e-05
R6955 6248 6249 1.68 0.8 13.44 37
I6249 6249 0 1.24921e-05
R6956 6249 6250 1.648 0.8 13.184 37
I6250 6250 0 1.23684e-05
R6957 6250 6251 1.712 0.8 13.696 37
I6251 6251 0 1.32342e-05
R6958 6251 6252 1.6 0.8 12.8 37
I6252 6252 0 1.23684e-05
R6959 6252 6253 1.6 0.8 12.8 37
I6253 6253 0 1.34816e-05
R6960 6253 6254 1.728 0.8 13.824 37
I6254 6254 0 1.32342e-05
R6961 6254 6255 1.712 0.8 13.696 37
I6255 6255 0 1.28631e-05
R6962 6255 6256 1.68 0.8 13.44 37
I6256 6256 0 1.27395e-05
R6963 6256 6257 1.632 0.8 13.056 37
I6257 6257 0 1.26158e-05
R6964 6257 6258 1.68 0.8 13.44 37
I6258 6258 0 1.33579e-05
R6965 6258 6259 1.712 0.8 13.696 37
I6259 6259 0 1.23684e-05
R6966 6259 6260 1.68 0.8 13.44 37
I6260 6260 0 1.34816e-05
R6967 6260 6261 1.696 0.8 13.568 37
I6261 6261 0 1.23684e-05
R6968 6261 6262 1.6 0.8 12.8 37
I6262 6262 0 1.29868e-05
R6969 6262 6263 1.728 0.8 13.824 37
I6263 6263 0 1.29868e-05
R6970 6263 6264 1.712 0.8 13.696 37
I6264 6264 0 1.29868e-05
R6971 6264 6265 1.712 0.8 13.696 37
I6265 6265 0 1.24921e-05
R6972 6265 6266 1.728 0.8 13.824 37
I6266 6266 0 1.28631e-05
R6973 6266 6267 1.728 0.8 13.824 37
I6267 6267 0 1.33579e-05
R6974 6267 6268 1.68 0.8 13.44 37
I6268 6268 0 1.23684e-05
R6975 6268 6269 1.744 0.8 13.952 37
I6269 6269 0 1.29868e-05
R6976 6269 6270 1.728 0.8 13.824 37
I6270 6270 0 1.33579e-05
R6977 6270 6271 1.744 0.8 13.952 37
I6271 6271 0 1.27395e-05
R6978 6271 6272 1.648 0.8 13.184 37
I6272 6272 0 1.27395e-05
R6979 6272 6273 1.712 0.8 13.696 37
I6273 6273 0 1.33579e-05
R6980 6273 6274 1.616 0.8 12.928 37
I6274 6274 0 1.31105e-05
R6981 6274 6275 1.728 0.8 13.824 37
I6275 6275 0 1.33579e-05
R6982 6275 6276 1.68 0.8 13.44 37
I6276 6276 0 1.31105e-05
R6983 6276 6277 1.6 0.8 12.8 37
I6277 6277 0 1.32342e-05
R6984 6277 6278 1.632 0.8 13.056 37
I6278 6278 0 1.23684e-05
R6985 6278 6279 1.648 0.8 13.184 37
I6279 6279 0 1.34816e-05
R6986 6279 6280 1.696 0.8 13.568 37
I6280 6280 0 1.23684e-05
R6987 6280 6281 1.632 0.8 13.056 37
I6281 6281 0 1.28631e-05
R6988 6281 6282 1.664 0.8 13.312 37
I6282 6282 0 1.24921e-05
R6989 6282 6283 1.664 0.8 13.312 37
I6283 6283 0 1.24921e-05
R6990 6283 6284 1.648 0.8 13.184 37
I6284 6284 0 1.27395e-05
R6991 6284 6285 1.712 0.8 13.696 37
I6285 6285 0 1.24921e-05
R6992 6285 6286 1.616 0.8 12.928 37
I6286 6286 0 1.33579e-05
R6993 6286 6287 1.696 0.8 13.568 37
I6287 6287 0 1.28631e-05
R6994 6287 6288 1.632 0.8 13.056 37
I6288 6288 0 1.29868e-05
R6995 6288 6289 1.68 0.8 13.44 37
I6289 6289 0 1.29868e-05
R6996 6289 6290 1.616 0.8 12.928 37
I6290 6290 0 1.29868e-05
R6997 6290 6291 1.696 0.8 13.568 37
I6291 6291 0 1.33579e-05
R6998 6291 6292 1.632 0.8 13.056 37
I6292 6292 0 1.31105e-05
R6999 6292 6293 1.696 0.8 13.568 37
I6293 6293 0 1.31105e-05
R7000 6293 6294 1.712 0.8 13.696 37
I6294 6294 0 1.34816e-05
R7001 6294 6295 1.712 0.8 13.696 37
I6295 6295 0 1.27395e-05
R7002 6295 6296 1.744 0.8 13.952 37
I6296 6296 0 1.23684e-05
R7003 6296 6297 1.744 0.8 13.952 37
I6297 6297 0 1.29868e-05
R7004 6297 6298 1.648 0.8 13.184 37
I6298 6298 0 1.29868e-05
R7005 6298 6299 1.744 0.8 13.952 37
I6299 6299 0 1.31105e-05
R7006 6299 6300 1.728 0.8 13.824 37
I6300 6300 0 1.33579e-05
R7007 6300 6301 1.6 0.8 12.8 37
I6301 6301 0 1.24921e-05
R7008 6301 6302 1.696 0.8 13.568 37
I6302 6302 0 1.33579e-05
R7009 6302 6303 1.68 0.8 13.44 37
I6303 6303 0 1.23684e-05
R7010 6303 6304 1.696 0.8 13.568 37
I6304 6304 0 1.26158e-05
R7011 6304 6305 1.728 0.8 13.824 37
I6305 6305 0 1.34816e-05
R7012 6305 6306 1.728 0.8 13.824 37
I6306 6306 0 1.28631e-05
R7013 6306 6307 1.728 0.8 13.824 37
I6307 6307 0 1.26158e-05
R7014 6307 6308 1.6 0.8 12.8 37
I6308 6308 0 1.28631e-05
R7015 6308 6309 1.6 0.8 12.8 37
I6309 6309 0 1.32342e-05
R7016 6309 6310 1.68 0.8 13.44 37
I6310 6310 0 1.32342e-05
R7017 6310 6311 1.632 0.8 13.056 37
I6311 6311 0 1.31105e-05
R7018 6311 6312 1.744 0.8 13.952 37
I6312 6312 0 1.27395e-05
R7019 6312 6313 1.648 0.8 13.184 37
I6313 6313 0 1.26158e-05
R7020 6313 6314 1.728 0.8 13.824 37
I6314 6314 0 1.26158e-05
R7021 6314 6315 1.616 0.8 12.928 37
I6315 6315 0 1.31105e-05
R7022 6315 6316 1.6 0.8 12.8 37
I6316 6316 0 1.24921e-05
R7023 6316 6317 1.744 0.8 13.952 37
I6317 6317 0 1.34816e-05
R7024 6317 6318 1.616 0.8 12.928 37
I6318 6318 0 1.32342e-05
R7025 6318 6319 1.744 0.8 13.952 37
I6319 6319 0 1.32342e-05
R7026 6319 6320 1.744 0.8 13.952 37
I6320 6320 0 1.32342e-05
R7027 6320 6321 1.712 0.8 13.696 37
I6321 6321 0 1.34816e-05
R7028 6321 6322 1.648 0.8 13.184 37
I6322 6322 0 1.29868e-05
R7029 6322 6323 1.648 0.8 13.184 37
I6323 6323 0 1.28631e-05
R7030 6323 6324 1.616 0.8 12.928 37
I6324 6324 0 1.27395e-05
R7031 6324 6325 1.648 0.8 13.184 37
I6325 6325 0 1.33579e-05
R7032 6325 6326 1.648 0.8 13.184 37
I6326 6326 0 1.31105e-05
R7033 6326 6327 1.696 0.8 13.568 37
I6327 6327 0 1.28631e-05
R7034 6327 6328 1.744 0.8 13.952 37
I6328 6328 0 1.34816e-05
R7035 6328 6329 1.744 0.8 13.952 37
I6329 6329 0 1.23684e-05
R7036 6329 6330 1.664 0.8 13.312 37
I6330 6330 0 1.23684e-05
R7037 6330 6331 1.728 0.8 13.824 37
I6331 6331 0 1.28631e-05
R7038 6331 6332 1.648 0.8 13.184 37
I6332 6332 0 1.33579e-05
R7039 6332 6333 1.68 0.8 13.44 37
I6333 6333 0 1.28631e-05
R7040 6333 6334 1.68 0.8 13.44 37
I6334 6334 0 1.29868e-05
R7041 6334 6335 1.664 0.8 13.312 37
I6335 6335 0 1.31105e-05
R7042 6335 6336 1.664 0.8 13.312 37
I6336 6336 0 1.24921e-05
R7043 6336 6337 1.696 0.8 13.568 37
I6337 6337 0 1.33579e-05
R7044 6337 6338 1.728 0.8 13.824 37
I6338 6338 0 1.24921e-05
R7045 6338 6339 1.664 0.8 13.312 37
I6339 6339 0 1.24921e-05
R7046 6339 6340 1.712 0.8 13.696 37
I6340 6340 0 1.32342e-05
R7047 6340 6341 1.616 0.8 12.928 37
I6341 6341 0 1.26158e-05
R7048 6341 6342 1.68 0.8 13.44 37
I6342 6342 0 1.32342e-05
R7049 6342 6343 1.696 0.8 13.568 37
I6343 6343 0 1.32342e-05
R7050 6343 6344 1.696 0.8 13.568 37
I6344 6344 0 1.29868e-05
R7051 6344 6345 1.712 0.8 13.696 37
I6345 6345 0 1.23684e-05
R7052 6345 6346 1.68 0.8 13.44 37
I6346 6346 0 1.32342e-05
R7053 6346 6347 1.712 0.8 13.696 37
I6347 6347 0 1.33579e-05
R7054 6347 6348 1.68 0.8 13.44 37
I6348 6348 0 1.26158e-05
R7055 6348 6349 1.68 0.8 13.44 37
I6349 6349 0 1.26158e-05
R7056 6349 6350 1.744 0.8 13.952 37
I6350 6350 0 1.34816e-05
R7057 6350 6351 1.744 0.8 13.952 37
I6351 6351 0 1.31105e-05
R7058 6351 6352 1.632 0.8 13.056 37
I6352 6352 0 1.32342e-05
R7059 6352 6353 1.696 0.8 13.568 37
I6353 6353 0 1.23684e-05
R7060 6353 6354 1.728 0.8 13.824 37
I6354 6354 0 1.23684e-05
R7061 6354 6355 1.648 0.8 13.184 37
I6355 6355 0 1.29868e-05
R7062 6355 6356 1.744 0.8 13.952 37
I6356 6356 0 1.28631e-05
R7063 6356 6357 1.712 0.8 13.696 37
I6357 6357 0 1.32342e-05
R7064 6357 6358 1.616 0.8 12.928 37
I6358 6358 0 1.31105e-05
R7065 6358 6359 1.664 0.8 13.312 37
I6359 6359 0 1.34816e-05
R7066 6359 6360 1.616 0.8 12.928 37
I6360 6360 0 1.27395e-05
R7067 6360 6361 1.632 0.8 13.056 37
I6361 6361 0 1.34816e-05
R7068 6361 6362 1.6 0.8 12.8 37
I6362 6362 0 1.34816e-05
R7069 6362 6363 1.712 0.8 13.696 37
I6363 6363 0 1.33579e-05
R7070 6363 6364 1.648 0.8 13.184 37
I6364 6364 0 1.28631e-05
R7071 6364 6365 1.6 0.8 12.8 37
I6365 6365 0 1.29868e-05
R7072 6365 6366 1.648 0.8 13.184 37
I6366 6366 0 1.34816e-05
R7073 6366 6367 1.616 0.8 12.928 37
I6367 6367 0 1.29868e-05
R7074 6367 6368 1.728 0.8 13.824 37
I6368 6368 0 1.32342e-05
R7075 6368 6369 1.712 0.8 13.696 37
I6369 6369 0 1.32342e-05
R7076 6369 6370 1.744 0.8 13.952 37
I6370 6370 0 1.23684e-05
R7077 6370 6371 1.664 0.8 13.312 37
I6371 6371 0 1.33579e-05
R7078 6371 6372 1.664 0.8 13.312 37
I6372 6372 0 1.28631e-05
R7079 6372 6373 1.68 0.8 13.44 37
I6373 6373 0 1.32342e-05
R7080 6373 6374 1.6 0.8 12.8 37
I6374 6374 0 1.24921e-05
R7081 6374 6375 1.712 0.8 13.696 37
I6375 6375 0 1.27395e-05
R7082 6375 6376 1.696 0.8 13.568 37
I6376 6376 0 1.34816e-05
R7083 6376 6377 1.632 0.8 13.056 37
I6377 6377 0 1.34816e-05
R7084 6377 6378 1.6 0.8 12.8 37
I6378 6378 0 1.26158e-05
R7085 6378 6379 1.712 0.8 13.696 37
I6379 6379 0 1.29868e-05
R7086 6379 6380 1.696 0.8 13.568 37
I6380 6380 0 1.34816e-05
R7087 6380 6381 1.6 0.8 12.8 37
I6381 6381 0 1.26158e-05
R7088 6381 6382 1.616 0.8 12.928 37
I6382 6382 0 1.27395e-05
R7089 6382 6383 1.744 0.8 13.952 37
I6383 6383 0 1.34816e-05
R7090 6383 6384 1.632 0.8 13.056 37
I6384 6384 0 1.34816e-05
R7091 6384 6385 1.696 0.8 13.568 37
I6385 6385 0 1.24921e-05
R7092 6385 6386 1.744 0.8 13.952 37
I6386 6386 0 1.27395e-05
R7093 6386 6387 1.6 0.8 12.8 37
I6387 6387 0 1.31105e-05
R7094 6387 6388 1.712 0.8 13.696 37
I6388 6388 0 1.32342e-05
R7095 6388 6389 1.68 0.8 13.44 37
I6389 6389 0 1.34816e-05
R7096 6389 6390 1.616 0.8 12.928 37
I6390 6390 0 1.26158e-05
R7097 6390 6391 1.632 0.8 13.056 37
I6391 6391 0 1.32342e-05
R7098 6391 6392 1.648 0.8 13.184 37
I6392 6392 0 1.32342e-05
R7099 6392 6393 1.696 0.8 13.568 37
I6393 6393 0 1.29868e-05
R7100 6393 6394 1.744 0.8 13.952 37
I6394 6394 0 1.29868e-05
R7101 6394 6395 1.616 0.8 12.928 37
I6395 6395 0 1.32342e-05
R7102 6395 6396 1.68 0.8 13.44 37
I6396 6396 0 1.27395e-05
R7103 6396 6397 1.616 0.8 12.928 37
I6397 6397 0 1.33579e-05
R7104 6397 6398 1.712 0.8 13.696 37
I6398 6398 0 1.24921e-05
R7105 6398 6399 1.712 0.8 13.696 37
I6399 6399 0 1.24921e-05
R7106 6399 6400 1.632 0.8 13.056 37
I6400 6400 0 1.31105e-05
R7107 6400 6401 1.648 0.8 13.184 37
I6401 6401 0 1.24921e-05
R7108 6401 6402 1.744 0.8 13.952 37
I6402 6402 0 1.29868e-05
R7109 6402 6403 1.744 0.8 13.952 37
I6403 6403 0 1.33579e-05
R7110 6403 6404 1.632 0.8 13.056 37
I6404 6404 0 1.32342e-05
R7111 6404 6405 1.744 0.8 13.952 37
I6405 6405 0 1.29868e-05
R7112 6405 6406 1.616 0.8 12.928 37
I6406 6406 0 1.27395e-05
R7113 6406 6407 1.648 0.8 13.184 37
I6407 6407 0 1.29868e-05
R7114 6407 6408 1.6 0.8 12.8 37
I6408 6408 0 1.24921e-05
R7115 6408 6409 1.632 0.8 13.056 37
I6409 6409 0 1.24921e-05
R7116 6409 6410 1.744 0.8 13.952 37
I6410 6410 0 1.29868e-05
R7117 6410 6411 1.744 0.8 13.952 37
I6411 6411 0 1.31105e-05
R7118 6411 6412 1.744 0.8 13.952 37
I6412 6412 0 1.23684e-05
R7119 6412 6413 1.664 0.8 13.312 37
I6413 6413 0 1.33579e-05
R7120 6413 6414 1.648 0.8 13.184 37
I6414 6414 0 1.24921e-05
R7121 6414 6415 1.744 0.8 13.952 37
I6415 6415 0 1.29868e-05
R7122 6415 6416 1.712 0.8 13.696 37
I6416 6416 0 1.28631e-05
R7123 6416 6417 1.744 0.8 13.952 37
I6417 6417 0 1.33579e-05
R7124 6417 6418 1.744 0.8 13.952 37
I6418 6418 0 1.23684e-05
R7125 6418 6419 1.728 0.8 13.824 37
I6419 6419 0 1.28631e-05
R7126 6419 6420 1.712 0.8 13.696 37
I6420 6420 0 1.32342e-05
R7127 6420 6421 1.744 0.8 13.952 37
I6421 6421 0 1.34816e-05
R7128 6421 6422 1.616 0.8 12.928 37
I6422 6422 0 1.28631e-05
R7129 6422 6423 1.696 0.8 13.568 37
I6423 6423 0 1.27395e-05
R7130 6423 6424 1.696 0.8 13.568 37
I6424 6424 0 1.33579e-05
R7131 6424 6425 1.68 0.8 13.44 37
I6425 6425 0 1.32342e-05
R7132 6425 6426 1.664 0.8 13.312 37
I6426 6426 0 1.28631e-05
R7133 6426 6427 1.648 0.8 13.184 37
I6427 6427 0 1.29868e-05
R7134 6427 6428 1.696 0.8 13.568 37
I6428 6428 0 1.34816e-05
R7135 6428 6429 1.648 0.8 13.184 37
I6429 6429 0 1.26158e-05
R7136 6429 6430 1.632 0.8 13.056 37
I6430 6430 0 1.28631e-05
R7137 6430 6431 1.712 0.8 13.696 37
I6431 6431 0 1.23684e-05
R7138 6431 6432 1.744 0.8 13.952 37
I6432 6432 0 1.33579e-05
R7139 6432 6433 1.6 0.8 12.8 37
I6433 6433 0 1.23684e-05
R7140 6433 6434 1.744 0.8 13.952 37
I6434 6434 0 1.34816e-05
R7141 6434 6435 1.664 0.8 13.312 37
I6435 6435 0 1.33579e-05
R7142 6435 6436 1.696 0.8 13.568 37
I6436 6436 0 1.28631e-05
R7143 6436 6437 1.712 0.8 13.696 37
I6437 6437 0 1.34816e-05
R7144 6437 6438 1.728 0.8 13.824 37
I6438 6438 0 1.27395e-05
R7145 6438 6439 1.648 0.8 13.184 37
I6439 6439 0 1.31105e-05
R7146 6439 6440 1.664 0.8 13.312 37
I6440 6440 0 1.33579e-05
R7147 6440 6441 1.648 0.8 13.184 37
I6441 6441 0 1.33579e-05
R7148 6441 6442 1.664 0.8 13.312 37
I6442 6442 0 1.33579e-05
R7149 6442 6443 1.648 0.8 13.184 37
I6443 6443 0 1.23684e-05
R7150 6443 6444 1.712 0.8 13.696 37
I6444 6444 0 1.33579e-05
R7151 6444 6445 1.632 0.8 13.056 37
I6445 6445 0 1.23684e-05
R7152 6445 6446 1.664 0.8 13.312 37
I6446 6446 0 1.26158e-05
R7153 6446 6447 1.632 0.8 13.056 37
I6447 6447 0 1.29868e-05
R7154 6447 6448 1.6 0.8 12.8 37
I6448 6448 0 1.28631e-05
R7155 6448 6449 1.696 0.8 13.568 37
I6449 6449 0 1.24921e-05
R7156 6449 6450 1.648 0.8 13.184 37
I6450 6450 0 1.23684e-05
R7157 6450 6451 1.6 0.8 12.8 37
I6451 6451 0 1.26158e-05
R7158 6451 6452 1.696 0.8 13.568 37
I6452 6452 0 1.32342e-05
R7159 6452 6453 1.616 0.8 12.928 37
I6453 6453 0 1.29868e-05
R7160 6453 6454 1.648 0.8 13.184 37
I6454 6454 0 1.28631e-05
R7161 6454 6455 1.648 0.8 13.184 37
I6455 6455 0 1.32342e-05
R7162 6455 6456 1.632 0.8 13.056 37
I6456 6456 0 1.32342e-05
R7163 6456 6457 1.712 0.8 13.696 37
I6457 6457 0 1.33579e-05
R7164 6457 6458 1.712 0.8 13.696 37
I6458 6458 0 1.26158e-05
R7165 6458 6459 1.744 0.8 13.952 37
I6459 6459 0 1.32342e-05
R7166 6459 6460 1.632 0.8 13.056 37
I6460 6460 0 1.27395e-05
R7167 6460 6461 1.744 0.8 13.952 37
I6461 6461 0 1.31105e-05
R7168 6461 6462 1.712 0.8 13.696 37
I6462 6462 0 1.24921e-05
R7169 6462 6463 1.664 0.8 13.312 37
I6463 6463 0 1.23684e-05
R7170 6463 6464 1.68 0.8 13.44 37
I6464 6464 0 1.23684e-05
R7171 6464 6465 1.616 0.8 12.928 37
I6465 6465 0 1.24921e-05
R7172 6465 6466 1.6 0.8 12.8 37
I6466 6466 0 1.27395e-05
R7173 6466 6467 1.648 0.8 13.184 37
I6467 6467 0 1.32342e-05
R7174 6467 6468 1.648 0.8 13.184 37
I6468 6468 0 1.28631e-05
R7175 6468 6469 1.664 0.8 13.312 37
I6469 6469 0 1.33579e-05
R7176 6469 6470 1.616 0.8 12.928 37
I6470 6470 0 1.32342e-05
R7177 6470 6471 1.712 0.8 13.696 37
I6471 6471 0 1.29868e-05
R7178 6471 6472 1.696 0.8 13.568 37
I6472 6472 0 1.28631e-05
R7179 6472 6473 1.664 0.8 13.312 37
I6473 6473 0 1.28631e-05
R7180 6473 6474 1.728 0.8 13.824 37
I6474 6474 0 1.29868e-05
R7181 6474 6475 1.616 0.8 12.928 37
I6475 6475 0 1.23684e-05
R7182 6475 6476 1.6 0.8 12.8 37
I6476 6476 0 1.26158e-05
R7183 6476 6477 1.728 0.8 13.824 37
I6477 6477 0 1.33579e-05
R7184 6477 6478 1.648 0.8 13.184 37
I6478 6478 0 1.26158e-05
R7185 6478 6479 1.6 0.8 12.8 37
I6479 6479 0 1.23684e-05
R7186 6479 6480 1.664 0.8 13.312 37
I6480 6480 0 1.27395e-05
R7187 6480 6481 1.648 0.8 13.184 37
I6481 6481 0 1.29868e-05
R7188 6481 6482 1.712 0.8 13.696 37
I6482 6482 0 1.31105e-05
R7189 6482 6483 1.664 0.8 13.312 37
I6483 6483 0 1.23684e-05
R7190 6483 6484 1.648 0.8 13.184 37
I6484 6484 0 1.33579e-05
R7191 6484 6485 1.728 0.8 13.824 37
I6485 6485 0 1.31105e-05
R7192 6485 6486 1.712 0.8 13.696 37
I6486 6486 0 1.29868e-05
R7193 6486 6487 1.616 0.8 12.928 37
I6487 6487 0 1.28631e-05
R7194 6487 6488 1.616 0.8 12.928 37
I6488 6488 0 1.29868e-05
R7195 6488 6489 1.6 0.8 12.8 37
I6489 6489 0 1.34816e-05
R7196 6489 6490 1.632 0.8 13.056 37
I6490 6490 0 1.27395e-05
R7197 6490 6491 1.616 0.8 12.928 37
I6491 6491 0 1.27395e-05
R7198 6491 6492 1.68 0.8 13.44 37
I6492 6492 0 1.24921e-05
R7199 6492 6493 1.648 0.8 13.184 37
I6493 6493 0 1.23684e-05
R7200 6493 6494 1.696 0.8 13.568 37
I6494 6494 0 1.27395e-05
R7201 6494 6495 1.632 0.8 13.056 37
I6495 6495 0 1.26158e-05
R7202 6495 6496 1.696 0.8 13.568 37
I6496 6496 0 1.31105e-05
R7203 6496 6497 1.744 0.8 13.952 37
I6497 6497 0 1.27395e-05
R7204 6497 6498 1.664 0.8 13.312 37
I6498 6498 0 1.27395e-05
R7205 6498 6499 1.68 0.8 13.44 37
I6499 6499 0 1.34816e-05
R7206 6499 6500 1.648 0.8 13.184 37
I6500 6500 0 1.29868e-05
R7207 6500 6501 1.68 0.8 13.44 37
I6501 6501 0 1.27395e-05
R7208 6501 6502 1.632 0.8 13.056 37
I6502 6502 0 1.32342e-05
R7209 6502 6503 1.712 0.8 13.696 37
I6503 6503 0 1.27395e-05
R7210 6503 6504 1.664 0.8 13.312 37
I6504 6504 0 1.34816e-05
R7211 6504 6505 1.664 0.8 13.312 37
I6505 6505 0 1.32342e-05
R7212 6505 6506 1.632 0.8 13.056 37
I6506 6506 0 1.32342e-05
R7213 6506 6507 1.6 0.8 12.8 37
I6507 6507 0 1.34816e-05
R7214 6507 6508 1.616 0.8 12.928 37
I6508 6508 0 1.27395e-05
R7215 6508 6509 1.744 0.8 13.952 37
I6509 6509 0 1.34816e-05
R7216 6509 6510 1.696 0.8 13.568 37
I6510 6510 0 1.24921e-05
R7217 6510 6511 1.616 0.8 12.928 37
I6511 6511 0 1.28631e-05
R7218 6511 6512 1.744 0.8 13.952 37
I6512 6512 0 1.24921e-05
R7219 6512 6513 1.728 0.8 13.824 37
I6513 6513 0 1.28631e-05
R7220 6513 6514 1.664 0.8 13.312 37
I6514 6514 0 1.29868e-05
R7221 6514 6515 1.68 0.8 13.44 37
I6515 6515 0 1.23684e-05
R7222 6515 6516 1.616 0.8 12.928 37
I6516 6516 0 1.24921e-05
R7223 6516 6517 1.648 0.8 13.184 37
I6517 6517 0 1.27395e-05
R7224 6517 6518 1.728 0.8 13.824 37
I6518 6518 0 1.26158e-05
R7225 6518 6519 1.744 0.8 13.952 37
I6519 6519 0 1.26158e-05
R7226 6519 6520 1.616 0.8 12.928 37
I6520 6520 0 1.29868e-05
R7227 6520 6521 1.616 0.8 12.928 37
I6521 6521 0 1.29868e-05
R7228 6521 6522 1.648 0.8 13.184 37
I6522 6522 0 1.24921e-05
R7229 6522 6523 1.664 0.8 13.312 37
I6523 6523 0 1.31105e-05
R7230 6523 6524 1.696 0.8 13.568 37
I6524 6524 0 1.29868e-05
R7231 6524 6525 1.68 0.8 13.44 37
I6525 6525 0 1.26158e-05
R7232 6525 6526 1.728 0.8 13.824 37
I6526 6526 0 1.31105e-05
R7233 6526 6527 1.744 0.8 13.952 37
I6527 6527 0 1.23684e-05
R7234 6527 6528 1.712 0.8 13.696 37
I6528 6528 0 1.32342e-05
R7235 6528 6529 1.664 0.8 13.312 37
I6529 6529 0 1.28631e-05
R7236 6529 6530 1.664 0.8 13.312 37
I6530 6530 0 1.24921e-05
R7237 6530 6531 1.696 0.8 13.568 37
I6531 6531 0 1.29868e-05
R7238 6531 6532 1.632 0.8 13.056 37
I6532 6532 0 1.34816e-05
R7239 6532 6533 1.616 0.8 12.928 37
I6533 6533 0 1.26158e-05
R7240 6533 6534 1.648 0.8 13.184 37
I6534 6534 0 1.23684e-05
R7241 6534 6535 1.712 0.8 13.696 37
I6535 6535 0 1.31105e-05
R7242 6535 6536 1.68 0.8 13.44 37
I6536 6536 0 1.33579e-05
R7243 6536 6537 1.616 0.8 12.928 37
I6537 6537 0 1.23684e-05
R7244 6537 6538 1.6 0.8 12.8 37
I6538 6538 0 1.32342e-05
R7245 6538 6539 1.696 0.8 13.568 37
I6539 6539 0 1.33579e-05
R7246 6539 6540 1.664 0.8 13.312 37
I6540 6540 0 1.24921e-05
R7247 6540 6541 1.648 0.8 13.184 37
I6541 6541 0 1.26158e-05
R7248 6541 6542 1.6 0.8 12.8 37
I6542 6542 0 1.26158e-05
R7249 6542 6543 1.632 0.8 13.056 37
I6543 6543 0 1.34816e-05
R7250 6543 6544 1.744 0.8 13.952 37
I6544 6544 0 1.33579e-05
R7251 6544 6545 1.648 0.8 13.184 37
I6545 6545 0 1.27395e-05
R7252 6545 6546 1.6 0.8 12.8 37
I6546 6546 0 1.24921e-05
R7253 6546 6547 1.616 0.8 12.928 37
I6547 6547 0 1.28631e-05
R7254 6547 6548 1.632 0.8 13.056 37
I6548 6548 0 1.26158e-05
R7255 6548 6549 1.712 0.8 13.696 37
I6549 6549 0 1.29868e-05
R7256 6549 6550 1.664 0.8 13.312 37
I6550 6550 0 1.28631e-05
R7257 6550 6551 1.616 0.8 12.928 37
I6551 6551 0 1.34816e-05
R7258 6551 6552 1.632 0.8 13.056 37
I6552 6552 0 1.28631e-05
R7259 6552 6553 1.632 0.8 13.056 37
I6553 6553 0 1.28631e-05
R7260 6553 6554 1.616 0.8 12.928 37
I6554 6554 0 1.33579e-05
R7261 6554 6555 1.648 0.8 13.184 37
I6555 6555 0 1.29868e-05
R7262 6555 6556 1.632 0.8 13.056 37
I6556 6556 0 1.31105e-05
R7263 6556 6557 1.6 0.8 12.8 37
I6557 6557 0 1.26158e-05
R7264 6557 6558 1.728 0.8 13.824 37
I6558 6558 0 1.28631e-05
R7265 6558 6559 1.616 0.8 12.928 37
I6559 6559 0 1.34816e-05
R7266 6559 6560 1.68 0.8 13.44 37
I6560 6560 0 1.32342e-05
R7267 6560 6561 1.664 0.8 13.312 37
I6561 6561 0 1.29868e-05
R7268 6561 6562 1.728 0.8 13.824 37
I6562 6562 0 1.32342e-05
R7269 6562 6563 1.616 0.8 12.928 37
I6563 6563 0 1.24921e-05
R7270 6563 6564 1.744 0.8 13.952 37
I6564 6564 0 1.33579e-05
R7271 6564 6565 1.728 0.8 13.824 37
I6565 6565 0 1.29868e-05
R7272 6565 6566 1.664 0.8 13.312 37
I6566 6566 0 1.23684e-05
R7273 6566 6567 1.712 0.8 13.696 37
I6567 6567 0 1.32342e-05
R7274 6567 6568 1.664 0.8 13.312 37
I6568 6568 0 1.34816e-05
R7275 6568 6569 1.648 0.8 13.184 37
I6569 6569 0 1.33579e-05
R7276 6569 6570 1.744 0.8 13.952 37
I6570 6570 0 1.31105e-05
R7277 6570 6571 1.648 0.8 13.184 37
I6571 6571 0 1.24921e-05
R7278 6571 6572 1.664 0.8 13.312 37
I6572 6572 0 1.29868e-05
R7279 6572 6573 1.648 0.8 13.184 37
I6573 6573 0 1.28631e-05
R7280 6573 6574 1.6 0.8 12.8 37
I6574 6574 0 1.32342e-05
R7281 6574 6575 1.648 0.8 13.184 37
I6575 6575 0 1.29868e-05
R7282 6575 6576 1.664 0.8 13.312 37
I6576 6576 0 1.23684e-05
R7283 6576 6577 1.632 0.8 13.056 37
I6577 6577 0 1.26158e-05
R7284 6577 6578 1.712 0.8 13.696 37
I6578 6578 0 1.27395e-05
R7285 6578 6579 1.68 0.8 13.44 37
I6579 6579 0 1.34816e-05
R7286 6579 6580 1.664 0.8 13.312 37
I6580 6580 0 1.28631e-05
R7287 6580 6581 1.664 0.8 13.312 37
I6581 6581 0 1.33579e-05
R7288 6581 6582 1.696 0.8 13.568 37
I6582 6582 0 1.24921e-05
R7289 6582 6583 1.712 0.8 13.696 37
I6583 6583 0 1.23684e-05
R7290 6583 6584 1.632 0.8 13.056 37
I6584 6584 0 1.24921e-05
R7291 6584 6585 1.728 0.8 13.824 37
I6585 6585 0 1.26158e-05
R7292 6585 6586 1.744 0.8 13.952 37
I6586 6586 0 1.28631e-05
R7293 6586 6587 1.648 0.8 13.184 37
I6587 6587 0 1.31105e-05
R7294 6587 6588 1.744 0.8 13.952 37
I6588 6588 0 1.34816e-05
R7295 6588 6589 1.6 0.8 12.8 37
I6589 6589 0 1.24921e-05
R7296 6589 6590 1.696 0.8 13.568 37
I6590 6590 0 1.31105e-05
R7297 6590 6591 1.696 0.8 13.568 37
I6591 6591 0 1.23684e-05
R7298 6591 6592 1.696 0.8 13.568 37
I6592 6592 0 1.23684e-05
R7299 6592 6593 1.664 0.8 13.312 37
I6593 6593 0 1.29868e-05
R7300 6593 6594 1.696 0.8 13.568 37
I6594 6594 0 1.23684e-05
R7301 6594 6595 1.664 0.8 13.312 37
I6595 6595 0 1.23684e-05
R7302 6595 6596 1.696 0.8 13.568 37
I6596 6596 0 1.24921e-05
R7303 6596 6597 1.728 0.8 13.824 37
I6597 6597 0 1.26158e-05
R7304 6597 6598 1.664 0.8 13.312 37
I6598 6598 0 1.33579e-05
R7305 6598 6599 1.664 0.8 13.312 37
I6599 6599 0 1.32342e-05
R7306 6599 6600 1.744 0.8 13.952 37
I6600 6600 0 1.27395e-05
R7307 6600 6601 1.744 0.8 13.952 37
I6601 6601 0 1.23684e-05
R7308 6601 6602 1.744 0.8 13.952 37
I6602 6602 0 1.26158e-05
R7309 6602 6603 1.696 0.8 13.568 37
I6603 6603 0 1.33579e-05
R7310 6603 6604 1.616 0.8 12.928 37
I6604 6604 0 1.32342e-05
R7311 6604 6605 1.6 0.8 12.8 37
I6605 6605 0 1.34816e-05
R7312 6605 6606 1.68 0.8 13.44 37
I6606 6606 0 1.33579e-05
R7313 6606 6607 1.744 0.8 13.952 37
I6607 6607 0 1.27395e-05
R7314 6607 6608 1.744 0.8 13.952 37
I6608 6608 0 1.28631e-05
R7315 6608 6609 1.728 0.8 13.824 37
I6609 6609 0 1.29868e-05
R7316 6609 6610 1.696 0.8 13.568 37
I6610 6610 0 1.29868e-05
R7317 6610 6611 1.712 0.8 13.696 37
I6611 6611 0 1.28631e-05
R7318 6611 6612 1.696 0.8 13.568 37
I6612 6612 0 1.32342e-05
R7319 6612 6613 1.696 0.8 13.568 37
I6613 6613 0 1.23684e-05
R7320 6613 6614 1.68 0.8 13.44 37
I6614 6614 0 1.23684e-05
R7321 6614 6615 1.712 0.8 13.696 37
I6615 6615 0 1.28631e-05
R7322 6615 6616 1.68 0.8 13.44 37
I6616 6616 0 1.33579e-05
R7323 6616 6617 1.68 0.8 13.44 37
I6617 6617 0 1.28631e-05
R7324 6617 6618 1.648 0.8 13.184 37
I6618 6618 0 1.24921e-05
R7325 6618 6619 1.68 0.8 13.44 37
I6619 6619 0 1.31105e-05
R7326 6619 6620 1.6 0.8 12.8 37
I6620 6620 0 1.29868e-05
R7327 6620 6621 1.696 0.8 13.568 37
I6621 6621 0 1.29868e-05
R7328 6621 6622 1.68 0.8 13.44 37
I6622 6622 0 1.29868e-05
R7329 6622 6623 1.728 0.8 13.824 37
I6623 6623 0 1.31105e-05
R7330 6623 6624 1.616 0.8 12.928 37
I6624 6624 0 1.34816e-05
R7331 6624 6625 1.648 0.8 13.184 37
I6625 6625 0 1.34816e-05
R7332 6625 6626 1.664 0.8 13.312 37
I6626 6626 0 1.23684e-05
R7333 6626 6627 1.648 0.8 13.184 37
I6627 6627 0 1.26158e-05
R7334 6627 6628 1.728 0.8 13.824 37
I6628 6628 0 1.24921e-05
R7335 6628 6629 1.632 0.8 13.056 37
I6629 6629 0 1.27395e-05
R7336 6629 6630 1.632 0.8 13.056 37
I6630 6630 0 1.26158e-05
R7337 6630 6631 1.6 0.8 12.8 37
I6631 6631 0 1.34816e-05
R7338 6631 6632 1.632 0.8 13.056 37
I6632 6632 0 1.32342e-05
R7339 6632 6633 1.664 0.8 13.312 37
I6633 6633 0 1.29868e-05
R7340 6633 6634 1.6 0.8 12.8 37
I6634 6634 0 1.34816e-05
R7341 6634 6635 1.632 0.8 13.056 37
I6635 6635 0 1.24921e-05
R7342 6635 6636 1.696 0.8 13.568 37
I6636 6636 0 1.23684e-05
R7343 6636 6637 1.728 0.8 13.824 37
I6637 6637 0 1.24921e-05
R7344 6637 6638 1.68 0.8 13.44 37
I6638 6638 0 1.34816e-05
R7345 6638 6639 1.6 0.8 12.8 37
I6639 6639 0 1.34816e-05
R7346 6639 6640 1.728 0.8 13.824 37
I6640 6640 0 1.27395e-05
R7347 6640 6641 1.728 0.8 13.824 37
I6641 6641 0 1.28631e-05
R7348 6641 6642 1.664 0.8 13.312 37
I6642 6642 0 1.28631e-05
R7349 6642 6643 1.696 0.8 13.568 37
I6643 6643 0 1.26158e-05
R7350 6643 6644 1.68 0.8 13.44 37
I6644 6644 0 1.23684e-05
R7351 6644 6645 1.712 0.8 13.696 37
I6645 6645 0 1.34816e-05
R7352 6645 6646 1.664 0.8 13.312 37
I6646 6646 0 1.32342e-05
R7353 6646 6647 1.744 0.8 13.952 37
I6647 6647 0 1.32342e-05
R7354 6647 6648 1.696 0.8 13.568 37
I6648 6648 0 1.29868e-05
R7355 6648 6649 1.664 0.8 13.312 37
I6649 6649 0 1.32342e-05
R7356 6649 6650 1.696 0.8 13.568 37
I6650 6650 0 1.33579e-05
R7357 6650 6651 1.728 0.8 13.824 37
I6651 6651 0 1.26158e-05
R7358 6651 6652 1.728 0.8 13.824 37
I6652 6652 0 1.33579e-05
R7359 6652 6653 1.68 0.8 13.44 37
I6653 6653 0 1.31105e-05
R7360 6653 6654 1.712 0.8 13.696 37
I6654 6654 0 1.29868e-05
R7361 6654 6655 1.68 0.8 13.44 37
I6655 6655 0 1.32342e-05
R7362 6655 6656 1.744 0.8 13.952 37
I6656 6656 0 1.29868e-05
R7363 6656 6657 1.648 0.8 13.184 37
I6657 6657 0 1.29868e-05
R7364 6657 6658 1.616 0.8 12.928 37
I6658 6658 0 1.34816e-05
R7365 6658 6659 1.744 0.8 13.952 37
I6659 6659 0 1.32342e-05
R7366 6659 6660 1.632 0.8 13.056 37
I6660 6660 0 1.31105e-05
R7367 6660 6661 1.728 0.8 13.824 37
I6661 6661 0 1.33579e-05
R7368 6661 6662 1.696 0.8 13.568 37
I6662 6662 0 1.34816e-05
R7369 6662 6663 1.712 0.8 13.696 37
I6663 6663 0 1.26158e-05
R7370 6663 6664 1.664 0.8 13.312 37
I6664 6664 0 1.26158e-05
R7371 6664 6665 1.744 0.8 13.952 37
I6665 6665 0 1.23684e-05
R7372 6665 6666 1.632 0.8 13.056 37
I6666 6666 0 1.34816e-05
R7373 6666 6667 1.664 0.8 13.312 37
I6667 6667 0 1.24921e-05
R7374 6667 6668 1.6 0.8 12.8 37
I6668 6668 0 1.26158e-05
R7375 6668 6669 1.744 0.8 13.952 37
I6669 6669 0 1.34816e-05
R7376 6669 6670 1.744 0.8 13.952 37
I6670 6670 0 1.31105e-05
R7377 6670 6671 1.712 0.8 13.696 37
I6671 6671 0 1.23684e-05
R7378 6671 6672 1.616 0.8 12.928 37
I6672 6672 0 1.23684e-05
R7379 6672 6673 1.68 0.8 13.44 37
I6673 6673 0 1.27395e-05
R7380 6673 6674 1.632 0.8 13.056 37
I6674 6674 0 1.28631e-05
R7381 6674 6675 1.632 0.8 13.056 37
I6675 6675 0 1.31105e-05
R7382 6675 6676 1.648 0.8 13.184 37
I6676 6676 0 1.23684e-05
R7383 6676 6677 1.664 0.8 13.312 37
I6677 6677 0 1.34816e-05
R7384 6677 6678 1.6 0.8 12.8 37
I6678 6678 0 1.26158e-05
R7385 6678 6679 1.648 0.8 13.184 37
I6679 6679 0 1.31105e-05
R7386 6679 6680 1.696 0.8 13.568 37
I6680 6680 0 1.27395e-05
R7387 6680 6681 1.744 0.8 13.952 37
I6681 6681 0 1.33579e-05
R7388 6681 6682 1.664 0.8 13.312 37
I6682 6682 0 1.29868e-05
R7389 6682 6683 1.616 0.8 12.928 37
I6683 6683 0 1.28631e-05
R7390 6683 6684 1.744 0.8 13.952 37
I6684 6684 0 1.23684e-05
R7391 6684 6685 1.664 0.8 13.312 37
I6685 6685 0 1.34816e-05
R7392 6685 6686 1.696 0.8 13.568 37
I6686 6686 0 1.27395e-05
R7393 6686 6687 1.616 0.8 12.928 37
I6687 6687 0 1.23684e-05
R7394 6687 6688 1.648 0.8 13.184 37
I6688 6688 0 1.32342e-05
R7395 6688 6689 1.68 0.8 13.44 37
I6689 6689 0 1.32342e-05
R7396 6689 6690 1.648 0.8 13.184 37
I6690 6690 0 1.32342e-05
R7397 6690 6691 1.68 0.8 13.44 37
I6691 6691 0 1.31105e-05
R7398 6691 6692 1.744 0.8 13.952 37
I6692 6692 0 1.23684e-05
R7399 6692 6693 1.712 0.8 13.696 37
I6693 6693 0 1.24921e-05
R7400 6693 6694 1.664 0.8 13.312 37
I6694 6694 0 1.24921e-05
R7401 6694 6695 1.6 0.8 12.8 37
I6695 6695 0 1.23684e-05
R7402 6695 6696 1.696 0.8 13.568 37
I6696 6696 0 1.34816e-05
R7403 6696 6697 1.728 0.8 13.824 37
I6697 6697 0 1.23684e-05
R7404 6697 6698 1.664 0.8 13.312 37
I6698 6698 0 1.23684e-05
R7405 6698 6699 1.68 0.8 13.44 37
I6699 6699 0 1.28631e-05
R7406 6699 6700 1.632 0.8 13.056 37
I6700 6700 0 1.24921e-05
R7407 6700 6701 1.68 0.8 13.44 37
I6701 6701 0 1.34816e-05
R7408 6701 6702 1.664 0.8 13.312 37
I6702 6702 0 1.31105e-05
R7409 6702 6703 1.616 0.8 12.928 37
I6703 6703 0 1.34816e-05
R7410 6703 6704 1.68 0.8 13.44 37
I6704 6704 0 1.31105e-05
R7411 6704 6705 1.712 0.8 13.696 37
I6705 6705 0 1.34816e-05
R7412 6705 6706 1.68 0.8 13.44 37
I6706 6706 0 1.26158e-05
R7413 6706 6707 1.712 0.8 13.696 37
I6707 6707 0 1.31105e-05
R7414 6707 6708 1.664 0.8 13.312 37
I6708 6708 0 1.32342e-05
R7415 6708 6709 1.728 0.8 13.824 37
I6709 6709 0 1.33579e-05
R7416 6709 6710 1.728 0.8 13.824 37
I6710 6710 0 1.33579e-05
R7417 6710 6711 1.728 0.8 13.824 37
I6711 6711 0 1.31105e-05
R7418 6711 6712 1.744 0.8 13.952 37
I6712 6712 0 1.34816e-05
R7419 6712 6713 1.696 0.8 13.568 37
I6713 6713 0 1.29868e-05
R7420 6713 6714 1.616 0.8 12.928 37
I6714 6714 0 1.27395e-05
R7421 6714 6715 1.616 0.8 12.928 37
I6715 6715 0 1.27395e-05
R7422 6715 6716 1.664 0.8 13.312 37
I6716 6716 0 1.31105e-05
R7423 6716 6717 1.664 0.8 13.312 37
I6717 6717 0 1.23684e-05
R7424 6717 6718 1.68 0.8 13.44 37
I6718 6718 0 1.29868e-05
R7425 6718 6719 1.6 0.8 12.8 37
I6719 6719 0 1.23684e-05
R7426 6719 6720 1.616 0.8 12.928 37
I6720 6720 0 1.34816e-05
R7427 6720 6721 1.616 0.8 12.928 37
I6721 6721 0 1.33579e-05
R7428 6721 6722 1.648 0.8 13.184 37
I6722 6722 0 1.34816e-05
R7429 6722 6723 1.68 0.8 13.44 37
I6723 6723 0 1.33579e-05
R7430 6723 6724 1.696 0.8 13.568 37
I6724 6724 0 1.27395e-05
R7431 6724 6725 1.696 0.8 13.568 37
I6725 6725 0 1.31105e-05
R7432 6725 6726 1.648 0.8 13.184 37
I6726 6726 0 1.32342e-05
R7433 6726 6727 1.632 0.8 13.056 37
I6727 6727 0 1.28631e-05
R7434 6727 6728 1.696 0.8 13.568 37
I6728 6728 0 1.23684e-05
R7435 6728 6729 1.744 0.8 13.952 37
I6729 6729 0 1.34816e-05
R7436 6729 6730 1.696 0.8 13.568 37
I6730 6730 0 1.24921e-05
R7437 6730 6731 1.632 0.8 13.056 37
I6731 6731 0 1.26158e-05
R7438 6731 6732 1.744 0.8 13.952 37
I6732 6732 0 1.34816e-05
R7439 6732 6733 1.648 0.8 13.184 37
I6733 6733 0 1.28631e-05
R7440 6733 6734 1.664 0.8 13.312 37
I6734 6734 0 1.27395e-05
R7441 6734 6735 1.68 0.8 13.44 37
I6735 6735 0 1.33579e-05
R7442 6735 6736 1.664 0.8 13.312 37
I6736 6736 0 1.31105e-05
R7443 6736 6737 1.696 0.8 13.568 37
I6737 6737 0 1.32342e-05
R7444 6737 6738 1.712 0.8 13.696 37
I6738 6738 0 1.24921e-05
R7445 6738 6739 1.68 0.8 13.44 37
I6739 6739 0 1.29868e-05
R7446 6739 6740 1.696 0.8 13.568 37
I6740 6740 0 1.28631e-05
R7447 6740 6741 1.616 0.8 12.928 37
I6741 6741 0 1.24921e-05
R7448 6741 6742 1.616 0.8 12.928 37
I6742 6742 0 1.29868e-05
R7449 6742 6743 1.68 0.8 13.44 37
I6743 6743 0 1.34816e-05
R7450 6743 6744 1.728 0.8 13.824 37
I6744 6744 0 1.32342e-05
R7451 6744 6745 1.728 0.8 13.824 37
I6745 6745 0 1.28631e-05
R7452 6745 6746 1.728 0.8 13.824 37
I6746 6746 0 1.26158e-05
R7453 6746 6747 1.728 0.8 13.824 37
I6747 6747 0 1.32342e-05
R7454 6747 6748 1.616 0.8 12.928 37
I6748 6748 0 1.24921e-05
R7455 6748 6749 1.632 0.8 13.056 37
I6749 6749 0 1.31105e-05
R7456 6749 6750 1.696 0.8 13.568 37
I6750 6750 0 1.34816e-05
R7457 6750 6751 1.696 0.8 13.568 37
I6751 6751 0 1.23684e-05
R7458 6751 6752 1.68 0.8 13.44 37
I6752 6752 0 1.26158e-05
R7459 6752 6753 1.728 0.8 13.824 37
I6753 6753 0 1.27395e-05
R7460 6753 6754 1.696 0.8 13.568 37
I6754 6754 0 1.29868e-05
R7461 6754 6755 1.6 0.8 12.8 37
I6755 6755 0 1.28631e-05
R7462 6755 6756 1.744 0.8 13.952 37
I6756 6756 0 1.26158e-05
R7463 6756 6757 1.728 0.8 13.824 37
I6757 6757 0 1.26158e-05
R7464 6757 6758 1.744 0.8 13.952 37
I6758 6758 0 1.27395e-05
R7465 6758 6759 1.616 0.8 12.928 37
I6759 6759 0 1.32342e-05
R7466 6759 6760 1.6 0.8 12.8 37
I6760 6760 0 1.34816e-05
R7467 6760 6761 1.648 0.8 13.184 37
I6761 6761 0 1.23684e-05
R7468 6761 6762 1.632 0.8 13.056 37
I6762 6762 0 1.28631e-05
R7469 6762 6763 1.728 0.8 13.824 37
I6763 6763 0 1.29868e-05
R7470 6763 6764 1.712 0.8 13.696 37
I6764 6764 0 1.26158e-05
R7471 6764 6765 1.616 0.8 12.928 37
I6765 6765 0 1.28631e-05
R7472 6765 6766 1.616 0.8 12.928 37
I6766 6766 0 1.32342e-05
R7473 6766 6767 1.696 0.8 13.568 37
I6767 6767 0 1.33579e-05
R7474 6767 6768 1.632 0.8 13.056 37
I6768 6768 0 1.31105e-05
R7475 6768 6769 1.648 0.8 13.184 37
I6769 6769 0 1.23684e-05
R7476 6769 6770 1.664 0.8 13.312 37
I6770 6770 0 1.28631e-05
R7477 6770 6771 1.664 0.8 13.312 37
I6771 6771 0 1.27395e-05
R7478 6771 6772 1.696 0.8 13.568 37
I6772 6772 0 1.26158e-05
R7479 6772 6773 1.696 0.8 13.568 37
I6773 6773 0 1.32342e-05
R7480 6773 6774 1.728 0.8 13.824 37
I6774 6774 0 1.34816e-05
R7481 6774 6775 1.712 0.8 13.696 37
I6775 6775 0 1.23684e-05
R7482 6775 6776 1.744 0.8 13.952 37
I6776 6776 0 1.23684e-05
R7483 6776 6777 1.648 0.8 13.184 37
I6777 6777 0 1.27395e-05
R7484 6777 6778 1.664 0.8 13.312 37
I6778 6778 0 1.24921e-05
R7485 6778 6779 1.728 0.8 13.824 37
I6779 6779 0 1.26158e-05
R7486 6779 6780 1.68 0.8 13.44 37
I6780 6780 0 1.26158e-05
R7487 6780 6781 1.728 0.8 13.824 37
I6781 6781 0 1.31105e-05
R7488 6781 6782 1.616 0.8 12.928 37
I6782 6782 0 1.31105e-05
R7489 6782 6783 1.664 0.8 13.312 37
I6783 6783 0 1.29868e-05
R7490 6783 6784 1.68 0.8 13.44 37
I6784 6784 0 1.33579e-05
R7491 6784 6785 1.68 0.8 13.44 37
I6785 6785 0 1.34816e-05
R7492 6785 6786 1.632 0.8 13.056 37
I6786 6786 0 1.26158e-05
R7493 6786 6787 1.664 0.8 13.312 37
I6787 6787 0 1.23684e-05
R7494 6787 6788 1.696 0.8 13.568 37
I6788 6788 0 1.26158e-05
R7495 6788 6789 1.744 0.8 13.952 37
I6789 6789 0 1.28631e-05
R7496 6789 6790 1.632 0.8 13.056 37
I6790 6790 0 1.31105e-05
R7497 6790 6791 1.712 0.8 13.696 37
I6791 6791 0 1.27395e-05
R7498 6791 6792 1.712 0.8 13.696 37
I6792 6792 0 1.23684e-05
R7499 6792 6793 1.728 0.8 13.824 37
I6793 6793 0 1.27395e-05
R7500 6793 6794 1.648 0.8 13.184 37
I6794 6794 0 1.33579e-05
R7501 6794 6795 1.712 0.8 13.696 37
I6795 6795 0 1.23684e-05
R7502 6795 6796 1.632 0.8 13.056 37
I6796 6796 0 1.32342e-05
R7503 6796 6797 1.696 0.8 13.568 37
I6797 6797 0 1.28631e-05
R7504 6797 6798 1.696 0.8 13.568 37
I6798 6798 0 1.26158e-05
R7505 6798 6799 1.744 0.8 13.952 37
I6799 6799 0 1.24921e-05
R7506 6799 6800 1.632 0.8 13.056 37
I6800 6800 0 1.32342e-05
R7507 6800 6801 1.632 0.8 13.056 37
I6801 6801 0 1.31105e-05
R7508 6801 6802 1.744 0.8 13.952 37
I6802 6802 0 1.33579e-05
R7509 6802 6803 1.728 0.8 13.824 37
I6803 6803 0 1.29868e-05
R7510 6803 6804 1.616 0.8 12.928 37
I6804 6804 0 1.33579e-05
R7511 6804 6805 1.632 0.8 13.056 37
I6805 6805 0 1.29868e-05
R7512 6805 6806 1.664 0.8 13.312 37
I6806 6806 0 1.24921e-05
R7513 6806 6807 1.6 0.8 12.8 37
I6807 6807 0 1.27395e-05
R7514 6807 6808 1.648 0.8 13.184 37
I6808 6808 0 1.23684e-05
R7515 6808 6809 1.744 0.8 13.952 37
I6809 6809 0 1.33579e-05
R7516 6809 6810 1.728 0.8 13.824 37
I6810 6810 0 1.31105e-05
R7517 6810 6811 1.728 0.8 13.824 37
I6811 6811 0 1.24921e-05
R7518 6811 6812 1.696 0.8 13.568 37
I6812 6812 0 1.31105e-05
R7519 6812 6813 1.712 0.8 13.696 37
I6813 6813 0 1.26158e-05
R7520 6813 6814 1.728 0.8 13.824 37
I6814 6814 0 1.33579e-05
R7521 6814 6815 1.648 0.8 13.184 37
I6815 6815 0 1.27395e-05
R7522 6815 6816 1.68 0.8 13.44 37
I6816 6816 0 1.32342e-05
R7523 6816 6817 1.616 0.8 12.928 37
I6817 6817 0 1.31105e-05
R7524 6817 6818 1.712 0.8 13.696 37
I6818 6818 0 1.23684e-05
R7525 6818 6819 1.664 0.8 13.312 37
I6819 6819 0 1.23684e-05
R7526 6819 6820 1.6 0.8 12.8 37
I6820 6820 0 1.33579e-05
R7527 6820 6821 1.68 0.8 13.44 37
I6821 6821 0 1.28631e-05
R7528 6821 6822 1.744 0.8 13.952 37
I6822 6822 0 1.32342e-05
R7529 6822 6823 1.6 0.8 12.8 37
I6823 6823 0 1.26158e-05
R7530 6823 6824 1.712 0.8 13.696 37
I6824 6824 0 1.34816e-05
R7531 6824 6825 1.632 0.8 13.056 37
I6825 6825 0 1.31105e-05
R7532 6825 6826 1.712 0.8 13.696 37
I6826 6826 0 1.23684e-05
R7533 6826 6827 1.744 0.8 13.952 37
I6827 6827 0 1.27395e-05
R7534 6827 6828 1.696 0.8 13.568 37
I6828 6828 0 1.33579e-05
R7535 6828 6829 1.68 0.8 13.44 37
I6829 6829 0 1.28631e-05
R7536 6829 6830 1.696 0.8 13.568 37
I6830 6830 0 1.23684e-05
R7537 6830 6831 1.744 0.8 13.952 37
I6831 6831 0 1.28631e-05
R7538 6831 6832 1.744 0.8 13.952 37
I6832 6832 0 1.24921e-05
R7539 6832 6833 1.632 0.8 13.056 37
I6833 6833 0 1.32342e-05
R7540 6833 6834 1.648 0.8 13.184 37
I6834 6834 0 1.31105e-05
R7541 6834 6835 1.712 0.8 13.696 37
I6835 6835 0 1.27395e-05
R7542 6835 6836 1.664 0.8 13.312 37
I6836 6836 0 1.29868e-05
R7543 6836 6837 1.712 0.8 13.696 37
I6837 6837 0 1.29868e-05
R7544 6837 6838 1.632 0.8 13.056 37
I6838 6838 0 1.34816e-05
R7545 6838 6839 1.744 0.8 13.952 37
I6839 6839 0 1.23684e-05
R7546 6839 6840 1.6 0.8 12.8 37
I6840 6840 0 1.24921e-05
R7547 6840 6841 1.728 0.8 13.824 37
I6841 6841 0 1.33579e-05
R7548 6841 6842 1.616 0.8 12.928 37
I6842 6842 0 1.34816e-05
R7549 6842 6843 1.648 0.8 13.184 37
I6843 6843 0 1.32342e-05
R7550 6843 6844 1.712 0.8 13.696 37
I6844 6844 0 1.34816e-05
R7551 6844 6845 1.664 0.8 13.312 37
I6845 6845 0 1.29868e-05
R7552 6845 6846 1.616 0.8 12.928 37
I6846 6846 0 1.29868e-05
R7553 6846 6847 1.616 0.8 12.928 37
I6847 6847 0 1.24921e-05
R7554 6847 6848 1.696 0.8 13.568 37
I6848 6848 0 1.31105e-05
R7555 6848 6849 1.6 0.8 12.8 37
I6849 6849 0 1.34816e-05
R7556 6849 6850 1.632 0.8 13.056 37
I6850 6850 0 1.32342e-05
R7557 6850 6851 1.632 0.8 13.056 37
I6851 6851 0 1.34816e-05
R7558 6851 6852 1.632 0.8 13.056 37
I6852 6852 0 1.26158e-05
R7559 6852 6853 1.696 0.8 13.568 37
I6853 6853 0 1.32342e-05
R7560 6853 6854 1.648 0.8 13.184 37
I6854 6854 0 1.31105e-05
R7561 6854 6855 1.744 0.8 13.952 37
I6855 6855 0 1.28631e-05
R7562 6855 6856 1.744 0.8 13.952 37
I6856 6856 0 1.32342e-05
R7563 6856 6857 1.632 0.8 13.056 37
I6857 6857 0 1.27395e-05
R7564 6857 6858 1.728 0.8 13.824 37
I6858 6858 0 1.29868e-05
R7565 6858 6859 1.632 0.8 13.056 37
I6859 6859 0 1.32342e-05
R7566 6859 6860 1.696 0.8 13.568 37
I6860 6860 0 1.31105e-05
R7567 6860 6861 1.664 0.8 13.312 37
I6861 6861 0 1.23684e-05
R7568 6861 6862 1.664 0.8 13.312 37
I6862 6862 0 1.31105e-05
R7569 6862 6863 1.648 0.8 13.184 37
I6863 6863 0 1.23684e-05
R7570 6863 6864 1.632 0.8 13.056 37
I6864 6864 0 1.27395e-05
R7571 6864 6865 1.632 0.8 13.056 37
I6865 6865 0 1.31105e-05
R7572 6865 6866 1.6 0.8 12.8 37
I6866 6866 0 1.31105e-05
R7573 6866 6867 1.712 0.8 13.696 37
I6867 6867 0 1.29868e-05
R7574 6867 6868 1.6 0.8 12.8 37
I6868 6868 0 1.28631e-05
R7575 6868 6869 1.632 0.8 13.056 37
I6869 6869 0 1.28631e-05
R7576 6869 6870 1.632 0.8 13.056 37
I6870 6870 0 1.27395e-05
R7577 6870 6871 1.728 0.8 13.824 37
I6871 6871 0 1.27395e-05
R7578 6871 6872 1.6 0.8 12.8 37
I6872 6872 0 1.26158e-05
R7579 6872 6873 1.696 0.8 13.568 37
I6873 6873 0 1.23684e-05
R7580 6873 6874 1.744 0.8 13.952 37
I6874 6874 0 1.34816e-05
R7581 6874 6875 1.744 0.8 13.952 37
I6875 6875 0 1.33579e-05
R7582 6875 6876 1.712 0.8 13.696 37
I6876 6876 0 1.27395e-05
R7583 6876 6877 1.728 0.8 13.824 37
I6877 6877 0 1.24921e-05
R7584 6877 6878 1.616 0.8 12.928 37
I6878 6878 0 1.24921e-05
R7585 6878 6879 1.664 0.8 13.312 37
I6879 6879 0 1.29868e-05
R7586 6879 6880 1.664 0.8 13.312 37
I6880 6880 0 1.31105e-05
R7587 6880 6881 1.664 0.8 13.312 37
I6881 6881 0 1.31105e-05
R7588 6881 6882 1.664 0.8 13.312 37
I6882 6882 0 1.24921e-05
R7589 6882 6883 1.648 0.8 13.184 37
I6883 6883 0 1.29868e-05
R7590 6883 6884 1.712 0.8 13.696 37
I6884 6884 0 1.32342e-05
R7591 6884 6885 1.616 0.8 12.928 37
I6885 6885 0 1.34816e-05
R7592 6885 6886 1.6 0.8 12.8 37
I6886 6886 0 1.34816e-05
R7593 6886 6887 1.68 0.8 13.44 37
I6887 6887 0 1.26158e-05
R7594 6887 6888 1.648 0.8 13.184 37
I6888 6888 0 1.24921e-05
R7595 6888 6889 1.664 0.8 13.312 37
I6889 6889 0 1.26158e-05
R7596 6889 6890 1.6 0.8 12.8 37
I6890 6890 0 1.27395e-05
R7597 6890 6891 1.6 0.8 12.8 37
I6891 6891 0 1.23684e-05
R7598 6891 6892 1.712 0.8 13.696 37
I6892 6892 0 1.23684e-05
R7599 6892 6893 1.616 0.8 12.928 37
I6893 6893 0 1.33579e-05
R7600 6893 6894 1.616 0.8 12.928 37
I6894 6894 0 1.29868e-05
R7601 6894 6895 1.696 0.8 13.568 37
I6895 6895 0 1.32342e-05
R7602 6895 6896 1.648 0.8 13.184 37
I6896 6896 0 1.23684e-05
R7603 6896 6897 1.696 0.8 13.568 37
I6897 6897 0 1.23684e-05
R7604 6897 6898 1.616 0.8 12.928 37
I6898 6898 0 1.34816e-05
R7605 6898 6899 1.68 0.8 13.44 37
I6899 6899 0 1.24921e-05
R7606 6899 6900 1.744 0.8 13.952 37
I6900 6900 0 1.31105e-05
R7607 6900 6901 1.632 0.8 13.056 37
I6901 6901 0 1.34816e-05
R7608 6901 6902 1.712 0.8 13.696 37
I6902 6902 0 1.32342e-05
R7609 6902 6903 1.664 0.8 13.312 37
I6903 6903 0 1.26158e-05
R7610 6903 6904 1.744 0.8 13.952 37
I6904 6904 0 1.33579e-05
R7611 6904 6905 1.664 0.8 13.312 37
I6905 6905 0 1.24921e-05
R7612 6905 6906 1.632 0.8 13.056 37
I6906 6906 0 1.32342e-05
R7613 6906 6907 1.616 0.8 12.928 37
I6907 6907 0 1.24921e-05
R7614 6907 6908 1.712 0.8 13.696 37
I6908 6908 0 1.27395e-05
R7615 6908 6909 1.744 0.8 13.952 37
I6909 6909 0 1.24921e-05
R7616 6909 6910 1.6 0.8 12.8 37
I6910 6910 0 1.32342e-05
R7617 6910 6911 1.728 0.8 13.824 37
I6911 6911 0 1.31105e-05
R7618 6911 6912 1.712 0.8 13.696 37
I6912 6912 0 1.28631e-05
R7619 6912 6913 1.696 0.8 13.568 37
I6913 6913 0 1.24921e-05
R7620 6913 6914 1.696 0.8 13.568 37
I6914 6914 0 1.27395e-05
R7621 6914 6915 1.632 0.8 13.056 37
I6915 6915 0 1.29868e-05
R7622 6915 6916 1.616 0.8 12.928 37
I6916 6916 0 1.28631e-05
R7623 6916 6917 1.696 0.8 13.568 37
I6917 6917 0 1.23684e-05
R7624 6917 6918 1.632 0.8 13.056 37
I6918 6918 0 1.26158e-05
R7625 6918 6919 1.632 0.8 13.056 37
I6919 6919 0 1.27395e-05
R7626 6919 6920 1.616 0.8 12.928 37
I6920 6920 0 1.33579e-05
R7627 6920 6921 1.664 0.8 13.312 37
I6921 6921 0 1.29868e-05
R7628 6921 6922 1.712 0.8 13.696 37
I6922 6922 0 1.31105e-05
R7629 6922 6923 1.696 0.8 13.568 37
I6923 6923 0 1.29868e-05
R7630 6923 6924 1.616 0.8 12.928 37
I6924 6924 0 1.32342e-05
R7631 6924 6925 1.728 0.8 13.824 37
I6925 6925 0 1.24921e-05
R7632 6925 6926 1.68 0.8 13.44 37
I6926 6926 0 1.33579e-05
R7633 6926 6927 1.744 0.8 13.952 37
I6927 6927 0 1.26158e-05
R7634 6927 6928 1.648 0.8 13.184 37
I6928 6928 0 1.29868e-05
R7635 6928 6929 1.648 0.8 13.184 37
I6929 6929 0 1.24921e-05
R7636 6929 6930 1.6 0.8 12.8 37
I6930 6930 0 1.32342e-05
R7637 6930 6931 1.728 0.8 13.824 37
I6931 6931 0 1.27395e-05
R7638 6931 6932 1.632 0.8 13.056 37
I6932 6932 0 1.28631e-05
R7639 6932 6933 1.648 0.8 13.184 37
I6933 6933 0 1.31105e-05
R7640 6933 6934 1.744 0.8 13.952 37
I6934 6934 0 1.32342e-05
R7641 6934 6935 1.744 0.8 13.952 37
I6935 6935 0 1.23684e-05
R7642 6935 6936 1.696 0.8 13.568 37
I6936 6936 0 1.27395e-05
R7643 6936 6937 1.68 0.8 13.44 37
I6937 6937 0 1.27395e-05
R7644 6937 6938 1.744 0.8 13.952 37
I6938 6938 0 1.24921e-05
R7645 6938 6939 1.6 0.8 12.8 37
I6939 6939 0 1.23684e-05
R7646 6939 6940 1.728 0.8 13.824 37
I6940 6940 0 1.23684e-05
R7647 6940 6941 1.664 0.8 13.312 37
I6941 6941 0 1.29868e-05
R7648 6941 6942 1.744 0.8 13.952 37
I6942 6942 0 1.27395e-05
R7649 6942 6943 1.728 0.8 13.824 37
I6943 6943 0 1.26158e-05
R7650 6943 6944 1.616 0.8 12.928 37
I6944 6944 0 1.27395e-05
R7651 6944 6945 1.68 0.8 13.44 37
I6945 6945 0 1.27395e-05
R7652 6945 6946 1.648 0.8 13.184 37
I6946 6946 0 1.27395e-05
R7653 6946 6947 1.712 0.8 13.696 37
I6947 6947 0 1.29868e-05
R7654 6947 6948 1.744 0.8 13.952 37
I6948 6948 0 1.26158e-05
R7655 6948 6949 1.648 0.8 13.184 37
I6949 6949 0 1.33579e-05
R7656 6949 6950 1.6 0.8 12.8 37
I6950 6950 0 1.26158e-05
R7657 6950 6951 1.6 0.8 12.8 37
I6951 6951 0 1.33579e-05
R7658 6951 6952 1.712 0.8 13.696 37
I6952 6952 0 1.29868e-05
R7659 6952 6953 1.648 0.8 13.184 37
I6953 6953 0 1.32342e-05
R7660 6953 6954 1.728 0.8 13.824 37
I6954 6954 0 1.31105e-05
R7661 6954 6955 1.744 0.8 13.952 37
I6955 6955 0 1.34816e-05
R7662 6955 6956 1.696 0.8 13.568 37
I6956 6956 0 1.29868e-05
R7663 6956 6957 1.664 0.8 13.312 37
I6957 6957 0 1.29868e-05
R7664 6957 6958 1.744 0.8 13.952 37
I6958 6958 0 1.28631e-05
R7665 6958 6959 1.744 0.8 13.952 37
I6959 6959 0 1.26158e-05
R7666 6959 6960 1.6 0.8 12.8 37
I6960 6960 0 1.28631e-05
R7667 6960 6961 1.68 0.8 13.44 37
I6961 6961 0 1.27395e-05
R7668 6961 6962 1.744 0.8 13.952 37
I6962 6962 0 1.28631e-05
R7669 6962 6963 1.6 0.8 12.8 37
I6963 6963 0 1.24921e-05
R7670 6963 6964 1.712 0.8 13.696 37
I6964 6964 0 1.27395e-05
R7671 6964 6965 1.616 0.8 12.928 37
I6965 6965 0 1.34816e-05
R7672 6965 6966 1.712 0.8 13.696 37
I6966 6966 0 1.26158e-05
R7673 6966 6967 1.744 0.8 13.952 37
I6967 6967 0 1.28631e-05
R7674 6967 6968 1.744 0.8 13.952 37
I6968 6968 0 1.26158e-05
R7675 6968 6969 1.616 0.8 12.928 37
I6969 6969 0 1.33579e-05
R7676 6969 6970 1.728 0.8 13.824 37
I6970 6970 0 1.27395e-05
R7677 6970 6971 1.744 0.8 13.952 37
I6971 6971 0 1.32342e-05
R7678 6971 6972 1.728 0.8 13.824 37
I6972 6972 0 1.27395e-05
R7679 6972 6973 1.632 0.8 13.056 37
I6973 6973 0 1.34816e-05
R7680 6973 6974 1.6 0.8 12.8 37
I6974 6974 0 1.28631e-05
R7681 6974 6975 1.616 0.8 12.928 37
I6975 6975 0 1.23684e-05
R7682 6975 6976 1.6 0.8 12.8 37
I6976 6976 0 1.34816e-05
R7683 6976 6977 1.68 0.8 13.44 37
I6977 6977 0 1.23684e-05
R7684 6977 6978 1.68 0.8 13.44 37
I6978 6978 0 1.29868e-05
R7685 6978 6979 1.648 0.8 13.184 37
I6979 6979 0 1.26158e-05
R7686 6979 6980 1.6 0.8 12.8 37
I6980 6980 0 1.28631e-05
R7687 6980 6981 1.648 0.8 13.184 37
I6981 6981 0 1.32342e-05
R7688 6981 6982 1.696 0.8 13.568 37
I6982 6982 0 1.26158e-05
R7689 6982 6983 1.616 0.8 12.928 37
I6983 6983 0 1.33579e-05
R7690 6983 6984 1.712 0.8 13.696 37
I6984 6984 0 1.29868e-05
R7691 6984 6985 1.728 0.8 13.824 37
I6985 6985 0 1.32342e-05
R7692 6985 6986 1.6 0.8 12.8 37
I6986 6986 0 1.32342e-05
R7693 6986 6987 1.664 0.8 13.312 37
I6987 6987 0 1.33579e-05
R7694 6987 6988 1.632 0.8 13.056 37
I6988 6988 0 1.34816e-05
R7695 6988 6989 1.6 0.8 12.8 37
I6989 6989 0 1.26158e-05
R7696 6989 6990 1.648 0.8 13.184 37
I6990 6990 0 1.27395e-05
R7697 6990 6991 1.664 0.8 13.312 37
I6991 6991 0 1.27395e-05
R7698 6991 6992 1.632 0.8 13.056 37
I6992 6992 0 1.34816e-05
R7699 6992 6993 1.68 0.8 13.44 37
I6993 6993 0 1.33579e-05
R7700 6993 6994 1.664 0.8 13.312 37
I6994 6994 0 1.33579e-05
R7701 6994 6995 1.632 0.8 13.056 37
I6995 6995 0 1.28631e-05
R7702 6995 6996 1.648 0.8 13.184 37
I6996 6996 0 1.33579e-05
R7703 6996 6997 1.648 0.8 13.184 37
I6997 6997 0 1.24921e-05
R7704 6997 6998 1.632 0.8 13.056 37
I6998 6998 0 1.29868e-05
R7705 6998 6999 1.744 0.8 13.952 37
I6999 6999 0 1.24921e-05
R7706 6999 7000 1.632 0.8 13.056 37
I7000 7000 0 1.23684e-05
R7707 7000 10001 0.5 10 50 37
*seg: 8
* inter-segment connection
R7708 7010 8010 6.16 0.8 49.28 37
R7709 7020 8020 6.16 0.8 49.28 37
R7710 7030 8030 6.16 0.8 49.28 37
R7711 7040 8040 6.16 0.8 49.28 37
R7712 7050 8050 6.16 0.8 49.28 37
R7713 7060 8060 6.16 0.8 49.28 37
R7714 7070 8070 6.16 0.8 49.28 37
R7715 7080 8080 6.16 0.8 49.28 37
R7716 7090 8090 6.16 0.8 49.28 37
R7717 7100 8100 6.16 0.8 49.28 37
R7718 7110 8110 6.16 0.8 49.28 37
R7719 7120 8120 6.16 0.8 49.28 37
R7720 7130 8130 6.16 0.8 49.28 37
R7721 7140 8140 6.16 0.8 49.28 37
R7722 7150 8150 6.16 0.8 49.28 37
R7723 7160 8160 6.16 0.8 49.28 37
R7724 7170 8170 6.16 0.8 49.28 37
R7725 7180 8180 6.16 0.8 49.28 37
R7726 7190 8190 6.16 0.8 49.28 37
R7727 7200 8200 6.16 0.8 49.28 37
R7728 7210 8210 6.16 0.8 49.28 37
R7729 7220 8220 6.16 0.8 49.28 37
R7730 7230 8230 6.16 0.8 49.28 37
R7731 7240 8240 6.16 0.8 49.28 37
R7732 7250 8250 6.16 0.8 49.28 37
R7733 7260 8260 6.16 0.8 49.28 37
R7734 7270 8270 6.16 0.8 49.28 37
R7735 7280 8280 6.16 0.8 49.28 37
R7736 7290 8290 6.16 0.8 49.28 37
R7737 7300 8300 6.16 0.8 49.28 37
R7738 7310 8310 6.16 0.8 49.28 37
R7739 7320 8320 6.16 0.8 49.28 37
R7740 7330 8330 6.16 0.8 49.28 37
R7741 7340 8340 6.16 0.8 49.28 37
R7742 7350 8350 6.16 0.8 49.28 37
R7743 7360 8360 6.16 0.8 49.28 37
R7744 7370 8370 6.16 0.8 49.28 37
R7745 7380 8380 6.16 0.8 49.28 37
R7746 7390 8390 6.16 0.8 49.28 37
R7747 7400 8400 6.16 0.8 49.28 37
R7748 7410 8410 6.16 0.8 49.28 37
R7749 7420 8420 6.16 0.8 49.28 37
R7750 7430 8430 6.16 0.8 49.28 37
R7751 7440 8440 6.16 0.8 49.28 37
R7752 7450 8450 6.16 0.8 49.28 37
R7753 7460 8460 6.16 0.8 49.28 37
R7754 7470 8470 6.16 0.8 49.28 37
R7755 7480 8480 6.16 0.8 49.28 37
R7756 7490 8490 6.16 0.8 49.28 37
R7757 7500 8500 6.16 0.8 49.28 37
R7758 7510 8510 6.16 0.8 49.28 37
R7759 7520 8520 6.16 0.8 49.28 37
R7760 7530 8530 6.16 0.8 49.28 37
R7761 7540 8540 6.16 0.8 49.28 37
R7762 7550 8550 6.16 0.8 49.28 37
R7763 7560 8560 6.16 0.8 49.28 37
R7764 7570 8570 6.16 0.8 49.28 37
R7765 7580 8580 6.16 0.8 49.28 37
R7766 7590 8590 6.16 0.8 49.28 37
R7767 7600 8600 6.16 0.8 49.28 37
R7768 7610 8610 6.16 0.8 49.28 37
R7769 7620 8620 6.16 0.8 49.28 37
R7770 7630 8630 6.16 0.8 49.28 37
R7771 7640 8640 6.16 0.8 49.28 37
R7772 7650 8650 6.16 0.8 49.28 37
R7773 7660 8660 6.16 0.8 49.28 37
R7774 7670 8670 6.16 0.8 49.28 37
R7775 7680 8680 6.16 0.8 49.28 37
R7776 7690 8690 6.16 0.8 49.28 37
R7777 7700 8700 6.16 0.8 49.28 37
R7778 7710 8710 6.16 0.8 49.28 37
R7779 7720 8720 6.16 0.8 49.28 37
R7780 7730 8730 6.16 0.8 49.28 37
R7781 7740 8740 6.16 0.8 49.28 37
R7782 7750 8750 6.16 0.8 49.28 37
R7783 7760 8760 6.16 0.8 49.28 37
R7784 7770 8770 6.16 0.8 49.28 37
R7785 7780 8780 6.16 0.8 49.28 37
R7786 7790 8790 6.16 0.8 49.28 37
R7787 7800 8800 6.16 0.8 49.28 37
R7788 7810 8810 6.16 0.8 49.28 37
R7789 7820 8820 6.16 0.8 49.28 37
R7790 7830 8830 6.16 0.8 49.28 37
R7791 7840 8840 6.16 0.8 49.28 37
R7792 7850 8850 6.16 0.8 49.28 37
R7793 7860 8860 6.16 0.8 49.28 37
R7794 7870 8870 6.16 0.8 49.28 37
R7795 7880 8880 6.16 0.8 49.28 37
R7796 7890 8890 6.16 0.8 49.28 37
R7797 7900 8900 6.16 0.8 49.28 37
R7798 7910 8910 6.16 0.8 49.28 37
R7799 7920 8920 6.16 0.8 49.28 37
R7800 7930 8930 6.16 0.8 49.28 37
R7801 7940 8940 6.16 0.8 49.28 37
R7802 7950 8950 6.16 0.8 49.28 37
R7803 7960 8960 6.16 0.8 49.28 37
R7804 7970 8970 6.16 0.8 49.28 37
R7805 7980 8980 6.16 0.8 49.28 37
R7806 7990 8990 6.16 0.8 49.28 37
R7807 8000 9000 6.16 0.8 49.28 37
R7808 10001 7001 0.4 20 80 37
I7001 7001 0 1.32342e-05
R7809 7001 7002 1.744 0.8 13.952 37
I7002 7002 0 1.26158e-05
R7810 7002 7003 1.664 0.8 13.312 37
I7003 7003 0 1.29868e-05
R7811 7003 7004 1.632 0.8 13.056 37
I7004 7004 0 1.34816e-05
R7812 7004 7005 1.696 0.8 13.568 37
I7005 7005 0 1.26158e-05
R7813 7005 7006 1.616 0.8 12.928 37
I7006 7006 0 1.34816e-05
R7814 7006 7007 1.696 0.8 13.568 37
I7007 7007 0 1.31105e-05
R7815 7007 7008 1.68 0.8 13.44 37
I7008 7008 0 1.23684e-05
R7816 7008 7009 1.712 0.8 13.696 37
I7009 7009 0 1.26158e-05
R7817 7009 7010 1.6 0.8 12.8 37
I7010 7010 0 1.26158e-05
R7818 7010 7011 1.616 0.8 12.928 37
I7011 7011 0 1.29868e-05
R7819 7011 7012 1.728 0.8 13.824 37
I7012 7012 0 1.31105e-05
R7820 7012 7013 1.68 0.8 13.44 37
I7013 7013 0 1.28631e-05
R7821 7013 7014 1.744 0.8 13.952 37
I7014 7014 0 1.32342e-05
R7822 7014 7015 1.744 0.8 13.952 37
I7015 7015 0 1.34816e-05
R7823 7015 7016 1.616 0.8 12.928 37
I7016 7016 0 1.24921e-05
R7824 7016 7017 1.728 0.8 13.824 37
I7017 7017 0 1.26158e-05
R7825 7017 7018 1.68 0.8 13.44 37
I7018 7018 0 1.29868e-05
R7826 7018 7019 1.712 0.8 13.696 37
I7019 7019 0 1.32342e-05
R7827 7019 7020 1.664 0.8 13.312 37
I7020 7020 0 1.28631e-05
R7828 7020 7021 1.632 0.8 13.056 37
I7021 7021 0 1.32342e-05
R7829 7021 7022 1.68 0.8 13.44 37
I7022 7022 0 1.23684e-05
R7830 7022 7023 1.68 0.8 13.44 37
I7023 7023 0 1.26158e-05
R7831 7023 7024 1.632 0.8 13.056 37
I7024 7024 0 1.27395e-05
R7832 7024 7025 1.712 0.8 13.696 37
I7025 7025 0 1.27395e-05
R7833 7025 7026 1.712 0.8 13.696 37
I7026 7026 0 1.33579e-05
R7834 7026 7027 1.6 0.8 12.8 37
I7027 7027 0 1.32342e-05
R7835 7027 7028 1.696 0.8 13.568 37
I7028 7028 0 1.29868e-05
R7836 7028 7029 1.616 0.8 12.928 37
I7029 7029 0 1.29868e-05
R7837 7029 7030 1.664 0.8 13.312 37
I7030 7030 0 1.26158e-05
R7838 7030 7031 1.696 0.8 13.568 37
I7031 7031 0 1.29868e-05
R7839 7031 7032 1.68 0.8 13.44 37
I7032 7032 0 1.32342e-05
R7840 7032 7033 1.712 0.8 13.696 37
I7033 7033 0 1.23684e-05
R7841 7033 7034 1.632 0.8 13.056 37
I7034 7034 0 1.32342e-05
R7842 7034 7035 1.6 0.8 12.8 37
I7035 7035 0 1.33579e-05
R7843 7035 7036 1.648 0.8 13.184 37
I7036 7036 0 1.26158e-05
R7844 7036 7037 1.68 0.8 13.44 37
I7037 7037 0 1.23684e-05
R7845 7037 7038 1.632 0.8 13.056 37
I7038 7038 0 1.27395e-05
R7846 7038 7039 1.68 0.8 13.44 37
I7039 7039 0 1.28631e-05
R7847 7039 7040 1.728 0.8 13.824 37
I7040 7040 0 1.26158e-05
R7848 7040 7041 1.744 0.8 13.952 37
I7041 7041 0 1.29868e-05
R7849 7041 7042 1.632 0.8 13.056 37
I7042 7042 0 1.34816e-05
R7850 7042 7043 1.664 0.8 13.312 37
I7043 7043 0 1.23684e-05
R7851 7043 7044 1.696 0.8 13.568 37
I7044 7044 0 1.31105e-05
R7852 7044 7045 1.712 0.8 13.696 37
I7045 7045 0 1.27395e-05
R7853 7045 7046 1.728 0.8 13.824 37
I7046 7046 0 1.28631e-05
R7854 7046 7047 1.6 0.8 12.8 37
I7047 7047 0 1.31105e-05
R7855 7047 7048 1.648 0.8 13.184 37
I7048 7048 0 1.23684e-05
R7856 7048 7049 1.696 0.8 13.568 37
I7049 7049 0 1.32342e-05
R7857 7049 7050 1.712 0.8 13.696 37
I7050 7050 0 1.31105e-05
R7858 7050 7051 1.68 0.8 13.44 37
I7051 7051 0 1.26158e-05
R7859 7051 7052 1.6 0.8 12.8 37
I7052 7052 0 1.26158e-05
R7860 7052 7053 1.664 0.8 13.312 37
I7053 7053 0 1.28631e-05
R7861 7053 7054 1.712 0.8 13.696 37
I7054 7054 0 1.34816e-05
R7862 7054 7055 1.744 0.8 13.952 37
I7055 7055 0 1.29868e-05
R7863 7055 7056 1.648 0.8 13.184 37
I7056 7056 0 1.23684e-05
R7864 7056 7057 1.632 0.8 13.056 37
I7057 7057 0 1.29868e-05
R7865 7057 7058 1.632 0.8 13.056 37
I7058 7058 0 1.32342e-05
R7866 7058 7059 1.712 0.8 13.696 37
I7059 7059 0 1.33579e-05
R7867 7059 7060 1.648 0.8 13.184 37
I7060 7060 0 1.29868e-05
R7868 7060 7061 1.648 0.8 13.184 37
I7061 7061 0 1.27395e-05
R7869 7061 7062 1.616 0.8 12.928 37
I7062 7062 0 1.28631e-05
R7870 7062 7063 1.744 0.8 13.952 37
I7063 7063 0 1.28631e-05
R7871 7063 7064 1.664 0.8 13.312 37
I7064 7064 0 1.33579e-05
R7872 7064 7065 1.616 0.8 12.928 37
I7065 7065 0 1.27395e-05
R7873 7065 7066 1.696 0.8 13.568 37
I7066 7066 0 1.31105e-05
R7874 7066 7067 1.712 0.8 13.696 37
I7067 7067 0 1.32342e-05
R7875 7067 7068 1.6 0.8 12.8 37
I7068 7068 0 1.24921e-05
R7876 7068 7069 1.616 0.8 12.928 37
I7069 7069 0 1.33579e-05
R7877 7069 7070 1.648 0.8 13.184 37
I7070 7070 0 1.26158e-05
R7878 7070 7071 1.648 0.8 13.184 37
I7071 7071 0 1.31105e-05
R7879 7071 7072 1.648 0.8 13.184 37
I7072 7072 0 1.31105e-05
R7880 7072 7073 1.664 0.8 13.312 37
I7073 7073 0 1.29868e-05
R7881 7073 7074 1.68 0.8 13.44 37
I7074 7074 0 1.24921e-05
R7882 7074 7075 1.68 0.8 13.44 37
I7075 7075 0 1.23684e-05
R7883 7075 7076 1.696 0.8 13.568 37
I7076 7076 0 1.34816e-05
R7884 7076 7077 1.648 0.8 13.184 37
I7077 7077 0 1.32342e-05
R7885 7077 7078 1.68 0.8 13.44 37
I7078 7078 0 1.29868e-05
R7886 7078 7079 1.648 0.8 13.184 37
I7079 7079 0 1.34816e-05
R7887 7079 7080 1.68 0.8 13.44 37
I7080 7080 0 1.28631e-05
R7888 7080 7081 1.664 0.8 13.312 37
I7081 7081 0 1.24921e-05
R7889 7081 7082 1.632 0.8 13.056 37
I7082 7082 0 1.24921e-05
R7890 7082 7083 1.6 0.8 12.8 37
I7083 7083 0 1.29868e-05
R7891 7083 7084 1.632 0.8 13.056 37
I7084 7084 0 1.26158e-05
R7892 7084 7085 1.648 0.8 13.184 37
I7085 7085 0 1.32342e-05
R7893 7085 7086 1.696 0.8 13.568 37
I7086 7086 0 1.33579e-05
R7894 7086 7087 1.664 0.8 13.312 37
I7087 7087 0 1.24921e-05
R7895 7087 7088 1.696 0.8 13.568 37
I7088 7088 0 1.23684e-05
R7896 7088 7089 1.696 0.8 13.568 37
I7089 7089 0 1.24921e-05
R7897 7089 7090 1.616 0.8 12.928 37
I7090 7090 0 1.28631e-05
R7898 7090 7091 1.616 0.8 12.928 37
I7091 7091 0 1.23684e-05
R7899 7091 7092 1.68 0.8 13.44 37
I7092 7092 0 1.32342e-05
R7900 7092 7093 1.712 0.8 13.696 37
I7093 7093 0 1.23684e-05
R7901 7093 7094 1.632 0.8 13.056 37
I7094 7094 0 1.24921e-05
R7902 7094 7095 1.616 0.8 12.928 37
I7095 7095 0 1.34816e-05
R7903 7095 7096 1.712 0.8 13.696 37
I7096 7096 0 1.29868e-05
R7904 7096 7097 1.6 0.8 12.8 37
I7097 7097 0 1.23684e-05
R7905 7097 7098 1.728 0.8 13.824 37
I7098 7098 0 1.24921e-05
R7906 7098 7099 1.712 0.8 13.696 37
I7099 7099 0 1.26158e-05
R7907 7099 7100 1.68 0.8 13.44 37
I7100 7100 0 1.23684e-05
R7908 7100 7101 1.6 0.8 12.8 37
I7101 7101 0 1.24921e-05
R7909 7101 7102 1.6 0.8 12.8 37
I7102 7102 0 1.31105e-05
R7910 7102 7103 1.648 0.8 13.184 37
I7103 7103 0 1.32342e-05
R7911 7103 7104 1.696 0.8 13.568 37
I7104 7104 0 1.24921e-05
R7912 7104 7105 1.728 0.8 13.824 37
I7105 7105 0 1.32342e-05
R7913 7105 7106 1.712 0.8 13.696 37
I7106 7106 0 1.23684e-05
R7914 7106 7107 1.712 0.8 13.696 37
I7107 7107 0 1.28631e-05
R7915 7107 7108 1.712 0.8 13.696 37
I7108 7108 0 1.32342e-05
R7916 7108 7109 1.664 0.8 13.312 37
I7109 7109 0 1.24921e-05
R7917 7109 7110 1.6 0.8 12.8 37
I7110 7110 0 1.32342e-05
R7918 7110 7111 1.6 0.8 12.8 37
I7111 7111 0 1.32342e-05
R7919 7111 7112 1.632 0.8 13.056 37
I7112 7112 0 1.26158e-05
R7920 7112 7113 1.744 0.8 13.952 37
I7113 7113 0 1.26158e-05
R7921 7113 7114 1.648 0.8 13.184 37
I7114 7114 0 1.31105e-05
R7922 7114 7115 1.68 0.8 13.44 37
I7115 7115 0 1.23684e-05
R7923 7115 7116 1.728 0.8 13.824 37
I7116 7116 0 1.29868e-05
R7924 7116 7117 1.664 0.8 13.312 37
I7117 7117 0 1.34816e-05
R7925 7117 7118 1.616 0.8 12.928 37
I7118 7118 0 1.34816e-05
R7926 7118 7119 1.696 0.8 13.568 37
I7119 7119 0 1.34816e-05
R7927 7119 7120 1.632 0.8 13.056 37
I7120 7120 0 1.28631e-05
R7928 7120 7121 1.696 0.8 13.568 37
I7121 7121 0 1.26158e-05
R7929 7121 7122 1.696 0.8 13.568 37
I7122 7122 0 1.31105e-05
R7930 7122 7123 1.696 0.8 13.568 37
I7123 7123 0 1.27395e-05
R7931 7123 7124 1.648 0.8 13.184 37
I7124 7124 0 1.24921e-05
R7932 7124 7125 1.696 0.8 13.568 37
I7125 7125 0 1.27395e-05
R7933 7125 7126 1.728 0.8 13.824 37
I7126 7126 0 1.31105e-05
R7934 7126 7127 1.632 0.8 13.056 37
I7127 7127 0 1.27395e-05
R7935 7127 7128 1.744 0.8 13.952 37
I7128 7128 0 1.26158e-05
R7936 7128 7129 1.712 0.8 13.696 37
I7129 7129 0 1.28631e-05
R7937 7129 7130 1.6 0.8 12.8 37
I7130 7130 0 1.26158e-05
R7938 7130 7131 1.712 0.8 13.696 37
I7131 7131 0 1.34816e-05
R7939 7131 7132 1.744 0.8 13.952 37
I7132 7132 0 1.27395e-05
R7940 7132 7133 1.728 0.8 13.824 37
I7133 7133 0 1.26158e-05
R7941 7133 7134 1.632 0.8 13.056 37
I7134 7134 0 1.28631e-05
R7942 7134 7135 1.616 0.8 12.928 37
I7135 7135 0 1.31105e-05
R7943 7135 7136 1.6 0.8 12.8 37
I7136 7136 0 1.23684e-05
R7944 7136 7137 1.728 0.8 13.824 37
I7137 7137 0 1.32342e-05
R7945 7137 7138 1.696 0.8 13.568 37
I7138 7138 0 1.29868e-05
R7946 7138 7139 1.632 0.8 13.056 37
I7139 7139 0 1.34816e-05
R7947 7139 7140 1.728 0.8 13.824 37
I7140 7140 0 1.34816e-05
R7948 7140 7141 1.664 0.8 13.312 37
I7141 7141 0 1.31105e-05
R7949 7141 7142 1.712 0.8 13.696 37
I7142 7142 0 1.31105e-05
R7950 7142 7143 1.616 0.8 12.928 37
I7143 7143 0 1.33579e-05
R7951 7143 7144 1.6 0.8 12.8 37
I7144 7144 0 1.24921e-05
R7952 7144 7145 1.68 0.8 13.44 37
I7145 7145 0 1.24921e-05
R7953 7145 7146 1.648 0.8 13.184 37
I7146 7146 0 1.26158e-05
R7954 7146 7147 1.6 0.8 12.8 37
I7147 7147 0 1.29868e-05
R7955 7147 7148 1.68 0.8 13.44 37
I7148 7148 0 1.23684e-05
R7956 7148 7149 1.712 0.8 13.696 37
I7149 7149 0 1.34816e-05
R7957 7149 7150 1.664 0.8 13.312 37
I7150 7150 0 1.34816e-05
R7958 7150 7151 1.68 0.8 13.44 37
I7151 7151 0 1.31105e-05
R7959 7151 7152 1.744 0.8 13.952 37
I7152 7152 0 1.31105e-05
R7960 7152 7153 1.648 0.8 13.184 37
I7153 7153 0 1.32342e-05
R7961 7153 7154 1.616 0.8 12.928 37
I7154 7154 0 1.33579e-05
R7962 7154 7155 1.728 0.8 13.824 37
I7155 7155 0 1.34816e-05
R7963 7155 7156 1.712 0.8 13.696 37
I7156 7156 0 1.26158e-05
R7964 7156 7157 1.712 0.8 13.696 37
I7157 7157 0 1.31105e-05
R7965 7157 7158 1.6 0.8 12.8 37
I7158 7158 0 1.24921e-05
R7966 7158 7159 1.68 0.8 13.44 37
I7159 7159 0 1.24921e-05
R7967 7159 7160 1.632 0.8 13.056 37
I7160 7160 0 1.23684e-05
R7968 7160 7161 1.664 0.8 13.312 37
I7161 7161 0 1.29868e-05
R7969 7161 7162 1.664 0.8 13.312 37
I7162 7162 0 1.31105e-05
R7970 7162 7163 1.6 0.8 12.8 37
I7163 7163 0 1.24921e-05
R7971 7163 7164 1.696 0.8 13.568 37
I7164 7164 0 1.23684e-05
R7972 7164 7165 1.6 0.8 12.8 37
I7165 7165 0 1.26158e-05
R7973 7165 7166 1.616 0.8 12.928 37
I7166 7166 0 1.32342e-05
R7974 7166 7167 1.728 0.8 13.824 37
I7167 7167 0 1.26158e-05
R7975 7167 7168 1.648 0.8 13.184 37
I7168 7168 0 1.28631e-05
R7976 7168 7169 1.744 0.8 13.952 37
I7169 7169 0 1.28631e-05
R7977 7169 7170 1.632 0.8 13.056 37
I7170 7170 0 1.32342e-05
R7978 7170 7171 1.68 0.8 13.44 37
I7171 7171 0 1.24921e-05
R7979 7171 7172 1.616 0.8 12.928 37
I7172 7172 0 1.27395e-05
R7980 7172 7173 1.712 0.8 13.696 37
I7173 7173 0 1.27395e-05
R7981 7173 7174 1.696 0.8 13.568 37
I7174 7174 0 1.28631e-05
R7982 7174 7175 1.664 0.8 13.312 37
I7175 7175 0 1.33579e-05
R7983 7175 7176 1.664 0.8 13.312 37
I7176 7176 0 1.23684e-05
R7984 7176 7177 1.68 0.8 13.44 37
I7177 7177 0 1.33579e-05
R7985 7177 7178 1.696 0.8 13.568 37
I7178 7178 0 1.33579e-05
R7986 7178 7179 1.744 0.8 13.952 37
I7179 7179 0 1.26158e-05
R7987 7179 7180 1.728 0.8 13.824 37
I7180 7180 0 1.24921e-05
R7988 7180 7181 1.664 0.8 13.312 37
I7181 7181 0 1.24921e-05
R7989 7181 7182 1.744 0.8 13.952 37
I7182 7182 0 1.29868e-05
R7990 7182 7183 1.648 0.8 13.184 37
I7183 7183 0 1.28631e-05
R7991 7183 7184 1.744 0.8 13.952 37
I7184 7184 0 1.26158e-05
R7992 7184 7185 1.616 0.8 12.928 37
I7185 7185 0 1.27395e-05
R7993 7185 7186 1.616 0.8 12.928 37
I7186 7186 0 1.31105e-05
R7994 7186 7187 1.664 0.8 13.312 37
I7187 7187 0 1.28631e-05
R7995 7187 7188 1.616 0.8 12.928 37
I7188 7188 0 1.27395e-05
R7996 7188 7189 1.712 0.8 13.696 37
I7189 7189 0 1.32342e-05
R7997 7189 7190 1.728 0.8 13.824 37
I7190 7190 0 1.28631e-05
R7998 7190 7191 1.712 0.8 13.696 37
I7191 7191 0 1.28631e-05
R7999 7191 7192 1.664 0.8 13.312 37
I7192 7192 0 1.27395e-05
R8000 7192 7193 1.648 0.8 13.184 37
I7193 7193 0 1.27395e-05
R8001 7193 7194 1.616 0.8 12.928 37
I7194 7194 0 1.28631e-05
R8002 7194 7195 1.68 0.8 13.44 37
I7195 7195 0 1.24921e-05
R8003 7195 7196 1.728 0.8 13.824 37
I7196 7196 0 1.26158e-05
R8004 7196 7197 1.632 0.8 13.056 37
I7197 7197 0 1.34816e-05
R8005 7197 7198 1.712 0.8 13.696 37
I7198 7198 0 1.29868e-05
R8006 7198 7199 1.648 0.8 13.184 37
I7199 7199 0 1.31105e-05
R8007 7199 7200 1.744 0.8 13.952 37
I7200 7200 0 1.28631e-05
R8008 7200 7201 1.616 0.8 12.928 37
I7201 7201 0 1.26158e-05
R8009 7201 7202 1.648 0.8 13.184 37
I7202 7202 0 1.32342e-05
R8010 7202 7203 1.696 0.8 13.568 37
I7203 7203 0 1.31105e-05
R8011 7203 7204 1.6 0.8 12.8 37
I7204 7204 0 1.29868e-05
R8012 7204 7205 1.696 0.8 13.568 37
I7205 7205 0 1.23684e-05
R8013 7205 7206 1.744 0.8 13.952 37
I7206 7206 0 1.27395e-05
R8014 7206 7207 1.68 0.8 13.44 37
I7207 7207 0 1.31105e-05
R8015 7207 7208 1.696 0.8 13.568 37
I7208 7208 0 1.23684e-05
R8016 7208 7209 1.744 0.8 13.952 37
I7209 7209 0 1.34816e-05
R8017 7209 7210 1.696 0.8 13.568 37
I7210 7210 0 1.28631e-05
R8018 7210 7211 1.6 0.8 12.8 37
I7211 7211 0 1.28631e-05
R8019 7211 7212 1.728 0.8 13.824 37
I7212 7212 0 1.26158e-05
R8020 7212 7213 1.648 0.8 13.184 37
I7213 7213 0 1.29868e-05
R8021 7213 7214 1.744 0.8 13.952 37
I7214 7214 0 1.34816e-05
R8022 7214 7215 1.648 0.8 13.184 37
I7215 7215 0 1.33579e-05
R8023 7215 7216 1.68 0.8 13.44 37
I7216 7216 0 1.28631e-05
R8024 7216 7217 1.632 0.8 13.056 37
I7217 7217 0 1.23684e-05
R8025 7217 7218 1.616 0.8 12.928 37
I7218 7218 0 1.33579e-05
R8026 7218 7219 1.712 0.8 13.696 37
I7219 7219 0 1.28631e-05
R8027 7219 7220 1.664 0.8 13.312 37
I7220 7220 0 1.27395e-05
R8028 7220 7221 1.664 0.8 13.312 37
I7221 7221 0 1.29868e-05
R8029 7221 7222 1.728 0.8 13.824 37
I7222 7222 0 1.24921e-05
R8030 7222 7223 1.616 0.8 12.928 37
I7223 7223 0 1.32342e-05
R8031 7223 7224 1.648 0.8 13.184 37
I7224 7224 0 1.26158e-05
R8032 7224 7225 1.696 0.8 13.568 37
I7225 7225 0 1.23684e-05
R8033 7225 7226 1.744 0.8 13.952 37
I7226 7226 0 1.34816e-05
R8034 7226 7227 1.696 0.8 13.568 37
I7227 7227 0 1.32342e-05
R8035 7227 7228 1.648 0.8 13.184 37
I7228 7228 0 1.26158e-05
R8036 7228 7229 1.648 0.8 13.184 37
I7229 7229 0 1.27395e-05
R8037 7229 7230 1.616 0.8 12.928 37
I7230 7230 0 1.33579e-05
R8038 7230 7231 1.648 0.8 13.184 37
I7231 7231 0 1.31105e-05
R8039 7231 7232 1.648 0.8 13.184 37
I7232 7232 0 1.33579e-05
R8040 7232 7233 1.712 0.8 13.696 37
I7233 7233 0 1.28631e-05
R8041 7233 7234 1.696 0.8 13.568 37
I7234 7234 0 1.31105e-05
R8042 7234 7235 1.6 0.8 12.8 37
I7235 7235 0 1.26158e-05
R8043 7235 7236 1.616 0.8 12.928 37
I7236 7236 0 1.29868e-05
R8044 7236 7237 1.6 0.8 12.8 37
I7237 7237 0 1.34816e-05
R8045 7237 7238 1.728 0.8 13.824 37
I7238 7238 0 1.27395e-05
R8046 7238 7239 1.728 0.8 13.824 37
I7239 7239 0 1.26158e-05
R8047 7239 7240 1.696 0.8 13.568 37
I7240 7240 0 1.29868e-05
R8048 7240 7241 1.664 0.8 13.312 37
I7241 7241 0 1.32342e-05
R8049 7241 7242 1.696 0.8 13.568 37
I7242 7242 0 1.26158e-05
R8050 7242 7243 1.664 0.8 13.312 37
I7243 7243 0 1.34816e-05
R8051 7243 7244 1.664 0.8 13.312 37
I7244 7244 0 1.34816e-05
R8052 7244 7245 1.664 0.8 13.312 37
I7245 7245 0 1.29868e-05
R8053 7245 7246 1.728 0.8 13.824 37
I7246 7246 0 1.23684e-05
R8054 7246 7247 1.664 0.8 13.312 37
I7247 7247 0 1.27395e-05
R8055 7247 7248 1.728 0.8 13.824 37
I7248 7248 0 1.27395e-05
R8056 7248 7249 1.712 0.8 13.696 37
I7249 7249 0 1.31105e-05
R8057 7249 7250 1.744 0.8 13.952 37
I7250 7250 0 1.23684e-05
R8058 7250 7251 1.616 0.8 12.928 37
I7251 7251 0 1.26158e-05
R8059 7251 7252 1.712 0.8 13.696 37
I7252 7252 0 1.24921e-05
R8060 7252 7253 1.616 0.8 12.928 37
I7253 7253 0 1.29868e-05
R8061 7253 7254 1.696 0.8 13.568 37
I7254 7254 0 1.23684e-05
R8062 7254 7255 1.744 0.8 13.952 37
I7255 7255 0 1.26158e-05
R8063 7255 7256 1.712 0.8 13.696 37
I7256 7256 0 1.27395e-05
R8064 7256 7257 1.616 0.8 12.928 37
I7257 7257 0 1.29868e-05
R8065 7257 7258 1.696 0.8 13.568 37
I7258 7258 0 1.31105e-05
R8066 7258 7259 1.664 0.8 13.312 37
I7259 7259 0 1.26158e-05
R8067 7259 7260 1.712 0.8 13.696 37
I7260 7260 0 1.24921e-05
R8068 7260 7261 1.6 0.8 12.8 37
I7261 7261 0 1.29868e-05
R8069 7261 7262 1.648 0.8 13.184 37
I7262 7262 0 1.28631e-05
R8070 7262 7263 1.728 0.8 13.824 37
I7263 7263 0 1.24921e-05
R8071 7263 7264 1.744 0.8 13.952 37
I7264 7264 0 1.33579e-05
R8072 7264 7265 1.744 0.8 13.952 37
I7265 7265 0 1.33579e-05
R8073 7265 7266 1.728 0.8 13.824 37
I7266 7266 0 1.23684e-05
R8074 7266 7267 1.6 0.8 12.8 37
I7267 7267 0 1.29868e-05
R8075 7267 7268 1.648 0.8 13.184 37
I7268 7268 0 1.27395e-05
R8076 7268 7269 1.632 0.8 13.056 37
I7269 7269 0 1.23684e-05
R8077 7269 7270 1.68 0.8 13.44 37
I7270 7270 0 1.26158e-05
R8078 7270 7271 1.664 0.8 13.312 37
I7271 7271 0 1.28631e-05
R8079 7271 7272 1.712 0.8 13.696 37
I7272 7272 0 1.31105e-05
R8080 7272 7273 1.744 0.8 13.952 37
I7273 7273 0 1.29868e-05
R8081 7273 7274 1.664 0.8 13.312 37
I7274 7274 0 1.31105e-05
R8082 7274 7275 1.728 0.8 13.824 37
I7275 7275 0 1.24921e-05
R8083 7275 7276 1.744 0.8 13.952 37
I7276 7276 0 1.33579e-05
R8084 7276 7277 1.744 0.8 13.952 37
I7277 7277 0 1.26158e-05
R8085 7277 7278 1.664 0.8 13.312 37
I7278 7278 0 1.34816e-05
R8086 7278 7279 1.648 0.8 13.184 37
I7279 7279 0 1.27395e-05
R8087 7279 7280 1.712 0.8 13.696 37
I7280 7280 0 1.26158e-05
R8088 7280 7281 1.648 0.8 13.184 37
I7281 7281 0 1.32342e-05
R8089 7281 7282 1.68 0.8 13.44 37
I7282 7282 0 1.29868e-05
R8090 7282 7283 1.664 0.8 13.312 37
I7283 7283 0 1.33579e-05
R8091 7283 7284 1.728 0.8 13.824 37
I7284 7284 0 1.34816e-05
R8092 7284 7285 1.6 0.8 12.8 37
I7285 7285 0 1.31105e-05
R8093 7285 7286 1.616 0.8 12.928 37
I7286 7286 0 1.29868e-05
R8094 7286 7287 1.632 0.8 13.056 37
I7287 7287 0 1.33579e-05
R8095 7287 7288 1.648 0.8 13.184 37
I7288 7288 0 1.26158e-05
R8096 7288 7289 1.664 0.8 13.312 37
I7289 7289 0 1.32342e-05
R8097 7289 7290 1.6 0.8 12.8 37
I7290 7290 0 1.28631e-05
R8098 7290 7291 1.6 0.8 12.8 37
I7291 7291 0 1.34816e-05
R8099 7291 7292 1.632 0.8 13.056 37
I7292 7292 0 1.34816e-05
R8100 7292 7293 1.616 0.8 12.928 37
I7293 7293 0 1.31105e-05
R8101 7293 7294 1.744 0.8 13.952 37
I7294 7294 0 1.31105e-05
R8102 7294 7295 1.744 0.8 13.952 37
I7295 7295 0 1.33579e-05
R8103 7295 7296 1.6 0.8 12.8 37
I7296 7296 0 1.26158e-05
R8104 7296 7297 1.728 0.8 13.824 37
I7297 7297 0 1.29868e-05
R8105 7297 7298 1.712 0.8 13.696 37
I7298 7298 0 1.26158e-05
R8106 7298 7299 1.696 0.8 13.568 37
I7299 7299 0 1.32342e-05
R8107 7299 7300 1.616 0.8 12.928 37
I7300 7300 0 1.31105e-05
R8108 7300 7301 1.68 0.8 13.44 37
I7301 7301 0 1.28631e-05
R8109 7301 7302 1.648 0.8 13.184 37
I7302 7302 0 1.33579e-05
R8110 7302 7303 1.68 0.8 13.44 37
I7303 7303 0 1.33579e-05
R8111 7303 7304 1.632 0.8 13.056 37
I7304 7304 0 1.24921e-05
R8112 7304 7305 1.68 0.8 13.44 37
I7305 7305 0 1.26158e-05
R8113 7305 7306 1.68 0.8 13.44 37
I7306 7306 0 1.33579e-05
R8114 7306 7307 1.648 0.8 13.184 37
I7307 7307 0 1.32342e-05
R8115 7307 7308 1.712 0.8 13.696 37
I7308 7308 0 1.28631e-05
R8116 7308 7309 1.68 0.8 13.44 37
I7309 7309 0 1.31105e-05
R8117 7309 7310 1.6 0.8 12.8 37
I7310 7310 0 1.28631e-05
R8118 7310 7311 1.712 0.8 13.696 37
I7311 7311 0 1.26158e-05
R8119 7311 7312 1.728 0.8 13.824 37
I7312 7312 0 1.29868e-05
R8120 7312 7313 1.728 0.8 13.824 37
I7313 7313 0 1.32342e-05
R8121 7313 7314 1.744 0.8 13.952 37
I7314 7314 0 1.28631e-05
R8122 7314 7315 1.696 0.8 13.568 37
I7315 7315 0 1.27395e-05
R8123 7315 7316 1.632 0.8 13.056 37
I7316 7316 0 1.26158e-05
R8124 7316 7317 1.712 0.8 13.696 37
I7317 7317 0 1.33579e-05
R8125 7317 7318 1.632 0.8 13.056 37
I7318 7318 0 1.26158e-05
R8126 7318 7319 1.696 0.8 13.568 37
I7319 7319 0 1.28631e-05
R8127 7319 7320 1.68 0.8 13.44 37
I7320 7320 0 1.28631e-05
R8128 7320 7321 1.728 0.8 13.824 37
I7321 7321 0 1.23684e-05
R8129 7321 7322 1.632 0.8 13.056 37
I7322 7322 0 1.24921e-05
R8130 7322 7323 1.712 0.8 13.696 37
I7323 7323 0 1.24921e-05
R8131 7323 7324 1.712 0.8 13.696 37
I7324 7324 0 1.28631e-05
R8132 7324 7325 1.6 0.8 12.8 37
I7325 7325 0 1.34816e-05
R8133 7325 7326 1.728 0.8 13.824 37
I7326 7326 0 1.32342e-05
R8134 7326 7327 1.616 0.8 12.928 37
I7327 7327 0 1.33579e-05
R8135 7327 7328 1.632 0.8 13.056 37
I7328 7328 0 1.24921e-05
R8136 7328 7329 1.712 0.8 13.696 37
I7329 7329 0 1.27395e-05
R8137 7329 7330 1.68 0.8 13.44 37
I7330 7330 0 1.28631e-05
R8138 7330 7331 1.696 0.8 13.568 37
I7331 7331 0 1.23684e-05
R8139 7331 7332 1.728 0.8 13.824 37
I7332 7332 0 1.31105e-05
R8140 7332 7333 1.6 0.8 12.8 37
I7333 7333 0 1.23684e-05
R8141 7333 7334 1.6 0.8 12.8 37
I7334 7334 0 1.31105e-05
R8142 7334 7335 1.696 0.8 13.568 37
I7335 7335 0 1.31105e-05
R8143 7335 7336 1.632 0.8 13.056 37
I7336 7336 0 1.31105e-05
R8144 7336 7337 1.696 0.8 13.568 37
I7337 7337 0 1.28631e-05
R8145 7337 7338 1.712 0.8 13.696 37
I7338 7338 0 1.31105e-05
R8146 7338 7339 1.696 0.8 13.568 37
I7339 7339 0 1.31105e-05
R8147 7339 7340 1.6 0.8 12.8 37
I7340 7340 0 1.31105e-05
R8148 7340 7341 1.68 0.8 13.44 37
I7341 7341 0 1.24921e-05
R8149 7341 7342 1.68 0.8 13.44 37
I7342 7342 0 1.33579e-05
R8150 7342 7343 1.744 0.8 13.952 37
I7343 7343 0 1.34816e-05
R8151 7343 7344 1.6 0.8 12.8 37
I7344 7344 0 1.32342e-05
R8152 7344 7345 1.632 0.8 13.056 37
I7345 7345 0 1.32342e-05
R8153 7345 7346 1.648 0.8 13.184 37
I7346 7346 0 1.24921e-05
R8154 7346 7347 1.712 0.8 13.696 37
I7347 7347 0 1.24921e-05
R8155 7347 7348 1.712 0.8 13.696 37
I7348 7348 0 1.32342e-05
R8156 7348 7349 1.648 0.8 13.184 37
I7349 7349 0 1.32342e-05
R8157 7349 7350 1.696 0.8 13.568 37
I7350 7350 0 1.34816e-05
R8158 7350 7351 1.648 0.8 13.184 37
I7351 7351 0 1.33579e-05
R8159 7351 7352 1.68 0.8 13.44 37
I7352 7352 0 1.26158e-05
R8160 7352 7353 1.68 0.8 13.44 37
I7353 7353 0 1.28631e-05
R8161 7353 7354 1.728 0.8 13.824 37
I7354 7354 0 1.24921e-05
R8162 7354 7355 1.6 0.8 12.8 37
I7355 7355 0 1.23684e-05
R8163 7355 7356 1.744 0.8 13.952 37
I7356 7356 0 1.32342e-05
R8164 7356 7357 1.616 0.8 12.928 37
I7357 7357 0 1.28631e-05
R8165 7357 7358 1.68 0.8 13.44 37
I7358 7358 0 1.27395e-05
R8166 7358 7359 1.648 0.8 13.184 37
I7359 7359 0 1.29868e-05
R8167 7359 7360 1.632 0.8 13.056 37
I7360 7360 0 1.32342e-05
R8168 7360 7361 1.648 0.8 13.184 37
I7361 7361 0 1.32342e-05
R8169 7361 7362 1.728 0.8 13.824 37
I7362 7362 0 1.26158e-05
R8170 7362 7363 1.728 0.8 13.824 37
I7363 7363 0 1.29868e-05
R8171 7363 7364 1.632 0.8 13.056 37
I7364 7364 0 1.27395e-05
R8172 7364 7365 1.68 0.8 13.44 37
I7365 7365 0 1.33579e-05
R8173 7365 7366 1.664 0.8 13.312 37
I7366 7366 0 1.23684e-05
R8174 7366 7367 1.728 0.8 13.824 37
I7367 7367 0 1.24921e-05
R8175 7367 7368 1.632 0.8 13.056 37
I7368 7368 0 1.27395e-05
R8176 7368 7369 1.712 0.8 13.696 37
I7369 7369 0 1.26158e-05
R8177 7369 7370 1.664 0.8 13.312 37
I7370 7370 0 1.32342e-05
R8178 7370 7371 1.648 0.8 13.184 37
I7371 7371 0 1.29868e-05
R8179 7371 7372 1.696 0.8 13.568 37
I7372 7372 0 1.31105e-05
R8180 7372 7373 1.744 0.8 13.952 37
I7373 7373 0 1.27395e-05
R8181 7373 7374 1.616 0.8 12.928 37
I7374 7374 0 1.28631e-05
R8182 7374 7375 1.616 0.8 12.928 37
I7375 7375 0 1.27395e-05
R8183 7375 7376 1.632 0.8 13.056 37
I7376 7376 0 1.28631e-05
R8184 7376 7377 1.6 0.8 12.8 37
I7377 7377 0 1.23684e-05
R8185 7377 7378 1.728 0.8 13.824 37
I7378 7378 0 1.23684e-05
R8186 7378 7379 1.728 0.8 13.824 37
I7379 7379 0 1.23684e-05
R8187 7379 7380 1.648 0.8 13.184 37
I7380 7380 0 1.27395e-05
R8188 7380 7381 1.6 0.8 12.8 37
I7381 7381 0 1.34816e-05
R8189 7381 7382 1.648 0.8 13.184 37
I7382 7382 0 1.34816e-05
R8190 7382 7383 1.6 0.8 12.8 37
I7383 7383 0 1.33579e-05
R8191 7383 7384 1.632 0.8 13.056 37
I7384 7384 0 1.32342e-05
R8192 7384 7385 1.6 0.8 12.8 37
I7385 7385 0 1.34816e-05
R8193 7385 7386 1.696 0.8 13.568 37
I7386 7386 0 1.29868e-05
R8194 7386 7387 1.664 0.8 13.312 37
I7387 7387 0 1.28631e-05
R8195 7387 7388 1.632 0.8 13.056 37
I7388 7388 0 1.31105e-05
R8196 7388 7389 1.728 0.8 13.824 37
I7389 7389 0 1.27395e-05
R8197 7389 7390 1.6 0.8 12.8 37
I7390 7390 0 1.34816e-05
R8198 7390 7391 1.744 0.8 13.952 37
I7391 7391 0 1.28631e-05
R8199 7391 7392 1.68 0.8 13.44 37
I7392 7392 0 1.24921e-05
R8200 7392 7393 1.712 0.8 13.696 37
I7393 7393 0 1.29868e-05
R8201 7393 7394 1.632 0.8 13.056 37
I7394 7394 0 1.29868e-05
R8202 7394 7395 1.696 0.8 13.568 37
I7395 7395 0 1.32342e-05
R8203 7395 7396 1.6 0.8 12.8 37
I7396 7396 0 1.33579e-05
R8204 7396 7397 1.744 0.8 13.952 37
I7397 7397 0 1.27395e-05
R8205 7397 7398 1.744 0.8 13.952 37
I7398 7398 0 1.34816e-05
R8206 7398 7399 1.648 0.8 13.184 37
I7399 7399 0 1.26158e-05
R8207 7399 7400 1.744 0.8 13.952 37
I7400 7400 0 1.28631e-05
R8208 7400 7401 1.648 0.8 13.184 37
I7401 7401 0 1.29868e-05
R8209 7401 7402 1.744 0.8 13.952 37
I7402 7402 0 1.32342e-05
R8210 7402 7403 1.6 0.8 12.8 37
I7403 7403 0 1.27395e-05
R8211 7403 7404 1.68 0.8 13.44 37
I7404 7404 0 1.23684e-05
R8212 7404 7405 1.744 0.8 13.952 37
I7405 7405 0 1.31105e-05
R8213 7405 7406 1.744 0.8 13.952 37
I7406 7406 0 1.23684e-05
R8214 7406 7407 1.632 0.8 13.056 37
I7407 7407 0 1.31105e-05
R8215 7407 7408 1.616 0.8 12.928 37
I7408 7408 0 1.34816e-05
R8216 7408 7409 1.616 0.8 12.928 37
I7409 7409 0 1.29868e-05
R8217 7409 7410 1.696 0.8 13.568 37
I7410 7410 0 1.34816e-05
R8218 7410 7411 1.68 0.8 13.44 37
I7411 7411 0 1.33579e-05
R8219 7411 7412 1.728 0.8 13.824 37
I7412 7412 0 1.28631e-05
R8220 7412 7413 1.632 0.8 13.056 37
I7413 7413 0 1.32342e-05
R8221 7413 7414 1.648 0.8 13.184 37
I7414 7414 0 1.32342e-05
R8222 7414 7415 1.616 0.8 12.928 37
I7415 7415 0 1.26158e-05
R8223 7415 7416 1.616 0.8 12.928 37
I7416 7416 0 1.28631e-05
R8224 7416 7417 1.6 0.8 12.8 37
I7417 7417 0 1.27395e-05
R8225 7417 7418 1.664 0.8 13.312 37
I7418 7418 0 1.26158e-05
R8226 7418 7419 1.728 0.8 13.824 37
I7419 7419 0 1.34816e-05
R8227 7419 7420 1.632 0.8 13.056 37
I7420 7420 0 1.32342e-05
R8228 7420 7421 1.712 0.8 13.696 37
I7421 7421 0 1.27395e-05
R8229 7421 7422 1.712 0.8 13.696 37
I7422 7422 0 1.23684e-05
R8230 7422 7423 1.744 0.8 13.952 37
I7423 7423 0 1.24921e-05
R8231 7423 7424 1.616 0.8 12.928 37
I7424 7424 0 1.23684e-05
R8232 7424 7425 1.696 0.8 13.568 37
I7425 7425 0 1.23684e-05
R8233 7425 7426 1.6 0.8 12.8 37
I7426 7426 0 1.24921e-05
R8234 7426 7427 1.728 0.8 13.824 37
I7427 7427 0 1.23684e-05
R8235 7427 7428 1.68 0.8 13.44 37
I7428 7428 0 1.26158e-05
R8236 7428 7429 1.744 0.8 13.952 37
I7429 7429 0 1.24921e-05
R8237 7429 7430 1.6 0.8 12.8 37
I7430 7430 0 1.27395e-05
R8238 7430 7431 1.68 0.8 13.44 37
I7431 7431 0 1.27395e-05
R8239 7431 7432 1.744 0.8 13.952 37
I7432 7432 0 1.29868e-05
R8240 7432 7433 1.696 0.8 13.568 37
I7433 7433 0 1.27395e-05
R8241 7433 7434 1.744 0.8 13.952 37
I7434 7434 0 1.29868e-05
R8242 7434 7435 1.648 0.8 13.184 37
I7435 7435 0 1.24921e-05
R8243 7435 7436 1.664 0.8 13.312 37
I7436 7436 0 1.26158e-05
R8244 7436 7437 1.664 0.8 13.312 37
I7437 7437 0 1.28631e-05
R8245 7437 7438 1.664 0.8 13.312 37
I7438 7438 0 1.27395e-05
R8246 7438 7439 1.68 0.8 13.44 37
I7439 7439 0 1.31105e-05
R8247 7439 7440 1.696 0.8 13.568 37
I7440 7440 0 1.24921e-05
R8248 7440 7441 1.728 0.8 13.824 37
I7441 7441 0 1.33579e-05
R8249 7441 7442 1.68 0.8 13.44 37
I7442 7442 0 1.31105e-05
R8250 7442 7443 1.6 0.8 12.8 37
I7443 7443 0 1.26158e-05
R8251 7443 7444 1.616 0.8 12.928 37
I7444 7444 0 1.24921e-05
R8252 7444 7445 1.648 0.8 13.184 37
I7445 7445 0 1.24921e-05
R8253 7445 7446 1.664 0.8 13.312 37
I7446 7446 0 1.24921e-05
R8254 7446 7447 1.664 0.8 13.312 37
I7447 7447 0 1.28631e-05
R8255 7447 7448 1.728 0.8 13.824 37
I7448 7448 0 1.27395e-05
R8256 7448 7449 1.744 0.8 13.952 37
I7449 7449 0 1.33579e-05
R8257 7449 7450 1.728 0.8 13.824 37
I7450 7450 0 1.28631e-05
R8258 7450 7451 1.744 0.8 13.952 37
I7451 7451 0 1.28631e-05
R8259 7451 7452 1.712 0.8 13.696 37
I7452 7452 0 1.31105e-05
R8260 7452 7453 1.728 0.8 13.824 37
I7453 7453 0 1.24921e-05
R8261 7453 7454 1.616 0.8 12.928 37
I7454 7454 0 1.27395e-05
R8262 7454 7455 1.744 0.8 13.952 37
I7455 7455 0 1.32342e-05
R8263 7455 7456 1.712 0.8 13.696 37
I7456 7456 0 1.32342e-05
R8264 7456 7457 1.712 0.8 13.696 37
I7457 7457 0 1.26158e-05
R8265 7457 7458 1.696 0.8 13.568 37
I7458 7458 0 1.32342e-05
R8266 7458 7459 1.664 0.8 13.312 37
I7459 7459 0 1.32342e-05
R8267 7459 7460 1.616 0.8 12.928 37
I7460 7460 0 1.23684e-05
R8268 7460 7461 1.6 0.8 12.8 37
I7461 7461 0 1.29868e-05
R8269 7461 7462 1.616 0.8 12.928 37
I7462 7462 0 1.28631e-05
R8270 7462 7463 1.616 0.8 12.928 37
I7463 7463 0 1.34816e-05
R8271 7463 7464 1.744 0.8 13.952 37
I7464 7464 0 1.24921e-05
R8272 7464 7465 1.712 0.8 13.696 37
I7465 7465 0 1.34816e-05
R8273 7465 7466 1.712 0.8 13.696 37
I7466 7466 0 1.34816e-05
R8274 7466 7467 1.664 0.8 13.312 37
I7467 7467 0 1.28631e-05
R8275 7467 7468 1.712 0.8 13.696 37
I7468 7468 0 1.26158e-05
R8276 7468 7469 1.728 0.8 13.824 37
I7469 7469 0 1.33579e-05
R8277 7469 7470 1.728 0.8 13.824 37
I7470 7470 0 1.32342e-05
R8278 7470 7471 1.728 0.8 13.824 37
I7471 7471 0 1.29868e-05
R8279 7471 7472 1.712 0.8 13.696 37
I7472 7472 0 1.29868e-05
R8280 7472 7473 1.744 0.8 13.952 37
I7473 7473 0 1.29868e-05
R8281 7473 7474 1.68 0.8 13.44 37
I7474 7474 0 1.27395e-05
R8282 7474 7475 1.632 0.8 13.056 37
I7475 7475 0 1.33579e-05
R8283 7475 7476 1.68 0.8 13.44 37
I7476 7476 0 1.26158e-05
R8284 7476 7477 1.648 0.8 13.184 37
I7477 7477 0 1.31105e-05
R8285 7477 7478 1.728 0.8 13.824 37
I7478 7478 0 1.32342e-05
R8286 7478 7479 1.728 0.8 13.824 37
I7479 7479 0 1.33579e-05
R8287 7479 7480 1.6 0.8 12.8 37
I7480 7480 0 1.32342e-05
R8288 7480 7481 1.712 0.8 13.696 37
I7481 7481 0 1.32342e-05
R8289 7481 7482 1.696 0.8 13.568 37
I7482 7482 0 1.27395e-05
R8290 7482 7483 1.664 0.8 13.312 37
I7483 7483 0 1.27395e-05
R8291 7483 7484 1.696 0.8 13.568 37
I7484 7484 0 1.26158e-05
R8292 7484 7485 1.664 0.8 13.312 37
I7485 7485 0 1.31105e-05
R8293 7485 7486 1.616 0.8 12.928 37
I7486 7486 0 1.26158e-05
R8294 7486 7487 1.616 0.8 12.928 37
I7487 7487 0 1.23684e-05
R8295 7487 7488 1.744 0.8 13.952 37
I7488 7488 0 1.23684e-05
R8296 7488 7489 1.68 0.8 13.44 37
I7489 7489 0 1.31105e-05
R8297 7489 7490 1.68 0.8 13.44 37
I7490 7490 0 1.34816e-05
R8298 7490 7491 1.664 0.8 13.312 37
I7491 7491 0 1.27395e-05
R8299 7491 7492 1.616 0.8 12.928 37
I7492 7492 0 1.23684e-05
R8300 7492 7493 1.616 0.8 12.928 37
I7493 7493 0 1.26158e-05
R8301 7493 7494 1.712 0.8 13.696 37
I7494 7494 0 1.34816e-05
R8302 7494 7495 1.632 0.8 13.056 37
I7495 7495 0 1.34816e-05
R8303 7495 7496 1.712 0.8 13.696 37
I7496 7496 0 1.24921e-05
R8304 7496 7497 1.696 0.8 13.568 37
I7497 7497 0 1.29868e-05
R8305 7497 7498 1.68 0.8 13.44 37
I7498 7498 0 1.26158e-05
R8306 7498 7499 1.744 0.8 13.952 37
I7499 7499 0 1.27395e-05
R8307 7499 7500 1.696 0.8 13.568 37
I7500 7500 0 1.29868e-05
R8308 7500 7501 1.744 0.8 13.952 37
I7501 7501 0 1.33579e-05
R8309 7501 7502 1.712 0.8 13.696 37
I7502 7502 0 1.26158e-05
R8310 7502 7503 1.6 0.8 12.8 37
I7503 7503 0 1.31105e-05
R8311 7503 7504 1.664 0.8 13.312 37
I7504 7504 0 1.31105e-05
R8312 7504 7505 1.68 0.8 13.44 37
I7505 7505 0 1.24921e-05
R8313 7505 7506 1.68 0.8 13.44 37
I7506 7506 0 1.34816e-05
R8314 7506 7507 1.664 0.8 13.312 37
I7507 7507 0 1.34816e-05
R8315 7507 7508 1.616 0.8 12.928 37
I7508 7508 0 1.31105e-05
R8316 7508 7509 1.648 0.8 13.184 37
I7509 7509 0 1.23684e-05
R8317 7509 7510 1.68 0.8 13.44 37
I7510 7510 0 1.29868e-05
R8318 7510 7511 1.744 0.8 13.952 37
I7511 7511 0 1.28631e-05
R8319 7511 7512 1.696 0.8 13.568 37
I7512 7512 0 1.33579e-05
R8320 7512 7513 1.6 0.8 12.8 37
I7513 7513 0 1.27395e-05
R8321 7513 7514 1.6 0.8 12.8 37
I7514 7514 0 1.24921e-05
R8322 7514 7515 1.696 0.8 13.568 37
I7515 7515 0 1.32342e-05
R8323 7515 7516 1.696 0.8 13.568 37
I7516 7516 0 1.32342e-05
R8324 7516 7517 1.712 0.8 13.696 37
I7517 7517 0 1.29868e-05
R8325 7517 7518 1.744 0.8 13.952 37
I7518 7518 0 1.34816e-05
R8326 7518 7519 1.648 0.8 13.184 37
I7519 7519 0 1.27395e-05
R8327 7519 7520 1.68 0.8 13.44 37
I7520 7520 0 1.33579e-05
R8328 7520 7521 1.68 0.8 13.44 37
I7521 7521 0 1.27395e-05
R8329 7521 7522 1.6 0.8 12.8 37
I7522 7522 0 1.24921e-05
R8330 7522 7523 1.664 0.8 13.312 37
I7523 7523 0 1.24921e-05
R8331 7523 7524 1.712 0.8 13.696 37
I7524 7524 0 1.32342e-05
R8332 7524 7525 1.632 0.8 13.056 37
I7525 7525 0 1.29868e-05
R8333 7525 7526 1.664 0.8 13.312 37
I7526 7526 0 1.24921e-05
R8334 7526 7527 1.744 0.8 13.952 37
I7527 7527 0 1.26158e-05
R8335 7527 7528 1.744 0.8 13.952 37
I7528 7528 0 1.24921e-05
R8336 7528 7529 1.696 0.8 13.568 37
I7529 7529 0 1.26158e-05
R8337 7529 7530 1.632 0.8 13.056 37
I7530 7530 0 1.28631e-05
R8338 7530 7531 1.744 0.8 13.952 37
I7531 7531 0 1.23684e-05
R8339 7531 7532 1.632 0.8 13.056 37
I7532 7532 0 1.33579e-05
R8340 7532 7533 1.68 0.8 13.44 37
I7533 7533 0 1.27395e-05
R8341 7533 7534 1.712 0.8 13.696 37
I7534 7534 0 1.34816e-05
R8342 7534 7535 1.744 0.8 13.952 37
I7535 7535 0 1.29868e-05
R8343 7535 7536 1.712 0.8 13.696 37
I7536 7536 0 1.28631e-05
R8344 7536 7537 1.6 0.8 12.8 37
I7537 7537 0 1.32342e-05
R8345 7537 7538 1.68 0.8 13.44 37
I7538 7538 0 1.28631e-05
R8346 7538 7539 1.616 0.8 12.928 37
I7539 7539 0 1.29868e-05
R8347 7539 7540 1.648 0.8 13.184 37
I7540 7540 0 1.27395e-05
R8348 7540 7541 1.6 0.8 12.8 37
I7541 7541 0 1.34816e-05
R8349 7541 7542 1.696 0.8 13.568 37
I7542 7542 0 1.24921e-05
R8350 7542 7543 1.616 0.8 12.928 37
I7543 7543 0 1.31105e-05
R8351 7543 7544 1.648 0.8 13.184 37
I7544 7544 0 1.34816e-05
R8352 7544 7545 1.6 0.8 12.8 37
I7545 7545 0 1.29868e-05
R8353 7545 7546 1.664 0.8 13.312 37
I7546 7546 0 1.34816e-05
R8354 7546 7547 1.728 0.8 13.824 37
I7547 7547 0 1.33579e-05
R8355 7547 7548 1.744 0.8 13.952 37
I7548 7548 0 1.27395e-05
R8356 7548 7549 1.616 0.8 12.928 37
I7549 7549 0 1.31105e-05
R8357 7549 7550 1.632 0.8 13.056 37
I7550 7550 0 1.26158e-05
R8358 7550 7551 1.648 0.8 13.184 37
I7551 7551 0 1.26158e-05
R8359 7551 7552 1.696 0.8 13.568 37
I7552 7552 0 1.27395e-05
R8360 7552 7553 1.616 0.8 12.928 37
I7553 7553 0 1.28631e-05
R8361 7553 7554 1.744 0.8 13.952 37
I7554 7554 0 1.26158e-05
R8362 7554 7555 1.616 0.8 12.928 37
I7555 7555 0 1.26158e-05
R8363 7555 7556 1.712 0.8 13.696 37
I7556 7556 0 1.24921e-05
R8364 7556 7557 1.616 0.8 12.928 37
I7557 7557 0 1.28631e-05
R8365 7557 7558 1.632 0.8 13.056 37
I7558 7558 0 1.29868e-05
R8366 7558 7559 1.632 0.8 13.056 37
I7559 7559 0 1.32342e-05
R8367 7559 7560 1.664 0.8 13.312 37
I7560 7560 0 1.26158e-05
R8368 7560 7561 1.68 0.8 13.44 37
I7561 7561 0 1.23684e-05
R8369 7561 7562 1.648 0.8 13.184 37
I7562 7562 0 1.27395e-05
R8370 7562 7563 1.728 0.8 13.824 37
I7563 7563 0 1.26158e-05
R8371 7563 7564 1.696 0.8 13.568 37
I7564 7564 0 1.26158e-05
R8372 7564 7565 1.6 0.8 12.8 37
I7565 7565 0 1.24921e-05
R8373 7565 7566 1.664 0.8 13.312 37
I7566 7566 0 1.28631e-05
R8374 7566 7567 1.68 0.8 13.44 37
I7567 7567 0 1.27395e-05
R8375 7567 7568 1.712 0.8 13.696 37
I7568 7568 0 1.33579e-05
R8376 7568 7569 1.744 0.8 13.952 37
I7569 7569 0 1.32342e-05
R8377 7569 7570 1.616 0.8 12.928 37
I7570 7570 0 1.23684e-05
R8378 7570 7571 1.616 0.8 12.928 37
I7571 7571 0 1.23684e-05
R8379 7571 7572 1.648 0.8 13.184 37
I7572 7572 0 1.27395e-05
R8380 7572 7573 1.664 0.8 13.312 37
I7573 7573 0 1.32342e-05
R8381 7573 7574 1.728 0.8 13.824 37
I7574 7574 0 1.31105e-05
R8382 7574 7575 1.68 0.8 13.44 37
I7575 7575 0 1.28631e-05
R8383 7575 7576 1.728 0.8 13.824 37
I7576 7576 0 1.23684e-05
R8384 7576 7577 1.68 0.8 13.44 37
I7577 7577 0 1.24921e-05
R8385 7577 7578 1.68 0.8 13.44 37
I7578 7578 0 1.29868e-05
R8386 7578 7579 1.68 0.8 13.44 37
I7579 7579 0 1.27395e-05
R8387 7579 7580 1.744 0.8 13.952 37
I7580 7580 0 1.31105e-05
R8388 7580 7581 1.664 0.8 13.312 37
I7581 7581 0 1.31105e-05
R8389 7581 7582 1.6 0.8 12.8 37
I7582 7582 0 1.24921e-05
R8390 7582 7583 1.744 0.8 13.952 37
I7583 7583 0 1.32342e-05
R8391 7583 7584 1.6 0.8 12.8 37
I7584 7584 0 1.23684e-05
R8392 7584 7585 1.696 0.8 13.568 37
I7585 7585 0 1.27395e-05
R8393 7585 7586 1.6 0.8 12.8 37
I7586 7586 0 1.33579e-05
R8394 7586 7587 1.648 0.8 13.184 37
I7587 7587 0 1.27395e-05
R8395 7587 7588 1.648 0.8 13.184 37
I7588 7588 0 1.33579e-05
R8396 7588 7589 1.6 0.8 12.8 37
I7589 7589 0 1.27395e-05
R8397 7589 7590 1.696 0.8 13.568 37
I7590 7590 0 1.32342e-05
R8398 7590 7591 1.712 0.8 13.696 37
I7591 7591 0 1.32342e-05
R8399 7591 7592 1.712 0.8 13.696 37
I7592 7592 0 1.28631e-05
R8400 7592 7593 1.6 0.8 12.8 37
I7593 7593 0 1.26158e-05
R8401 7593 7594 1.6 0.8 12.8 37
I7594 7594 0 1.31105e-05
R8402 7594 7595 1.696 0.8 13.568 37
I7595 7595 0 1.24921e-05
R8403 7595 7596 1.632 0.8 13.056 37
I7596 7596 0 1.26158e-05
R8404 7596 7597 1.712 0.8 13.696 37
I7597 7597 0 1.28631e-05
R8405 7597 7598 1.664 0.8 13.312 37
I7598 7598 0 1.33579e-05
R8406 7598 7599 1.616 0.8 12.928 37
I7599 7599 0 1.31105e-05
R8407 7599 7600 1.728 0.8 13.824 37
I7600 7600 0 1.23684e-05
R8408 7600 7601 1.744 0.8 13.952 37
I7601 7601 0 1.23684e-05
R8409 7601 7602 1.728 0.8 13.824 37
I7602 7602 0 1.28631e-05
R8410 7602 7603 1.68 0.8 13.44 37
I7603 7603 0 1.27395e-05
R8411 7603 7604 1.632 0.8 13.056 37
I7604 7604 0 1.31105e-05
R8412 7604 7605 1.696 0.8 13.568 37
I7605 7605 0 1.24921e-05
R8413 7605 7606 1.68 0.8 13.44 37
I7606 7606 0 1.29868e-05
R8414 7606 7607 1.728 0.8 13.824 37
I7607 7607 0 1.27395e-05
R8415 7607 7608 1.6 0.8 12.8 37
I7608 7608 0 1.33579e-05
R8416 7608 7609 1.712 0.8 13.696 37
I7609 7609 0 1.26158e-05
R8417 7609 7610 1.664 0.8 13.312 37
I7610 7610 0 1.29868e-05
R8418 7610 7611 1.648 0.8 13.184 37
I7611 7611 0 1.33579e-05
R8419 7611 7612 1.728 0.8 13.824 37
I7612 7612 0 1.24921e-05
R8420 7612 7613 1.632 0.8 13.056 37
I7613 7613 0 1.28631e-05
R8421 7613 7614 1.744 0.8 13.952 37
I7614 7614 0 1.31105e-05
R8422 7614 7615 1.632 0.8 13.056 37
I7615 7615 0 1.23684e-05
R8423 7615 7616 1.696 0.8 13.568 37
I7616 7616 0 1.24921e-05
R8424 7616 7617 1.6 0.8 12.8 37
I7617 7617 0 1.31105e-05
R8425 7617 7618 1.68 0.8 13.44 37
I7618 7618 0 1.33579e-05
R8426 7618 7619 1.744 0.8 13.952 37
I7619 7619 0 1.23684e-05
R8427 7619 7620 1.696 0.8 13.568 37
I7620 7620 0 1.32342e-05
R8428 7620 7621 1.648 0.8 13.184 37
I7621 7621 0 1.24921e-05
R8429 7621 7622 1.632 0.8 13.056 37
I7622 7622 0 1.24921e-05
R8430 7622 7623 1.664 0.8 13.312 37
I7623 7623 0 1.26158e-05
R8431 7623 7624 1.616 0.8 12.928 37
I7624 7624 0 1.28631e-05
R8432 7624 7625 1.664 0.8 13.312 37
I7625 7625 0 1.33579e-05
R8433 7625 7626 1.744 0.8 13.952 37
I7626 7626 0 1.33579e-05
R8434 7626 7627 1.696 0.8 13.568 37
I7627 7627 0 1.34816e-05
R8435 7627 7628 1.616 0.8 12.928 37
I7628 7628 0 1.34816e-05
R8436 7628 7629 1.68 0.8 13.44 37
I7629 7629 0 1.26158e-05
R8437 7629 7630 1.712 0.8 13.696 37
I7630 7630 0 1.32342e-05
R8438 7630 7631 1.664 0.8 13.312 37
I7631 7631 0 1.27395e-05
R8439 7631 7632 1.6 0.8 12.8 37
I7632 7632 0 1.32342e-05
R8440 7632 7633 1.616 0.8 12.928 37
I7633 7633 0 1.33579e-05
R8441 7633 7634 1.68 0.8 13.44 37
I7634 7634 0 1.26158e-05
R8442 7634 7635 1.6 0.8 12.8 37
I7635 7635 0 1.24921e-05
R8443 7635 7636 1.744 0.8 13.952 37
I7636 7636 0 1.27395e-05
R8444 7636 7637 1.632 0.8 13.056 37
I7637 7637 0 1.24921e-05
R8445 7637 7638 1.664 0.8 13.312 37
I7638 7638 0 1.34816e-05
R8446 7638 7639 1.664 0.8 13.312 37
I7639 7639 0 1.32342e-05
R8447 7639 7640 1.648 0.8 13.184 37
I7640 7640 0 1.23684e-05
R8448 7640 7641 1.68 0.8 13.44 37
I7641 7641 0 1.28631e-05
R8449 7641 7642 1.6 0.8 12.8 37
I7642 7642 0 1.26158e-05
R8450 7642 7643 1.696 0.8 13.568 37
I7643 7643 0 1.24921e-05
R8451 7643 7644 1.648 0.8 13.184 37
I7644 7644 0 1.24921e-05
R8452 7644 7645 1.696 0.8 13.568 37
I7645 7645 0 1.23684e-05
R8453 7645 7646 1.744 0.8 13.952 37
I7646 7646 0 1.23684e-05
R8454 7646 7647 1.68 0.8 13.44 37
I7647 7647 0 1.24921e-05
R8455 7647 7648 1.712 0.8 13.696 37
I7648 7648 0 1.31105e-05
R8456 7648 7649 1.744 0.8 13.952 37
I7649 7649 0 1.26158e-05
R8457 7649 7650 1.728 0.8 13.824 37
I7650 7650 0 1.34816e-05
R8458 7650 7651 1.648 0.8 13.184 37
I7651 7651 0 1.32342e-05
R8459 7651 7652 1.632 0.8 13.056 37
I7652 7652 0 1.33579e-05
R8460 7652 7653 1.6 0.8 12.8 37
I7653 7653 0 1.33579e-05
R8461 7653 7654 1.712 0.8 13.696 37
I7654 7654 0 1.28631e-05
R8462 7654 7655 1.696 0.8 13.568 37
I7655 7655 0 1.26158e-05
R8463 7655 7656 1.712 0.8 13.696 37
I7656 7656 0 1.24921e-05
R8464 7656 7657 1.696 0.8 13.568 37
I7657 7657 0 1.32342e-05
R8465 7657 7658 1.68 0.8 13.44 37
I7658 7658 0 1.26158e-05
R8466 7658 7659 1.616 0.8 12.928 37
I7659 7659 0 1.33579e-05
R8467 7659 7660 1.696 0.8 13.568 37
I7660 7660 0 1.32342e-05
R8468 7660 7661 1.6 0.8 12.8 37
I7661 7661 0 1.29868e-05
R8469 7661 7662 1.712 0.8 13.696 37
I7662 7662 0 1.29868e-05
R8470 7662 7663 1.696 0.8 13.568 37
I7663 7663 0 1.32342e-05
R8471 7663 7664 1.648 0.8 13.184 37
I7664 7664 0 1.33579e-05
R8472 7664 7665 1.744 0.8 13.952 37
I7665 7665 0 1.27395e-05
R8473 7665 7666 1.712 0.8 13.696 37
I7666 7666 0 1.29868e-05
R8474 7666 7667 1.6 0.8 12.8 37
I7667 7667 0 1.26158e-05
R8475 7667 7668 1.648 0.8 13.184 37
I7668 7668 0 1.27395e-05
R8476 7668 7669 1.6 0.8 12.8 37
I7669 7669 0 1.23684e-05
R8477 7669 7670 1.744 0.8 13.952 37
I7670 7670 0 1.33579e-05
R8478 7670 7671 1.632 0.8 13.056 37
I7671 7671 0 1.31105e-05
R8479 7671 7672 1.6 0.8 12.8 37
I7672 7672 0 1.23684e-05
R8480 7672 7673 1.664 0.8 13.312 37
I7673 7673 0 1.29868e-05
R8481 7673 7674 1.68 0.8 13.44 37
I7674 7674 0 1.32342e-05
R8482 7674 7675 1.696 0.8 13.568 37
I7675 7675 0 1.24921e-05
R8483 7675 7676 1.664 0.8 13.312 37
I7676 7676 0 1.31105e-05
R8484 7676 7677 1.728 0.8 13.824 37
I7677 7677 0 1.27395e-05
R8485 7677 7678 1.632 0.8 13.056 37
I7678 7678 0 1.31105e-05
R8486 7678 7679 1.6 0.8 12.8 37
I7679 7679 0 1.32342e-05
R8487 7679 7680 1.664 0.8 13.312 37
I7680 7680 0 1.23684e-05
R8488 7680 7681 1.616 0.8 12.928 37
I7681 7681 0 1.28631e-05
R8489 7681 7682 1.68 0.8 13.44 37
I7682 7682 0 1.27395e-05
R8490 7682 7683 1.696 0.8 13.568 37
I7683 7683 0 1.33579e-05
R8491 7683 7684 1.696 0.8 13.568 37
I7684 7684 0 1.33579e-05
R8492 7684 7685 1.6 0.8 12.8 37
I7685 7685 0 1.31105e-05
R8493 7685 7686 1.712 0.8 13.696 37
I7686 7686 0 1.28631e-05
R8494 7686 7687 1.632 0.8 13.056 37
I7687 7687 0 1.34816e-05
R8495 7687 7688 1.664 0.8 13.312 37
I7688 7688 0 1.33579e-05
R8496 7688 7689 1.696 0.8 13.568 37
I7689 7689 0 1.24921e-05
R8497 7689 7690 1.68 0.8 13.44 37
I7690 7690 0 1.26158e-05
R8498 7690 7691 1.664 0.8 13.312 37
I7691 7691 0 1.24921e-05
R8499 7691 7692 1.616 0.8 12.928 37
I7692 7692 0 1.28631e-05
R8500 7692 7693 1.68 0.8 13.44 37
I7693 7693 0 1.27395e-05
R8501 7693 7694 1.616 0.8 12.928 37
I7694 7694 0 1.29868e-05
R8502 7694 7695 1.6 0.8 12.8 37
I7695 7695 0 1.32342e-05
R8503 7695 7696 1.712 0.8 13.696 37
I7696 7696 0 1.27395e-05
R8504 7696 7697 1.616 0.8 12.928 37
I7697 7697 0 1.28631e-05
R8505 7697 7698 1.712 0.8 13.696 37
I7698 7698 0 1.34816e-05
R8506 7698 7699 1.664 0.8 13.312 37
I7699 7699 0 1.27395e-05
R8507 7699 7700 1.728 0.8 13.824 37
I7700 7700 0 1.31105e-05
R8508 7700 7701 1.744 0.8 13.952 37
I7701 7701 0 1.32342e-05
R8509 7701 7702 1.6 0.8 12.8 37
I7702 7702 0 1.28631e-05
R8510 7702 7703 1.696 0.8 13.568 37
I7703 7703 0 1.32342e-05
R8511 7703 7704 1.632 0.8 13.056 37
I7704 7704 0 1.28631e-05
R8512 7704 7705 1.6 0.8 12.8 37
I7705 7705 0 1.33579e-05
R8513 7705 7706 1.744 0.8 13.952 37
I7706 7706 0 1.29868e-05
R8514 7706 7707 1.616 0.8 12.928 37
I7707 7707 0 1.23684e-05
R8515 7707 7708 1.744 0.8 13.952 37
I7708 7708 0 1.31105e-05
R8516 7708 7709 1.648 0.8 13.184 37
I7709 7709 0 1.26158e-05
R8517 7709 7710 1.664 0.8 13.312 37
I7710 7710 0 1.29868e-05
R8518 7710 7711 1.6 0.8 12.8 37
I7711 7711 0 1.27395e-05
R8519 7711 7712 1.744 0.8 13.952 37
I7712 7712 0 1.24921e-05
R8520 7712 7713 1.6 0.8 12.8 37
I7713 7713 0 1.33579e-05
R8521 7713 7714 1.648 0.8 13.184 37
I7714 7714 0 1.31105e-05
R8522 7714 7715 1.616 0.8 12.928 37
I7715 7715 0 1.24921e-05
R8523 7715 7716 1.648 0.8 13.184 37
I7716 7716 0 1.27395e-05
R8524 7716 7717 1.6 0.8 12.8 37
I7717 7717 0 1.27395e-05
R8525 7717 7718 1.712 0.8 13.696 37
I7718 7718 0 1.31105e-05
R8526 7718 7719 1.632 0.8 13.056 37
I7719 7719 0 1.34816e-05
R8527 7719 7720 1.632 0.8 13.056 37
I7720 7720 0 1.27395e-05
R8528 7720 7721 1.744 0.8 13.952 37
I7721 7721 0 1.24921e-05
R8529 7721 7722 1.6 0.8 12.8 37
I7722 7722 0 1.24921e-05
R8530 7722 7723 1.616 0.8 12.928 37
I7723 7723 0 1.34816e-05
R8531 7723 7724 1.744 0.8 13.952 37
I7724 7724 0 1.31105e-05
R8532 7724 7725 1.632 0.8 13.056 37
I7725 7725 0 1.27395e-05
R8533 7725 7726 1.632 0.8 13.056 37
I7726 7726 0 1.28631e-05
R8534 7726 7727 1.744 0.8 13.952 37
I7727 7727 0 1.27395e-05
R8535 7727 7728 1.68 0.8 13.44 37
I7728 7728 0 1.34816e-05
R8536 7728 7729 1.616 0.8 12.928 37
I7729 7729 0 1.23684e-05
R8537 7729 7730 1.68 0.8 13.44 37
I7730 7730 0 1.28631e-05
R8538 7730 7731 1.616 0.8 12.928 37
I7731 7731 0 1.23684e-05
R8539 7731 7732 1.712 0.8 13.696 37
I7732 7732 0 1.24921e-05
R8540 7732 7733 1.664 0.8 13.312 37
I7733 7733 0 1.28631e-05
R8541 7733 7734 1.744 0.8 13.952 37
I7734 7734 0 1.33579e-05
R8542 7734 7735 1.696 0.8 13.568 37
I7735 7735 0 1.26158e-05
R8543 7735 7736 1.616 0.8 12.928 37
I7736 7736 0 1.29868e-05
R8544 7736 7737 1.648 0.8 13.184 37
I7737 7737 0 1.24921e-05
R8545 7737 7738 1.728 0.8 13.824 37
I7738 7738 0 1.32342e-05
R8546 7738 7739 1.648 0.8 13.184 37
I7739 7739 0 1.33579e-05
R8547 7739 7740 1.648 0.8 13.184 37
I7740 7740 0 1.32342e-05
R8548 7740 7741 1.648 0.8 13.184 37
I7741 7741 0 1.32342e-05
R8549 7741 7742 1.616 0.8 12.928 37
I7742 7742 0 1.26158e-05
R8550 7742 7743 1.632 0.8 13.056 37
I7743 7743 0 1.33579e-05
R8551 7743 7744 1.648 0.8 13.184 37
I7744 7744 0 1.29868e-05
R8552 7744 7745 1.744 0.8 13.952 37
I7745 7745 0 1.24921e-05
R8553 7745 7746 1.6 0.8 12.8 37
I7746 7746 0 1.26158e-05
R8554 7746 7747 1.616 0.8 12.928 37
I7747 7747 0 1.32342e-05
R8555 7747 7748 1.664 0.8 13.312 37
I7748 7748 0 1.32342e-05
R8556 7748 7749 1.632 0.8 13.056 37
I7749 7749 0 1.29868e-05
R8557 7749 7750 1.728 0.8 13.824 37
I7750 7750 0 1.33579e-05
R8558 7750 7751 1.744 0.8 13.952 37
I7751 7751 0 1.34816e-05
R8559 7751 7752 1.68 0.8 13.44 37
I7752 7752 0 1.29868e-05
R8560 7752 7753 1.648 0.8 13.184 37
I7753 7753 0 1.28631e-05
R8561 7753 7754 1.632 0.8 13.056 37
I7754 7754 0 1.33579e-05
R8562 7754 7755 1.664 0.8 13.312 37
I7755 7755 0 1.29868e-05
R8563 7755 7756 1.68 0.8 13.44 37
I7756 7756 0 1.34816e-05
R8564 7756 7757 1.68 0.8 13.44 37
I7757 7757 0 1.31105e-05
R8565 7757 7758 1.664 0.8 13.312 37
I7758 7758 0 1.32342e-05
R8566 7758 7759 1.696 0.8 13.568 37
I7759 7759 0 1.32342e-05
R8567 7759 7760 1.648 0.8 13.184 37
I7760 7760 0 1.29868e-05
R8568 7760 7761 1.6 0.8 12.8 37
I7761 7761 0 1.27395e-05
R8569 7761 7762 1.728 0.8 13.824 37
I7762 7762 0 1.28631e-05
R8570 7762 7763 1.632 0.8 13.056 37
I7763 7763 0 1.28631e-05
R8571 7763 7764 1.616 0.8 12.928 37
I7764 7764 0 1.31105e-05
R8572 7764 7765 1.616 0.8 12.928 37
I7765 7765 0 1.34816e-05
R8573 7765 7766 1.696 0.8 13.568 37
I7766 7766 0 1.24921e-05
R8574 7766 7767 1.616 0.8 12.928 37
I7767 7767 0 1.26158e-05
R8575 7767 7768 1.696 0.8 13.568 37
I7768 7768 0 1.31105e-05
R8576 7768 7769 1.728 0.8 13.824 37
I7769 7769 0 1.23684e-05
R8577 7769 7770 1.664 0.8 13.312 37
I7770 7770 0 1.28631e-05
R8578 7770 7771 1.712 0.8 13.696 37
I7771 7771 0 1.24921e-05
R8579 7771 7772 1.648 0.8 13.184 37
I7772 7772 0 1.26158e-05
R8580 7772 7773 1.744 0.8 13.952 37
I7773 7773 0 1.32342e-05
R8581 7773 7774 1.632 0.8 13.056 37
I7774 7774 0 1.29868e-05
R8582 7774 7775 1.712 0.8 13.696 37
I7775 7775 0 1.29868e-05
R8583 7775 7776 1.616 0.8 12.928 37
I7776 7776 0 1.32342e-05
R8584 7776 7777 1.6 0.8 12.8 37
I7777 7777 0 1.24921e-05
R8585 7777 7778 1.616 0.8 12.928 37
I7778 7778 0 1.26158e-05
R8586 7778 7779 1.68 0.8 13.44 37
I7779 7779 0 1.29868e-05
R8587 7779 7780 1.744 0.8 13.952 37
I7780 7780 0 1.31105e-05
R8588 7780 7781 1.696 0.8 13.568 37
I7781 7781 0 1.29868e-05
R8589 7781 7782 1.744 0.8 13.952 37
I7782 7782 0 1.34816e-05
R8590 7782 7783 1.744 0.8 13.952 37
I7783 7783 0 1.32342e-05
R8591 7783 7784 1.68 0.8 13.44 37
I7784 7784 0 1.34816e-05
R8592 7784 7785 1.712 0.8 13.696 37
I7785 7785 0 1.24921e-05
R8593 7785 7786 1.648 0.8 13.184 37
I7786 7786 0 1.32342e-05
R8594 7786 7787 1.632 0.8 13.056 37
I7787 7787 0 1.32342e-05
R8595 7787 7788 1.616 0.8 12.928 37
I7788 7788 0 1.24921e-05
R8596 7788 7789 1.696 0.8 13.568 37
I7789 7789 0 1.27395e-05
R8597 7789 7790 1.712 0.8 13.696 37
I7790 7790 0 1.27395e-05
R8598 7790 7791 1.6 0.8 12.8 37
I7791 7791 0 1.23684e-05
R8599 7791 7792 1.648 0.8 13.184 37
I7792 7792 0 1.23684e-05
R8600 7792 7793 1.616 0.8 12.928 37
I7793 7793 0 1.28631e-05
R8601 7793 7794 1.68 0.8 13.44 37
I7794 7794 0 1.31105e-05
R8602 7794 7795 1.616 0.8 12.928 37
I7795 7795 0 1.31105e-05
R8603 7795 7796 1.664 0.8 13.312 37
I7796 7796 0 1.33579e-05
R8604 7796 7797 1.648 0.8 13.184 37
I7797 7797 0 1.28631e-05
R8605 7797 7798 1.712 0.8 13.696 37
I7798 7798 0 1.27395e-05
R8606 7798 7799 1.648 0.8 13.184 37
I7799 7799 0 1.29868e-05
R8607 7799 7800 1.664 0.8 13.312 37
I7800 7800 0 1.24921e-05
R8608 7800 7801 1.696 0.8 13.568 37
I7801 7801 0 1.33579e-05
R8609 7801 7802 1.6 0.8 12.8 37
I7802 7802 0 1.24921e-05
R8610 7802 7803 1.712 0.8 13.696 37
I7803 7803 0 1.24921e-05
R8611 7803 7804 1.632 0.8 13.056 37
I7804 7804 0 1.27395e-05
R8612 7804 7805 1.712 0.8 13.696 37
I7805 7805 0 1.24921e-05
R8613 7805 7806 1.712 0.8 13.696 37
I7806 7806 0 1.32342e-05
R8614 7806 7807 1.616 0.8 12.928 37
I7807 7807 0 1.23684e-05
R8615 7807 7808 1.6 0.8 12.8 37
I7808 7808 0 1.26158e-05
R8616 7808 7809 1.696 0.8 13.568 37
I7809 7809 0 1.32342e-05
R8617 7809 7810 1.6 0.8 12.8 37
I7810 7810 0 1.23684e-05
R8618 7810 7811 1.648 0.8 13.184 37
I7811 7811 0 1.32342e-05
R8619 7811 7812 1.6 0.8 12.8 37
I7812 7812 0 1.31105e-05
R8620 7812 7813 1.616 0.8 12.928 37
I7813 7813 0 1.34816e-05
R8621 7813 7814 1.616 0.8 12.928 37
I7814 7814 0 1.28631e-05
R8622 7814 7815 1.664 0.8 13.312 37
I7815 7815 0 1.31105e-05
R8623 7815 7816 1.712 0.8 13.696 37
I7816 7816 0 1.27395e-05
R8624 7816 7817 1.696 0.8 13.568 37
I7817 7817 0 1.34816e-05
R8625 7817 7818 1.664 0.8 13.312 37
I7818 7818 0 1.27395e-05
R8626 7818 7819 1.616 0.8 12.928 37
I7819 7819 0 1.31105e-05
R8627 7819 7820 1.696 0.8 13.568 37
I7820 7820 0 1.33579e-05
R8628 7820 7821 1.728 0.8 13.824 37
I7821 7821 0 1.29868e-05
R8629 7821 7822 1.712 0.8 13.696 37
I7822 7822 0 1.24921e-05
R8630 7822 7823 1.712 0.8 13.696 37
I7823 7823 0 1.34816e-05
R8631 7823 7824 1.664 0.8 13.312 37
I7824 7824 0 1.28631e-05
R8632 7824 7825 1.696 0.8 13.568 37
I7825 7825 0 1.31105e-05
R8633 7825 7826 1.664 0.8 13.312 37
I7826 7826 0 1.34816e-05
R8634 7826 7827 1.648 0.8 13.184 37
I7827 7827 0 1.31105e-05
R8635 7827 7828 1.728 0.8 13.824 37
I7828 7828 0 1.31105e-05
R8636 7828 7829 1.68 0.8 13.44 37
I7829 7829 0 1.24921e-05
R8637 7829 7830 1.648 0.8 13.184 37
I7830 7830 0 1.23684e-05
R8638 7830 7831 1.744 0.8 13.952 37
I7831 7831 0 1.26158e-05
R8639 7831 7832 1.648 0.8 13.184 37
I7832 7832 0 1.29868e-05
R8640 7832 7833 1.632 0.8 13.056 37
I7833 7833 0 1.32342e-05
R8641 7833 7834 1.6 0.8 12.8 37
I7834 7834 0 1.27395e-05
R8642 7834 7835 1.68 0.8 13.44 37
I7835 7835 0 1.34816e-05
R8643 7835 7836 1.648 0.8 13.184 37
I7836 7836 0 1.29868e-05
R8644 7836 7837 1.664 0.8 13.312 37
I7837 7837 0 1.26158e-05
R8645 7837 7838 1.712 0.8 13.696 37
I7838 7838 0 1.26158e-05
R8646 7838 7839 1.632 0.8 13.056 37
I7839 7839 0 1.27395e-05
R8647 7839 7840 1.728 0.8 13.824 37
I7840 7840 0 1.33579e-05
R8648 7840 7841 1.744 0.8 13.952 37
I7841 7841 0 1.28631e-05
R8649 7841 7842 1.6 0.8 12.8 37
I7842 7842 0 1.29868e-05
R8650 7842 7843 1.6 0.8 12.8 37
I7843 7843 0 1.23684e-05
R8651 7843 7844 1.616 0.8 12.928 37
I7844 7844 0 1.29868e-05
R8652 7844 7845 1.616 0.8 12.928 37
I7845 7845 0 1.31105e-05
R8653 7845 7846 1.712 0.8 13.696 37
I7846 7846 0 1.27395e-05
R8654 7846 7847 1.744 0.8 13.952 37
I7847 7847 0 1.23684e-05
R8655 7847 7848 1.6 0.8 12.8 37
I7848 7848 0 1.24921e-05
R8656 7848 7849 1.744 0.8 13.952 37
I7849 7849 0 1.24921e-05
R8657 7849 7850 1.696 0.8 13.568 37
I7850 7850 0 1.32342e-05
R8658 7850 7851 1.6 0.8 12.8 37
I7851 7851 0 1.24921e-05
R8659 7851 7852 1.632 0.8 13.056 37
I7852 7852 0 1.31105e-05
R8660 7852 7853 1.648 0.8 13.184 37
I7853 7853 0 1.34816e-05
R8661 7853 7854 1.728 0.8 13.824 37
I7854 7854 0 1.32342e-05
R8662 7854 7855 1.632 0.8 13.056 37
I7855 7855 0 1.31105e-05
R8663 7855 7856 1.696 0.8 13.568 37
I7856 7856 0 1.28631e-05
R8664 7856 7857 1.6 0.8 12.8 37
I7857 7857 0 1.33579e-05
R8665 7857 7858 1.744 0.8 13.952 37
I7858 7858 0 1.26158e-05
R8666 7858 7859 1.728 0.8 13.824 37
I7859 7859 0 1.26158e-05
R8667 7859 7860 1.728 0.8 13.824 37
I7860 7860 0 1.34816e-05
R8668 7860 7861 1.744 0.8 13.952 37
I7861 7861 0 1.29868e-05
R8669 7861 7862 1.664 0.8 13.312 37
I7862 7862 0 1.23684e-05
R8670 7862 7863 1.728 0.8 13.824 37
I7863 7863 0 1.29868e-05
R8671 7863 7864 1.616 0.8 12.928 37
I7864 7864 0 1.32342e-05
R8672 7864 7865 1.696 0.8 13.568 37
I7865 7865 0 1.32342e-05
R8673 7865 7866 1.696 0.8 13.568 37
I7866 7866 0 1.33579e-05
R8674 7866 7867 1.6 0.8 12.8 37
I7867 7867 0 1.34816e-05
R8675 7867 7868 1.664 0.8 13.312 37
I7868 7868 0 1.27395e-05
R8676 7868 7869 1.6 0.8 12.8 37
I7869 7869 0 1.29868e-05
R8677 7869 7870 1.648 0.8 13.184 37
I7870 7870 0 1.29868e-05
R8678 7870 7871 1.616 0.8 12.928 37
I7871 7871 0 1.34816e-05
R8679 7871 7872 1.744 0.8 13.952 37
I7872 7872 0 1.28631e-05
R8680 7872 7873 1.712 0.8 13.696 37
I7873 7873 0 1.23684e-05
R8681 7873 7874 1.696 0.8 13.568 37
I7874 7874 0 1.32342e-05
R8682 7874 7875 1.664 0.8 13.312 37
I7875 7875 0 1.31105e-05
R8683 7875 7876 1.696 0.8 13.568 37
I7876 7876 0 1.29868e-05
R8684 7876 7877 1.632 0.8 13.056 37
I7877 7877 0 1.24921e-05
R8685 7877 7878 1.68 0.8 13.44 37
I7878 7878 0 1.23684e-05
R8686 7878 7879 1.728 0.8 13.824 37
I7879 7879 0 1.31105e-05
R8687 7879 7880 1.744 0.8 13.952 37
I7880 7880 0 1.28631e-05
R8688 7880 7881 1.68 0.8 13.44 37
I7881 7881 0 1.31105e-05
R8689 7881 7882 1.664 0.8 13.312 37
I7882 7882 0 1.32342e-05
R8690 7882 7883 1.712 0.8 13.696 37
I7883 7883 0 1.33579e-05
R8691 7883 7884 1.648 0.8 13.184 37
I7884 7884 0 1.32342e-05
R8692 7884 7885 1.68 0.8 13.44 37
I7885 7885 0 1.31105e-05
R8693 7885 7886 1.632 0.8 13.056 37
I7886 7886 0 1.34816e-05
R8694 7886 7887 1.712 0.8 13.696 37
I7887 7887 0 1.27395e-05
R8695 7887 7888 1.68 0.8 13.44 37
I7888 7888 0 1.28631e-05
R8696 7888 7889 1.68 0.8 13.44 37
I7889 7889 0 1.24921e-05
R8697 7889 7890 1.648 0.8 13.184 37
I7890 7890 0 1.23684e-05
R8698 7890 7891 1.6 0.8 12.8 37
I7891 7891 0 1.24921e-05
R8699 7891 7892 1.68 0.8 13.44 37
I7892 7892 0 1.26158e-05
R8700 7892 7893 1.632 0.8 13.056 37
I7893 7893 0 1.27395e-05
R8701 7893 7894 1.664 0.8 13.312 37
I7894 7894 0 1.26158e-05
R8702 7894 7895 1.616 0.8 12.928 37
I7895 7895 0 1.29868e-05
R8703 7895 7896 1.696 0.8 13.568 37
I7896 7896 0 1.34816e-05
R8704 7896 7897 1.648 0.8 13.184 37
I7897 7897 0 1.26158e-05
R8705 7897 7898 1.696 0.8 13.568 37
I7898 7898 0 1.23684e-05
R8706 7898 7899 1.648 0.8 13.184 37
I7899 7899 0 1.34816e-05
R8707 7899 7900 1.6 0.8 12.8 37
I7900 7900 0 1.33579e-05
R8708 7900 7901 1.68 0.8 13.44 37
I7901 7901 0 1.26158e-05
R8709 7901 7902 1.712 0.8 13.696 37
I7902 7902 0 1.26158e-05
R8710 7902 7903 1.728 0.8 13.824 37
I7903 7903 0 1.26158e-05
R8711 7903 7904 1.728 0.8 13.824 37
I7904 7904 0 1.27395e-05
R8712 7904 7905 1.696 0.8 13.568 37
I7905 7905 0 1.24921e-05
R8713 7905 7906 1.648 0.8 13.184 37
I7906 7906 0 1.31105e-05
R8714 7906 7907 1.648 0.8 13.184 37
I7907 7907 0 1.24921e-05
R8715 7907 7908 1.6 0.8 12.8 37
I7908 7908 0 1.32342e-05
R8716 7908 7909 1.664 0.8 13.312 37
I7909 7909 0 1.31105e-05
R8717 7909 7910 1.6 0.8 12.8 37
I7910 7910 0 1.32342e-05
R8718 7910 7911 1.648 0.8 13.184 37
I7911 7911 0 1.33579e-05
R8719 7911 7912 1.696 0.8 13.568 37
I7912 7912 0 1.34816e-05
R8720 7912 7913 1.648 0.8 13.184 37
I7913 7913 0 1.27395e-05
R8721 7913 7914 1.616 0.8 12.928 37
I7914 7914 0 1.31105e-05
R8722 7914 7915 1.664 0.8 13.312 37
I7915 7915 0 1.24921e-05
R8723 7915 7916 1.696 0.8 13.568 37
I7916 7916 0 1.23684e-05
R8724 7916 7917 1.696 0.8 13.568 37
I7917 7917 0 1.28631e-05
R8725 7917 7918 1.664 0.8 13.312 37
I7918 7918 0 1.28631e-05
R8726 7918 7919 1.728 0.8 13.824 37
I7919 7919 0 1.29868e-05
R8727 7919 7920 1.712 0.8 13.696 37
I7920 7920 0 1.31105e-05
R8728 7920 7921 1.696 0.8 13.568 37
I7921 7921 0 1.27395e-05
R8729 7921 7922 1.664 0.8 13.312 37
I7922 7922 0 1.24921e-05
R8730 7922 7923 1.696 0.8 13.568 37
I7923 7923 0 1.31105e-05
R8731 7923 7924 1.616 0.8 12.928 37
I7924 7924 0 1.26158e-05
R8732 7924 7925 1.664 0.8 13.312 37
I7925 7925 0 1.27395e-05
R8733 7925 7926 1.744 0.8 13.952 37
I7926 7926 0 1.33579e-05
R8734 7926 7927 1.616 0.8 12.928 37
I7927 7927 0 1.31105e-05
R8735 7927 7928 1.712 0.8 13.696 37
I7928 7928 0 1.31105e-05
R8736 7928 7929 1.616 0.8 12.928 37
I7929 7929 0 1.33579e-05
R8737 7929 7930 1.632 0.8 13.056 37
I7930 7930 0 1.29868e-05
R8738 7930 7931 1.632 0.8 13.056 37
I7931 7931 0 1.34816e-05
R8739 7931 7932 1.712 0.8 13.696 37
I7932 7932 0 1.33579e-05
R8740 7932 7933 1.68 0.8 13.44 37
I7933 7933 0 1.26158e-05
R8741 7933 7934 1.664 0.8 13.312 37
I7934 7934 0 1.29868e-05
R8742 7934 7935 1.712 0.8 13.696 37
I7935 7935 0 1.24921e-05
R8743 7935 7936 1.664 0.8 13.312 37
I7936 7936 0 1.29868e-05
R8744 7936 7937 1.696 0.8 13.568 37
I7937 7937 0 1.33579e-05
R8745 7937 7938 1.712 0.8 13.696 37
I7938 7938 0 1.26158e-05
R8746 7938 7939 1.712 0.8 13.696 37
I7939 7939 0 1.23684e-05
R8747 7939 7940 1.664 0.8 13.312 37
I7940 7940 0 1.24921e-05
R8748 7940 7941 1.648 0.8 13.184 37
I7941 7941 0 1.28631e-05
R8749 7941 7942 1.744 0.8 13.952 37
I7942 7942 0 1.31105e-05
R8750 7942 7943 1.632 0.8 13.056 37
I7943 7943 0 1.33579e-05
R8751 7943 7944 1.648 0.8 13.184 37
I7944 7944 0 1.27395e-05
R8752 7944 7945 1.712 0.8 13.696 37
I7945 7945 0 1.32342e-05
R8753 7945 7946 1.728 0.8 13.824 37
I7946 7946 0 1.24921e-05
R8754 7946 7947 1.696 0.8 13.568 37
I7947 7947 0 1.31105e-05
R8755 7947 7948 1.744 0.8 13.952 37
I7948 7948 0 1.27395e-05
R8756 7948 7949 1.6 0.8 12.8 37
I7949 7949 0 1.27395e-05
R8757 7949 7950 1.616 0.8 12.928 37
I7950 7950 0 1.32342e-05
R8758 7950 7951 1.696 0.8 13.568 37
I7951 7951 0 1.29868e-05
R8759 7951 7952 1.632 0.8 13.056 37
I7952 7952 0 1.29868e-05
R8760 7952 7953 1.648 0.8 13.184 37
I7953 7953 0 1.24921e-05
R8761 7953 7954 1.712 0.8 13.696 37
I7954 7954 0 1.23684e-05
R8762 7954 7955 1.616 0.8 12.928 37
I7955 7955 0 1.26158e-05
R8763 7955 7956 1.664 0.8 13.312 37
I7956 7956 0 1.31105e-05
R8764 7956 7957 1.728 0.8 13.824 37
I7957 7957 0 1.27395e-05
R8765 7957 7958 1.648 0.8 13.184 37
I7958 7958 0 1.23684e-05
R8766 7958 7959 1.632 0.8 13.056 37
I7959 7959 0 1.31105e-05
R8767 7959 7960 1.648 0.8 13.184 37
I7960 7960 0 1.24921e-05
R8768 7960 7961 1.648 0.8 13.184 37
I7961 7961 0 1.24921e-05
R8769 7961 7962 1.664 0.8 13.312 37
I7962 7962 0 1.26158e-05
R8770 7962 7963 1.744 0.8 13.952 37
I7963 7963 0 1.27395e-05
R8771 7963 7964 1.712 0.8 13.696 37
I7964 7964 0 1.34816e-05
R8772 7964 7965 1.728 0.8 13.824 37
I7965 7965 0 1.33579e-05
R8773 7965 7966 1.728 0.8 13.824 37
I7966 7966 0 1.31105e-05
R8774 7966 7967 1.648 0.8 13.184 37
I7967 7967 0 1.27395e-05
R8775 7967 7968 1.616 0.8 12.928 37
I7968 7968 0 1.34816e-05
R8776 7968 7969 1.664 0.8 13.312 37
I7969 7969 0 1.24921e-05
R8777 7969 7970 1.616 0.8 12.928 37
I7970 7970 0 1.33579e-05
R8778 7970 7971 1.648 0.8 13.184 37
I7971 7971 0 1.29868e-05
R8779 7971 7972 1.664 0.8 13.312 37
I7972 7972 0 1.24921e-05
R8780 7972 7973 1.744 0.8 13.952 37
I7973 7973 0 1.34816e-05
R8781 7973 7974 1.616 0.8 12.928 37
I7974 7974 0 1.27395e-05
R8782 7974 7975 1.68 0.8 13.44 37
I7975 7975 0 1.31105e-05
R8783 7975 7976 1.696 0.8 13.568 37
I7976 7976 0 1.24921e-05
R8784 7976 7977 1.744 0.8 13.952 37
I7977 7977 0 1.23684e-05
R8785 7977 7978 1.648 0.8 13.184 37
I7978 7978 0 1.34816e-05
R8786 7978 7979 1.68 0.8 13.44 37
I7979 7979 0 1.23684e-05
R8787 7979 7980 1.6 0.8 12.8 37
I7980 7980 0 1.29868e-05
R8788 7980 7981 1.616 0.8 12.928 37
I7981 7981 0 1.34816e-05
R8789 7981 7982 1.616 0.8 12.928 37
I7982 7982 0 1.28631e-05
R8790 7982 7983 1.632 0.8 13.056 37
I7983 7983 0 1.29868e-05
R8791 7983 7984 1.648 0.8 13.184 37
I7984 7984 0 1.33579e-05
R8792 7984 7985 1.696 0.8 13.568 37
I7985 7985 0 1.29868e-05
R8793 7985 7986 1.696 0.8 13.568 37
I7986 7986 0 1.24921e-05
R8794 7986 7987 1.6 0.8 12.8 37
I7987 7987 0 1.27395e-05
R8795 7987 7988 1.664 0.8 13.312 37
I7988 7988 0 1.24921e-05
R8796 7988 7989 1.632 0.8 13.056 37
I7989 7989 0 1.29868e-05
R8797 7989 7990 1.696 0.8 13.568 37
I7990 7990 0 1.23684e-05
R8798 7990 7991 1.648 0.8 13.184 37
I7991 7991 0 1.26158e-05
R8799 7991 7992 1.616 0.8 12.928 37
I7992 7992 0 1.26158e-05
R8800 7992 7993 1.632 0.8 13.056 37
I7993 7993 0 1.31105e-05
R8801 7993 7994 1.616 0.8 12.928 37
I7994 7994 0 1.34816e-05
R8802 7994 7995 1.728 0.8 13.824 37
I7995 7995 0 1.26158e-05
R8803 7995 7996 1.664 0.8 13.312 37
I7996 7996 0 1.34816e-05
R8804 7996 7997 1.616 0.8 12.928 37
I7997 7997 0 1.33579e-05
R8805 7997 7998 1.696 0.8 13.568 37
I7998 7998 0 1.29868e-05
R8806 7998 7999 1.648 0.8 13.184 37
I7999 7999 0 1.34816e-05
R8807 7999 8000 1.648 0.8 13.184 37
I8000 8000 0 1.23684e-05
R8808 8000 10001 0.5 10 50 37
*seg: 9
* inter-segment connection
R8809 8010 9010 6.16 0.8 49.28 37
R8810 8020 9020 6.16 0.8 49.28 37
R8811 8030 9030 6.16 0.8 49.28 37
R8812 8040 9040 6.16 0.8 49.28 37
R8813 8050 9050 6.16 0.8 49.28 37
R8814 8060 9060 6.16 0.8 49.28 37
R8815 8070 9070 6.16 0.8 49.28 37
R8816 8080 9080 6.16 0.8 49.28 37
R8817 8090 9090 6.16 0.8 49.28 37
R8818 8100 9100 6.16 0.8 49.28 37
R8819 8110 9110 6.16 0.8 49.28 37
R8820 8120 9120 6.16 0.8 49.28 37
R8821 8130 9130 6.16 0.8 49.28 37
R8822 8140 9140 6.16 0.8 49.28 37
R8823 8150 9150 6.16 0.8 49.28 37
R8824 8160 9160 6.16 0.8 49.28 37
R8825 8170 9170 6.16 0.8 49.28 37
R8826 8180 9180 6.16 0.8 49.28 37
R8827 8190 9190 6.16 0.8 49.28 37
R8828 8200 9200 6.16 0.8 49.28 37
R8829 8210 9210 6.16 0.8 49.28 37
R8830 8220 9220 6.16 0.8 49.28 37
R8831 8230 9230 6.16 0.8 49.28 37
R8832 8240 9240 6.16 0.8 49.28 37
R8833 8250 9250 6.16 0.8 49.28 37
R8834 8260 9260 6.16 0.8 49.28 37
R8835 8270 9270 6.16 0.8 49.28 37
R8836 8280 9280 6.16 0.8 49.28 37
R8837 8290 9290 6.16 0.8 49.28 37
R8838 8300 9300 6.16 0.8 49.28 37
R8839 8310 9310 6.16 0.8 49.28 37
R8840 8320 9320 6.16 0.8 49.28 37
R8841 8330 9330 6.16 0.8 49.28 37
R8842 8340 9340 6.16 0.8 49.28 37
R8843 8350 9350 6.16 0.8 49.28 37
R8844 8360 9360 6.16 0.8 49.28 37
R8845 8370 9370 6.16 0.8 49.28 37
R8846 8380 9380 6.16 0.8 49.28 37
R8847 8390 9390 6.16 0.8 49.28 37
R8848 8400 9400 6.16 0.8 49.28 37
R8849 8410 9410 6.16 0.8 49.28 37
R8850 8420 9420 6.16 0.8 49.28 37
R8851 8430 9430 6.16 0.8 49.28 37
R8852 8440 9440 6.16 0.8 49.28 37
R8853 8450 9450 6.16 0.8 49.28 37
R8854 8460 9460 6.16 0.8 49.28 37
R8855 8470 9470 6.16 0.8 49.28 37
R8856 8480 9480 6.16 0.8 49.28 37
R8857 8490 9490 6.16 0.8 49.28 37
R8858 8500 9500 6.16 0.8 49.28 37
R8859 8510 9510 6.16 0.8 49.28 37
R8860 8520 9520 6.16 0.8 49.28 37
R8861 8530 9530 6.16 0.8 49.28 37
R8862 8540 9540 6.16 0.8 49.28 37
R8863 8550 9550 6.16 0.8 49.28 37
R8864 8560 9560 6.16 0.8 49.28 37
R8865 8570 9570 6.16 0.8 49.28 37
R8866 8580 9580 6.16 0.8 49.28 37
R8867 8590 9590 6.16 0.8 49.28 37
R8868 8600 9600 6.16 0.8 49.28 37
R8869 8610 9610 6.16 0.8 49.28 37
R8870 8620 9620 6.16 0.8 49.28 37
R8871 8630 9630 6.16 0.8 49.28 37
R8872 8640 9640 6.16 0.8 49.28 37
R8873 8650 9650 6.16 0.8 49.28 37
R8874 8660 9660 6.16 0.8 49.28 37
R8875 8670 9670 6.16 0.8 49.28 37
R8876 8680 9680 6.16 0.8 49.28 37
R8877 8690 9690 6.16 0.8 49.28 37
R8878 8700 9700 6.16 0.8 49.28 37
R8879 8710 9710 6.16 0.8 49.28 37
R8880 8720 9720 6.16 0.8 49.28 37
R8881 8730 9730 6.16 0.8 49.28 37
R8882 8740 9740 6.16 0.8 49.28 37
R8883 8750 9750 6.16 0.8 49.28 37
R8884 8760 9760 6.16 0.8 49.28 37
R8885 8770 9770 6.16 0.8 49.28 37
R8886 8780 9780 6.16 0.8 49.28 37
R8887 8790 9790 6.16 0.8 49.28 37
R8888 8800 9800 6.16 0.8 49.28 37
R8889 8810 9810 6.16 0.8 49.28 37
R8890 8820 9820 6.16 0.8 49.28 37
R8891 8830 9830 6.16 0.8 49.28 37
R8892 8840 9840 6.16 0.8 49.28 37
R8893 8850 9850 6.16 0.8 49.28 37
R8894 8860 9860 6.16 0.8 49.28 37
R8895 8870 9870 6.16 0.8 49.28 37
R8896 8880 9880 6.16 0.8 49.28 37
R8897 8890 9890 6.16 0.8 49.28 37
R8898 8900 9900 6.16 0.8 49.28 37
R8899 8910 9910 6.16 0.8 49.28 37
R8900 8920 9920 6.16 0.8 49.28 37
R8901 8930 9930 6.16 0.8 49.28 37
R8902 8940 9940 6.16 0.8 49.28 37
R8903 8950 9950 6.16 0.8 49.28 37
R8904 8960 9960 6.16 0.8 49.28 37
R8905 8970 9970 6.16 0.8 49.28 37
R8906 8980 9980 6.16 0.8 49.28 37
R8907 8990 9990 6.16 0.8 49.28 37
R8908 9000 10000 6.16 0.8 49.28 37
R8909 10001 8001 0.4 20 80 37
I8001 8001 0 1.24921e-05
R8910 8001 8002 1.696 0.8 13.568 37
I8002 8002 0 1.23684e-05
R8911 8002 8003 1.632 0.8 13.056 37
I8003 8003 0 1.34816e-05
R8912 8003 8004 1.68 0.8 13.44 37
I8004 8004 0 1.31105e-05
R8913 8004 8005 1.6 0.8 12.8 37
I8005 8005 0 1.34816e-05
R8914 8005 8006 1.648 0.8 13.184 37
I8006 8006 0 1.34816e-05
R8915 8006 8007 1.744 0.8 13.952 37
I8007 8007 0 1.31105e-05
R8916 8007 8008 1.616 0.8 12.928 37
I8008 8008 0 1.26158e-05
R8917 8008 8009 1.6 0.8 12.8 37
I8009 8009 0 1.31105e-05
R8918 8009 8010 1.6 0.8 12.8 37
I8010 8010 0 1.26158e-05
R8919 8010 8011 1.68 0.8 13.44 37
I8011 8011 0 1.24921e-05
R8920 8011 8012 1.696 0.8 13.568 37
I8012 8012 0 1.26158e-05
R8921 8012 8013 1.6 0.8 12.8 37
I8013 8013 0 1.34816e-05
R8922 8013 8014 1.6 0.8 12.8 37
I8014 8014 0 1.31105e-05
R8923 8014 8015 1.664 0.8 13.312 37
I8015 8015 0 1.29868e-05
R8924 8015 8016 1.728 0.8 13.824 37
I8016 8016 0 1.32342e-05
R8925 8016 8017 1.696 0.8 13.568 37
I8017 8017 0 1.31105e-05
R8926 8017 8018 1.744 0.8 13.952 37
I8018 8018 0 1.23684e-05
R8927 8018 8019 1.68 0.8 13.44 37
I8019 8019 0 1.31105e-05
R8928 8019 8020 1.728 0.8 13.824 37
I8020 8020 0 1.33579e-05
R8929 8020 8021 1.696 0.8 13.568 37
I8021 8021 0 1.24921e-05
R8930 8021 8022 1.712 0.8 13.696 37
I8022 8022 0 1.32342e-05
R8931 8022 8023 1.744 0.8 13.952 37
I8023 8023 0 1.33579e-05
R8932 8023 8024 1.6 0.8 12.8 37
I8024 8024 0 1.34816e-05
R8933 8024 8025 1.696 0.8 13.568 37
I8025 8025 0 1.26158e-05
R8934 8025 8026 1.648 0.8 13.184 37
I8026 8026 0 1.26158e-05
R8935 8026 8027 1.648 0.8 13.184 37
I8027 8027 0 1.24921e-05
R8936 8027 8028 1.696 0.8 13.568 37
I8028 8028 0 1.31105e-05
R8937 8028 8029 1.632 0.8 13.056 37
I8029 8029 0 1.31105e-05
R8938 8029 8030 1.632 0.8 13.056 37
I8030 8030 0 1.31105e-05
R8939 8030 8031 1.616 0.8 12.928 37
I8031 8031 0 1.26158e-05
R8940 8031 8032 1.696 0.8 13.568 37
I8032 8032 0 1.34816e-05
R8941 8032 8033 1.744 0.8 13.952 37
I8033 8033 0 1.32342e-05
R8942 8033 8034 1.744 0.8 13.952 37
I8034 8034 0 1.28631e-05
R8943 8034 8035 1.664 0.8 13.312 37
I8035 8035 0 1.32342e-05
R8944 8035 8036 1.632 0.8 13.056 37
I8036 8036 0 1.26158e-05
R8945 8036 8037 1.6 0.8 12.8 37
I8037 8037 0 1.24921e-05
R8946 8037 8038 1.744 0.8 13.952 37
I8038 8038 0 1.24921e-05
R8947 8038 8039 1.6 0.8 12.8 37
I8039 8039 0 1.24921e-05
R8948 8039 8040 1.632 0.8 13.056 37
I8040 8040 0 1.31105e-05
R8949 8040 8041 1.664 0.8 13.312 37
I8041 8041 0 1.31105e-05
R8950 8041 8042 1.6 0.8 12.8 37
I8042 8042 0 1.32342e-05
R8951 8042 8043 1.744 0.8 13.952 37
I8043 8043 0 1.31105e-05
R8952 8043 8044 1.648 0.8 13.184 37
I8044 8044 0 1.26158e-05
R8953 8044 8045 1.664 0.8 13.312 37
I8045 8045 0 1.33579e-05
R8954 8045 8046 1.6 0.8 12.8 37
I8046 8046 0 1.32342e-05
R8955 8046 8047 1.6 0.8 12.8 37
I8047 8047 0 1.33579e-05
R8956 8047 8048 1.696 0.8 13.568 37
I8048 8048 0 1.24921e-05
R8957 8048 8049 1.728 0.8 13.824 37
I8049 8049 0 1.29868e-05
R8958 8049 8050 1.728 0.8 13.824 37
I8050 8050 0 1.26158e-05
R8959 8050 8051 1.664 0.8 13.312 37
I8051 8051 0 1.23684e-05
R8960 8051 8052 1.664 0.8 13.312 37
I8052 8052 0 1.31105e-05
R8961 8052 8053 1.632 0.8 13.056 37
I8053 8053 0 1.29868e-05
R8962 8053 8054 1.712 0.8 13.696 37
I8054 8054 0 1.28631e-05
R8963 8054 8055 1.712 0.8 13.696 37
I8055 8055 0 1.23684e-05
R8964 8055 8056 1.632 0.8 13.056 37
I8056 8056 0 1.24921e-05
R8965 8056 8057 1.728 0.8 13.824 37
I8057 8057 0 1.29868e-05
R8966 8057 8058 1.6 0.8 12.8 37
I8058 8058 0 1.34816e-05
R8967 8058 8059 1.648 0.8 13.184 37
I8059 8059 0 1.31105e-05
R8968 8059 8060 1.616 0.8 12.928 37
I8060 8060 0 1.23684e-05
R8969 8060 8061 1.664 0.8 13.312 37
I8061 8061 0 1.28631e-05
R8970 8061 8062 1.712 0.8 13.696 37
I8062 8062 0 1.31105e-05
R8971 8062 8063 1.664 0.8 13.312 37
I8063 8063 0 1.28631e-05
R8972 8063 8064 1.728 0.8 13.824 37
I8064 8064 0 1.26158e-05
R8973 8064 8065 1.616 0.8 12.928 37
I8065 8065 0 1.31105e-05
R8974 8065 8066 1.696 0.8 13.568 37
I8066 8066 0 1.31105e-05
R8975 8066 8067 1.728 0.8 13.824 37
I8067 8067 0 1.26158e-05
R8976 8067 8068 1.664 0.8 13.312 37
I8068 8068 0 1.26158e-05
R8977 8068 8069 1.728 0.8 13.824 37
I8069 8069 0 1.26158e-05
R8978 8069 8070 1.728 0.8 13.824 37
I8070 8070 0 1.32342e-05
R8979 8070 8071 1.664 0.8 13.312 37
I8071 8071 0 1.27395e-05
R8980 8071 8072 1.728 0.8 13.824 37
I8072 8072 0 1.26158e-05
R8981 8072 8073 1.728 0.8 13.824 37
I8073 8073 0 1.23684e-05
R8982 8073 8074 1.616 0.8 12.928 37
I8074 8074 0 1.27395e-05
R8983 8074 8075 1.696 0.8 13.568 37
I8075 8075 0 1.29868e-05
R8984 8075 8076 1.648 0.8 13.184 37
I8076 8076 0 1.23684e-05
R8985 8076 8077 1.616 0.8 12.928 37
I8077 8077 0 1.24921e-05
R8986 8077 8078 1.744 0.8 13.952 37
I8078 8078 0 1.29868e-05
R8987 8078 8079 1.712 0.8 13.696 37
I8079 8079 0 1.32342e-05
R8988 8079 8080 1.6 0.8 12.8 37
I8080 8080 0 1.33579e-05
R8989 8080 8081 1.68 0.8 13.44 37
I8081 8081 0 1.31105e-05
R8990 8081 8082 1.696 0.8 13.568 37
I8082 8082 0 1.29868e-05
R8991 8082 8083 1.744 0.8 13.952 37
I8083 8083 0 1.24921e-05
R8992 8083 8084 1.6 0.8 12.8 37
I8084 8084 0 1.34816e-05
R8993 8084 8085 1.68 0.8 13.44 37
I8085 8085 0 1.33579e-05
R8994 8085 8086 1.696 0.8 13.568 37
I8086 8086 0 1.34816e-05
R8995 8086 8087 1.616 0.8 12.928 37
I8087 8087 0 1.31105e-05
R8996 8087 8088 1.616 0.8 12.928 37
I8088 8088 0 1.24921e-05
R8997 8088 8089 1.696 0.8 13.568 37
I8089 8089 0 1.28631e-05
R8998 8089 8090 1.712 0.8 13.696 37
I8090 8090 0 1.27395e-05
R8999 8090 8091 1.744 0.8 13.952 37
I8091 8091 0 1.23684e-05
R9000 8091 8092 1.68 0.8 13.44 37
I8092 8092 0 1.26158e-05
R9001 8092 8093 1.648 0.8 13.184 37
I8093 8093 0 1.28631e-05
R9002 8093 8094 1.6 0.8 12.8 37
I8094 8094 0 1.23684e-05
R9003 8094 8095 1.648 0.8 13.184 37
I8095 8095 0 1.23684e-05
R9004 8095 8096 1.744 0.8 13.952 37
I8096 8096 0 1.33579e-05
R9005 8096 8097 1.696 0.8 13.568 37
I8097 8097 0 1.29868e-05
R9006 8097 8098 1.696 0.8 13.568 37
I8098 8098 0 1.32342e-05
R9007 8098 8099 1.728 0.8 13.824 37
I8099 8099 0 1.31105e-05
R9008 8099 8100 1.696 0.8 13.568 37
I8100 8100 0 1.27395e-05
R9009 8100 8101 1.664 0.8 13.312 37
I8101 8101 0 1.28631e-05
R9010 8101 8102 1.632 0.8 13.056 37
I8102 8102 0 1.33579e-05
R9011 8102 8103 1.6 0.8 12.8 37
I8103 8103 0 1.29868e-05
R9012 8103 8104 1.744 0.8 13.952 37
I8104 8104 0 1.32342e-05
R9013 8104 8105 1.6 0.8 12.8 37
I8105 8105 0 1.31105e-05
R9014 8105 8106 1.6 0.8 12.8 37
I8106 8106 0 1.24921e-05
R9015 8106 8107 1.744 0.8 13.952 37
I8107 8107 0 1.32342e-05
R9016 8107 8108 1.664 0.8 13.312 37
I8108 8108 0 1.26158e-05
R9017 8108 8109 1.632 0.8 13.056 37
I8109 8109 0 1.28631e-05
R9018 8109 8110 1.648 0.8 13.184 37
I8110 8110 0 1.29868e-05
R9019 8110 8111 1.696 0.8 13.568 37
I8111 8111 0 1.28631e-05
R9020 8111 8112 1.696 0.8 13.568 37
I8112 8112 0 1.26158e-05
R9021 8112 8113 1.616 0.8 12.928 37
I8113 8113 0 1.26158e-05
R9022 8113 8114 1.632 0.8 13.056 37
I8114 8114 0 1.23684e-05
R9023 8114 8115 1.728 0.8 13.824 37
I8115 8115 0 1.23684e-05
R9024 8115 8116 1.68 0.8 13.44 37
I8116 8116 0 1.28631e-05
R9025 8116 8117 1.68 0.8 13.44 37
I8117 8117 0 1.33579e-05
R9026 8117 8118 1.632 0.8 13.056 37
I8118 8118 0 1.29868e-05
R9027 8118 8119 1.68 0.8 13.44 37
I8119 8119 0 1.28631e-05
R9028 8119 8120 1.632 0.8 13.056 37
I8120 8120 0 1.29868e-05
R9029 8120 8121 1.632 0.8 13.056 37
I8121 8121 0 1.28631e-05
R9030 8121 8122 1.744 0.8 13.952 37
I8122 8122 0 1.27395e-05
R9031 8122 8123 1.632 0.8 13.056 37
I8123 8123 0 1.29868e-05
R9032 8123 8124 1.696 0.8 13.568 37
I8124 8124 0 1.31105e-05
R9033 8124 8125 1.616 0.8 12.928 37
I8125 8125 0 1.24921e-05
R9034 8125 8126 1.648 0.8 13.184 37
I8126 8126 0 1.32342e-05
R9035 8126 8127 1.712 0.8 13.696 37
I8127 8127 0 1.34816e-05
R9036 8127 8128 1.616 0.8 12.928 37
I8128 8128 0 1.33579e-05
R9037 8128 8129 1.648 0.8 13.184 37
I8129 8129 0 1.27395e-05
R9038 8129 8130 1.6 0.8 12.8 37
I8130 8130 0 1.24921e-05
R9039 8130 8131 1.664 0.8 13.312 37
I8131 8131 0 1.31105e-05
R9040 8131 8132 1.728 0.8 13.824 37
I8132 8132 0 1.34816e-05
R9041 8132 8133 1.696 0.8 13.568 37
I8133 8133 0 1.23684e-05
R9042 8133 8134 1.696 0.8 13.568 37
I8134 8134 0 1.24921e-05
R9043 8134 8135 1.696 0.8 13.568 37
I8135 8135 0 1.34816e-05
R9044 8135 8136 1.744 0.8 13.952 37
I8136 8136 0 1.24921e-05
R9045 8136 8137 1.68 0.8 13.44 37
I8137 8137 0 1.33579e-05
R9046 8137 8138 1.664 0.8 13.312 37
I8138 8138 0 1.34816e-05
R9047 8138 8139 1.648 0.8 13.184 37
I8139 8139 0 1.26158e-05
R9048 8139 8140 1.68 0.8 13.44 37
I8140 8140 0 1.28631e-05
R9049 8140 8141 1.68 0.8 13.44 37
I8141 8141 0 1.24921e-05
R9050 8141 8142 1.648 0.8 13.184 37
I8142 8142 0 1.26158e-05
R9051 8142 8143 1.6 0.8 12.8 37
I8143 8143 0 1.28631e-05
R9052 8143 8144 1.616 0.8 12.928 37
I8144 8144 0 1.28631e-05
R9053 8144 8145 1.728 0.8 13.824 37
I8145 8145 0 1.24921e-05
R9054 8145 8146 1.712 0.8 13.696 37
I8146 8146 0 1.28631e-05
R9055 8146 8147 1.712 0.8 13.696 37
I8147 8147 0 1.29868e-05
R9056 8147 8148 1.68 0.8 13.44 37
I8148 8148 0 1.29868e-05
R9057 8148 8149 1.728 0.8 13.824 37
I8149 8149 0 1.24921e-05
R9058 8149 8150 1.712 0.8 13.696 37
I8150 8150 0 1.31105e-05
R9059 8150 8151 1.632 0.8 13.056 37
I8151 8151 0 1.31105e-05
R9060 8151 8152 1.712 0.8 13.696 37
I8152 8152 0 1.33579e-05
R9061 8152 8153 1.696 0.8 13.568 37
I8153 8153 0 1.26158e-05
R9062 8153 8154 1.744 0.8 13.952 37
I8154 8154 0 1.34816e-05
R9063 8154 8155 1.696 0.8 13.568 37
I8155 8155 0 1.32342e-05
R9064 8155 8156 1.68 0.8 13.44 37
I8156 8156 0 1.26158e-05
R9065 8156 8157 1.728 0.8 13.824 37
I8157 8157 0 1.33579e-05
R9066 8157 8158 1.664 0.8 13.312 37
I8158 8158 0 1.33579e-05
R9067 8158 8159 1.664 0.8 13.312 37
I8159 8159 0 1.29868e-05
R9068 8159 8160 1.664 0.8 13.312 37
I8160 8160 0 1.28631e-05
R9069 8160 8161 1.744 0.8 13.952 37
I8161 8161 0 1.26158e-05
R9070 8161 8162 1.728 0.8 13.824 37
I8162 8162 0 1.33579e-05
R9071 8162 8163 1.744 0.8 13.952 37
I8163 8163 0 1.27395e-05
R9072 8163 8164 1.664 0.8 13.312 37
I8164 8164 0 1.32342e-05
R9073 8164 8165 1.712 0.8 13.696 37
I8165 8165 0 1.27395e-05
R9074 8165 8166 1.664 0.8 13.312 37
I8166 8166 0 1.34816e-05
R9075 8166 8167 1.616 0.8 12.928 37
I8167 8167 0 1.27395e-05
R9076 8167 8168 1.744 0.8 13.952 37
I8168 8168 0 1.32342e-05
R9077 8168 8169 1.712 0.8 13.696 37
I8169 8169 0 1.34816e-05
R9078 8169 8170 1.696 0.8 13.568 37
I8170 8170 0 1.28631e-05
R9079 8170 8171 1.728 0.8 13.824 37
I8171 8171 0 1.27395e-05
R9080 8171 8172 1.696 0.8 13.568 37
I8172 8172 0 1.31105e-05
R9081 8172 8173 1.648 0.8 13.184 37
I8173 8173 0 1.26158e-05
R9082 8173 8174 1.696 0.8 13.568 37
I8174 8174 0 1.32342e-05
R9083 8174 8175 1.6 0.8 12.8 37
I8175 8175 0 1.24921e-05
R9084 8175 8176 1.632 0.8 13.056 37
I8176 8176 0 1.34816e-05
R9085 8176 8177 1.68 0.8 13.44 37
I8177 8177 0 1.23684e-05
R9086 8177 8178 1.744 0.8 13.952 37
I8178 8178 0 1.28631e-05
R9087 8178 8179 1.696 0.8 13.568 37
I8179 8179 0 1.27395e-05
R9088 8179 8180 1.664 0.8 13.312 37
I8180 8180 0 1.27395e-05
R9089 8180 8181 1.728 0.8 13.824 37
I8181 8181 0 1.23684e-05
R9090 8181 8182 1.664 0.8 13.312 37
I8182 8182 0 1.34816e-05
R9091 8182 8183 1.648 0.8 13.184 37
I8183 8183 0 1.28631e-05
R9092 8183 8184 1.696 0.8 13.568 37
I8184 8184 0 1.24921e-05
R9093 8184 8185 1.648 0.8 13.184 37
I8185 8185 0 1.28631e-05
R9094 8185 8186 1.712 0.8 13.696 37
I8186 8186 0 1.27395e-05
R9095 8186 8187 1.712 0.8 13.696 37
I8187 8187 0 1.29868e-05
R9096 8187 8188 1.744 0.8 13.952 37
I8188 8188 0 1.26158e-05
R9097 8188 8189 1.712 0.8 13.696 37
I8189 8189 0 1.29868e-05
R9098 8189 8190 1.6 0.8 12.8 37
I8190 8190 0 1.32342e-05
R9099 8190 8191 1.728 0.8 13.824 37
I8191 8191 0 1.26158e-05
R9100 8191 8192 1.728 0.8 13.824 37
I8192 8192 0 1.29868e-05
R9101 8192 8193 1.664 0.8 13.312 37
I8193 8193 0 1.33579e-05
R9102 8193 8194 1.632 0.8 13.056 37
I8194 8194 0 1.26158e-05
R9103 8194 8195 1.648 0.8 13.184 37
I8195 8195 0 1.31105e-05
R9104 8195 8196 1.712 0.8 13.696 37
I8196 8196 0 1.26158e-05
R9105 8196 8197 1.696 0.8 13.568 37
I8197 8197 0 1.26158e-05
R9106 8197 8198 1.616 0.8 12.928 37
I8198 8198 0 1.24921e-05
R9107 8198 8199 1.696 0.8 13.568 37
I8199 8199 0 1.23684e-05
R9108 8199 8200 1.632 0.8 13.056 37
I8200 8200 0 1.24921e-05
R9109 8200 8201 1.664 0.8 13.312 37
I8201 8201 0 1.24921e-05
R9110 8201 8202 1.664 0.8 13.312 37
I8202 8202 0 1.28631e-05
R9111 8202 8203 1.696 0.8 13.568 37
I8203 8203 0 1.29868e-05
R9112 8203 8204 1.696 0.8 13.568 37
I8204 8204 0 1.28631e-05
R9113 8204 8205 1.632 0.8 13.056 37
I8205 8205 0 1.31105e-05
R9114 8205 8206 1.648 0.8 13.184 37
I8206 8206 0 1.24921e-05
R9115 8206 8207 1.6 0.8 12.8 37
I8207 8207 0 1.28631e-05
R9116 8207 8208 1.728 0.8 13.824 37
I8208 8208 0 1.32342e-05
R9117 8208 8209 1.664 0.8 13.312 37
I8209 8209 0 1.23684e-05
R9118 8209 8210 1.744 0.8 13.952 37
I8210 8210 0 1.34816e-05
R9119 8210 8211 1.696 0.8 13.568 37
I8211 8211 0 1.32342e-05
R9120 8211 8212 1.616 0.8 12.928 37
I8212 8212 0 1.28631e-05
R9121 8212 8213 1.616 0.8 12.928 37
I8213 8213 0 1.29868e-05
R9122 8213 8214 1.728 0.8 13.824 37
I8214 8214 0 1.32342e-05
R9123 8214 8215 1.712 0.8 13.696 37
I8215 8215 0 1.23684e-05
R9124 8215 8216 1.6 0.8 12.8 37
I8216 8216 0 1.24921e-05
R9125 8216 8217 1.664 0.8 13.312 37
I8217 8217 0 1.31105e-05
R9126 8217 8218 1.712 0.8 13.696 37
I8218 8218 0 1.23684e-05
R9127 8218 8219 1.616 0.8 12.928 37
I8219 8219 0 1.28631e-05
R9128 8219 8220 1.696 0.8 13.568 37
I8220 8220 0 1.27395e-05
R9129 8220 8221 1.632 0.8 13.056 37
I8221 8221 0 1.26158e-05
R9130 8221 8222 1.696 0.8 13.568 37
I8222 8222 0 1.27395e-05
R9131 8222 8223 1.696 0.8 13.568 37
I8223 8223 0 1.29868e-05
R9132 8223 8224 1.6 0.8 12.8 37
I8224 8224 0 1.26158e-05
R9133 8224 8225 1.68 0.8 13.44 37
I8225 8225 0 1.24921e-05
R9134 8225 8226 1.616 0.8 12.928 37
I8226 8226 0 1.28631e-05
R9135 8226 8227 1.6 0.8 12.8 37
I8227 8227 0 1.29868e-05
R9136 8227 8228 1.6 0.8 12.8 37
I8228 8228 0 1.24921e-05
R9137 8228 8229 1.632 0.8 13.056 37
I8229 8229 0 1.33579e-05
R9138 8229 8230 1.728 0.8 13.824 37
I8230 8230 0 1.34816e-05
R9139 8230 8231 1.616 0.8 12.928 37
I8231 8231 0 1.23684e-05
R9140 8231 8232 1.632 0.8 13.056 37
I8232 8232 0 1.29868e-05
R9141 8232 8233 1.696 0.8 13.568 37
I8233 8233 0 1.23684e-05
R9142 8233 8234 1.712 0.8 13.696 37
I8234 8234 0 1.32342e-05
R9143 8234 8235 1.696 0.8 13.568 37
I8235 8235 0 1.28631e-05
R9144 8235 8236 1.648 0.8 13.184 37
I8236 8236 0 1.33579e-05
R9145 8236 8237 1.696 0.8 13.568 37
I8237 8237 0 1.34816e-05
R9146 8237 8238 1.648 0.8 13.184 37
I8238 8238 0 1.28631e-05
R9147 8238 8239 1.696 0.8 13.568 37
I8239 8239 0 1.29868e-05
R9148 8239 8240 1.696 0.8 13.568 37
I8240 8240 0 1.28631e-05
R9149 8240 8241 1.712 0.8 13.696 37
I8241 8241 0 1.32342e-05
R9150 8241 8242 1.6 0.8 12.8 37
I8242 8242 0 1.32342e-05
R9151 8242 8243 1.632 0.8 13.056 37
I8243 8243 0 1.26158e-05
R9152 8243 8244 1.616 0.8 12.928 37
I8244 8244 0 1.28631e-05
R9153 8244 8245 1.616 0.8 12.928 37
I8245 8245 0 1.34816e-05
R9154 8245 8246 1.68 0.8 13.44 37
I8246 8246 0 1.28631e-05
R9155 8246 8247 1.632 0.8 13.056 37
I8247 8247 0 1.33579e-05
R9156 8247 8248 1.616 0.8 12.928 37
I8248 8248 0 1.33579e-05
R9157 8248 8249 1.6 0.8 12.8 37
I8249 8249 0 1.33579e-05
R9158 8249 8250 1.728 0.8 13.824 37
I8250 8250 0 1.31105e-05
R9159 8250 8251 1.664 0.8 13.312 37
I8251 8251 0 1.27395e-05
R9160 8251 8252 1.696 0.8 13.568 37
I8252 8252 0 1.23684e-05
R9161 8252 8253 1.664 0.8 13.312 37
I8253 8253 0 1.23684e-05
R9162 8253 8254 1.696 0.8 13.568 37
I8254 8254 0 1.24921e-05
R9163 8254 8255 1.68 0.8 13.44 37
I8255 8255 0 1.26158e-05
R9164 8255 8256 1.712 0.8 13.696 37
I8256 8256 0 1.28631e-05
R9165 8256 8257 1.6 0.8 12.8 37
I8257 8257 0 1.32342e-05
R9166 8257 8258 1.664 0.8 13.312 37
I8258 8258 0 1.28631e-05
R9167 8258 8259 1.744 0.8 13.952 37
I8259 8259 0 1.29868e-05
R9168 8259 8260 1.616 0.8 12.928 37
I8260 8260 0 1.26158e-05
R9169 8260 8261 1.696 0.8 13.568 37
I8261 8261 0 1.31105e-05
R9170 8261 8262 1.728 0.8 13.824 37
I8262 8262 0 1.33579e-05
R9171 8262 8263 1.664 0.8 13.312 37
I8263 8263 0 1.34816e-05
R9172 8263 8264 1.744 0.8 13.952 37
I8264 8264 0 1.31105e-05
R9173 8264 8265 1.6 0.8 12.8 37
I8265 8265 0 1.34816e-05
R9174 8265 8266 1.632 0.8 13.056 37
I8266 8266 0 1.31105e-05
R9175 8266 8267 1.632 0.8 13.056 37
I8267 8267 0 1.34816e-05
R9176 8267 8268 1.712 0.8 13.696 37
I8268 8268 0 1.33579e-05
R9177 8268 8269 1.616 0.8 12.928 37
I8269 8269 0 1.29868e-05
R9178 8269 8270 1.616 0.8 12.928 37
I8270 8270 0 1.31105e-05
R9179 8270 8271 1.728 0.8 13.824 37
I8271 8271 0 1.33579e-05
R9180 8271 8272 1.648 0.8 13.184 37
I8272 8272 0 1.23684e-05
R9181 8272 8273 1.68 0.8 13.44 37
I8273 8273 0 1.32342e-05
R9182 8273 8274 1.664 0.8 13.312 37
I8274 8274 0 1.29868e-05
R9183 8274 8275 1.632 0.8 13.056 37
I8275 8275 0 1.29868e-05
R9184 8275 8276 1.744 0.8 13.952 37
I8276 8276 0 1.23684e-05
R9185 8276 8277 1.664 0.8 13.312 37
I8277 8277 0 1.33579e-05
R9186 8277 8278 1.744 0.8 13.952 37
I8278 8278 0 1.23684e-05
R9187 8278 8279 1.712 0.8 13.696 37
I8279 8279 0 1.23684e-05
R9188 8279 8280 1.712 0.8 13.696 37
I8280 8280 0 1.34816e-05
R9189 8280 8281 1.744 0.8 13.952 37
I8281 8281 0 1.34816e-05
R9190 8281 8282 1.696 0.8 13.568 37
I8282 8282 0 1.27395e-05
R9191 8282 8283 1.6 0.8 12.8 37
I8283 8283 0 1.29868e-05
R9192 8283 8284 1.648 0.8 13.184 37
I8284 8284 0 1.24921e-05
R9193 8284 8285 1.6 0.8 12.8 37
I8285 8285 0 1.29868e-05
R9194 8285 8286 1.6 0.8 12.8 37
I8286 8286 0 1.23684e-05
R9195 8286 8287 1.648 0.8 13.184 37
I8287 8287 0 1.27395e-05
R9196 8287 8288 1.6 0.8 12.8 37
I8288 8288 0 1.34816e-05
R9197 8288 8289 1.6 0.8 12.8 37
I8289 8289 0 1.32342e-05
R9198 8289 8290 1.696 0.8 13.568 37
I8290 8290 0 1.28631e-05
R9199 8290 8291 1.632 0.8 13.056 37
I8291 8291 0 1.32342e-05
R9200 8291 8292 1.664 0.8 13.312 37
I8292 8292 0 1.33579e-05
R9201 8292 8293 1.68 0.8 13.44 37
I8293 8293 0 1.29868e-05
R9202 8293 8294 1.744 0.8 13.952 37
I8294 8294 0 1.29868e-05
R9203 8294 8295 1.712 0.8 13.696 37
I8295 8295 0 1.31105e-05
R9204 8295 8296 1.664 0.8 13.312 37
I8296 8296 0 1.33579e-05
R9205 8296 8297 1.68 0.8 13.44 37
I8297 8297 0 1.26158e-05
R9206 8297 8298 1.648 0.8 13.184 37
I8298 8298 0 1.33579e-05
R9207 8298 8299 1.712 0.8 13.696 37
I8299 8299 0 1.32342e-05
R9208 8299 8300 1.744 0.8 13.952 37
I8300 8300 0 1.23684e-05
R9209 8300 8301 1.632 0.8 13.056 37
I8301 8301 0 1.34816e-05
R9210 8301 8302 1.6 0.8 12.8 37
I8302 8302 0 1.32342e-05
R9211 8302 8303 1.632 0.8 13.056 37
I8303 8303 0 1.27395e-05
R9212 8303 8304 1.696 0.8 13.568 37
I8304 8304 0 1.28631e-05
R9213 8304 8305 1.6 0.8 12.8 37
I8305 8305 0 1.28631e-05
R9214 8305 8306 1.6 0.8 12.8 37
I8306 8306 0 1.28631e-05
R9215 8306 8307 1.632 0.8 13.056 37
I8307 8307 0 1.32342e-05
R9216 8307 8308 1.648 0.8 13.184 37
I8308 8308 0 1.34816e-05
R9217 8308 8309 1.632 0.8 13.056 37
I8309 8309 0 1.26158e-05
R9218 8309 8310 1.664 0.8 13.312 37
I8310 8310 0 1.26158e-05
R9219 8310 8311 1.728 0.8 13.824 37
I8311 8311 0 1.24921e-05
R9220 8311 8312 1.6 0.8 12.8 37
I8312 8312 0 1.29868e-05
R9221 8312 8313 1.648 0.8 13.184 37
I8313 8313 0 1.28631e-05
R9222 8313 8314 1.68 0.8 13.44 37
I8314 8314 0 1.27395e-05
R9223 8314 8315 1.616 0.8 12.928 37
I8315 8315 0 1.29868e-05
R9224 8315 8316 1.648 0.8 13.184 37
I8316 8316 0 1.29868e-05
R9225 8316 8317 1.696 0.8 13.568 37
I8317 8317 0 1.29868e-05
R9226 8317 8318 1.632 0.8 13.056 37
I8318 8318 0 1.34816e-05
R9227 8318 8319 1.728 0.8 13.824 37
I8319 8319 0 1.24921e-05
R9228 8319 8320 1.68 0.8 13.44 37
I8320 8320 0 1.23684e-05
R9229 8320 8321 1.712 0.8 13.696 37
I8321 8321 0 1.31105e-05
R9230 8321 8322 1.712 0.8 13.696 37
I8322 8322 0 1.34816e-05
R9231 8322 8323 1.68 0.8 13.44 37
I8323 8323 0 1.23684e-05
R9232 8323 8324 1.744 0.8 13.952 37
I8324 8324 0 1.34816e-05
R9233 8324 8325 1.664 0.8 13.312 37
I8325 8325 0 1.29868e-05
R9234 8325 8326 1.616 0.8 12.928 37
I8326 8326 0 1.28631e-05
R9235 8326 8327 1.696 0.8 13.568 37
I8327 8327 0 1.26158e-05
R9236 8327 8328 1.616 0.8 12.928 37
I8328 8328 0 1.23684e-05
R9237 8328 8329 1.696 0.8 13.568 37
I8329 8329 0 1.32342e-05
R9238 8329 8330 1.648 0.8 13.184 37
I8330 8330 0 1.34816e-05
R9239 8330 8331 1.632 0.8 13.056 37
I8331 8331 0 1.33579e-05
R9240 8331 8332 1.664 0.8 13.312 37
I8332 8332 0 1.33579e-05
R9241 8332 8333 1.68 0.8 13.44 37
I8333 8333 0 1.31105e-05
R9242 8333 8334 1.744 0.8 13.952 37
I8334 8334 0 1.31105e-05
R9243 8334 8335 1.744 0.8 13.952 37
I8335 8335 0 1.32342e-05
R9244 8335 8336 1.696 0.8 13.568 37
I8336 8336 0 1.32342e-05
R9245 8336 8337 1.68 0.8 13.44 37
I8337 8337 0 1.27395e-05
R9246 8337 8338 1.696 0.8 13.568 37
I8338 8338 0 1.23684e-05
R9247 8338 8339 1.68 0.8 13.44 37
I8339 8339 0 1.32342e-05
R9248 8339 8340 1.744 0.8 13.952 37
I8340 8340 0 1.34816e-05
R9249 8340 8341 1.648 0.8 13.184 37
I8341 8341 0 1.24921e-05
R9250 8341 8342 1.648 0.8 13.184 37
I8342 8342 0 1.24921e-05
R9251 8342 8343 1.648 0.8 13.184 37
I8343 8343 0 1.29868e-05
R9252 8343 8344 1.616 0.8 12.928 37
I8344 8344 0 1.24921e-05
R9253 8344 8345 1.632 0.8 13.056 37
I8345 8345 0 1.31105e-05
R9254 8345 8346 1.6 0.8 12.8 37
I8346 8346 0 1.31105e-05
R9255 8346 8347 1.664 0.8 13.312 37
I8347 8347 0 1.28631e-05
R9256 8347 8348 1.696 0.8 13.568 37
I8348 8348 0 1.23684e-05
R9257 8348 8349 1.632 0.8 13.056 37
I8349 8349 0 1.31105e-05
R9258 8349 8350 1.696 0.8 13.568 37
I8350 8350 0 1.28631e-05
R9259 8350 8351 1.648 0.8 13.184 37
I8351 8351 0 1.28631e-05
R9260 8351 8352 1.616 0.8 12.928 37
I8352 8352 0 1.33579e-05
R9261 8352 8353 1.728 0.8 13.824 37
I8353 8353 0 1.34816e-05
R9262 8353 8354 1.6 0.8 12.8 37
I8354 8354 0 1.27395e-05
R9263 8354 8355 1.712 0.8 13.696 37
I8355 8355 0 1.34816e-05
R9264 8355 8356 1.68 0.8 13.44 37
I8356 8356 0 1.26158e-05
R9265 8356 8357 1.6 0.8 12.8 37
I8357 8357 0 1.33579e-05
R9266 8357 8358 1.648 0.8 13.184 37
I8358 8358 0 1.29868e-05
R9267 8358 8359 1.68 0.8 13.44 37
I8359 8359 0 1.32342e-05
R9268 8359 8360 1.696 0.8 13.568 37
I8360 8360 0 1.34816e-05
R9269 8360 8361 1.648 0.8 13.184 37
I8361 8361 0 1.33579e-05
R9270 8361 8362 1.68 0.8 13.44 37
I8362 8362 0 1.23684e-05
R9271 8362 8363 1.632 0.8 13.056 37
I8363 8363 0 1.26158e-05
R9272 8363 8364 1.6 0.8 12.8 37
I8364 8364 0 1.32342e-05
R9273 8364 8365 1.6 0.8 12.8 37
I8365 8365 0 1.33579e-05
R9274 8365 8366 1.616 0.8 12.928 37
I8366 8366 0 1.29868e-05
R9275 8366 8367 1.632 0.8 13.056 37
I8367 8367 0 1.26158e-05
R9276 8367 8368 1.68 0.8 13.44 37
I8368 8368 0 1.26158e-05
R9277 8368 8369 1.648 0.8 13.184 37
I8369 8369 0 1.29868e-05
R9278 8369 8370 1.728 0.8 13.824 37
I8370 8370 0 1.26158e-05
R9279 8370 8371 1.664 0.8 13.312 37
I8371 8371 0 1.27395e-05
R9280 8371 8372 1.696 0.8 13.568 37
I8372 8372 0 1.32342e-05
R9281 8372 8373 1.648 0.8 13.184 37
I8373 8373 0 1.23684e-05
R9282 8373 8374 1.632 0.8 13.056 37
I8374 8374 0 1.34816e-05
R9283 8374 8375 1.744 0.8 13.952 37
I8375 8375 0 1.24921e-05
R9284 8375 8376 1.6 0.8 12.8 37
I8376 8376 0 1.26158e-05
R9285 8376 8377 1.744 0.8 13.952 37
I8377 8377 0 1.33579e-05
R9286 8377 8378 1.632 0.8 13.056 37
I8378 8378 0 1.28631e-05
R9287 8378 8379 1.632 0.8 13.056 37
I8379 8379 0 1.28631e-05
R9288 8379 8380 1.648 0.8 13.184 37
I8380 8380 0 1.26158e-05
R9289 8380 8381 1.664 0.8 13.312 37
I8381 8381 0 1.28631e-05
R9290 8381 8382 1.712 0.8 13.696 37
I8382 8382 0 1.34816e-05
R9291 8382 8383 1.728 0.8 13.824 37
I8383 8383 0 1.28631e-05
R9292 8383 8384 1.616 0.8 12.928 37
I8384 8384 0 1.27395e-05
R9293 8384 8385 1.744 0.8 13.952 37
I8385 8385 0 1.34816e-05
R9294 8385 8386 1.696 0.8 13.568 37
I8386 8386 0 1.29868e-05
R9295 8386 8387 1.664 0.8 13.312 37
I8387 8387 0 1.26158e-05
R9296 8387 8388 1.632 0.8 13.056 37
I8388 8388 0 1.33579e-05
R9297 8388 8389 1.664 0.8 13.312 37
I8389 8389 0 1.32342e-05
R9298 8389 8390 1.744 0.8 13.952 37
I8390 8390 0 1.27395e-05
R9299 8390 8391 1.728 0.8 13.824 37
I8391 8391 0 1.24921e-05
R9300 8391 8392 1.728 0.8 13.824 37
I8392 8392 0 1.34816e-05
R9301 8392 8393 1.744 0.8 13.952 37
I8393 8393 0 1.26158e-05
R9302 8393 8394 1.648 0.8 13.184 37
I8394 8394 0 1.24921e-05
R9303 8394 8395 1.744 0.8 13.952 37
I8395 8395 0 1.31105e-05
R9304 8395 8396 1.68 0.8 13.44 37
I8396 8396 0 1.27395e-05
R9305 8396 8397 1.632 0.8 13.056 37
I8397 8397 0 1.28631e-05
R9306 8397 8398 1.632 0.8 13.056 37
I8398 8398 0 1.26158e-05
R9307 8398 8399 1.728 0.8 13.824 37
I8399 8399 0 1.31105e-05
R9308 8399 8400 1.696 0.8 13.568 37
I8400 8400 0 1.32342e-05
R9309 8400 8401 1.712 0.8 13.696 37
I8401 8401 0 1.26158e-05
R9310 8401 8402 1.648 0.8 13.184 37
I8402 8402 0 1.26158e-05
R9311 8402 8403 1.696 0.8 13.568 37
I8403 8403 0 1.32342e-05
R9312 8403 8404 1.632 0.8 13.056 37
I8404 8404 0 1.24921e-05
R9313 8404 8405 1.664 0.8 13.312 37
I8405 8405 0 1.27395e-05
R9314 8405 8406 1.664 0.8 13.312 37
I8406 8406 0 1.28631e-05
R9315 8406 8407 1.664 0.8 13.312 37
I8407 8407 0 1.28631e-05
R9316 8407 8408 1.664 0.8 13.312 37
I8408 8408 0 1.28631e-05
R9317 8408 8409 1.712 0.8 13.696 37
I8409 8409 0 1.32342e-05
R9318 8409 8410 1.712 0.8 13.696 37
I8410 8410 0 1.31105e-05
R9319 8410 8411 1.696 0.8 13.568 37
I8411 8411 0 1.27395e-05
R9320 8411 8412 1.744 0.8 13.952 37
I8412 8412 0 1.33579e-05
R9321 8412 8413 1.712 0.8 13.696 37
I8413 8413 0 1.28631e-05
R9322 8413 8414 1.648 0.8 13.184 37
I8414 8414 0 1.31105e-05
R9323 8414 8415 1.6 0.8 12.8 37
I8415 8415 0 1.24921e-05
R9324 8415 8416 1.68 0.8 13.44 37
I8416 8416 0 1.34816e-05
R9325 8416 8417 1.68 0.8 13.44 37
I8417 8417 0 1.33579e-05
R9326 8417 8418 1.648 0.8 13.184 37
I8418 8418 0 1.24921e-05
R9327 8418 8419 1.728 0.8 13.824 37
I8419 8419 0 1.29868e-05
R9328 8419 8420 1.632 0.8 13.056 37
I8420 8420 0 1.26158e-05
R9329 8420 8421 1.6 0.8 12.8 37
I8421 8421 0 1.34816e-05
R9330 8421 8422 1.712 0.8 13.696 37
I8422 8422 0 1.29868e-05
R9331 8422 8423 1.648 0.8 13.184 37
I8423 8423 0 1.24921e-05
R9332 8423 8424 1.616 0.8 12.928 37
I8424 8424 0 1.26158e-05
R9333 8424 8425 1.6 0.8 12.8 37
I8425 8425 0 1.33579e-05
R9334 8425 8426 1.728 0.8 13.824 37
I8426 8426 0 1.33579e-05
R9335 8426 8427 1.616 0.8 12.928 37
I8427 8427 0 1.33579e-05
R9336 8427 8428 1.712 0.8 13.696 37
I8428 8428 0 1.24921e-05
R9337 8428 8429 1.664 0.8 13.312 37
I8429 8429 0 1.26158e-05
R9338 8429 8430 1.712 0.8 13.696 37
I8430 8430 0 1.31105e-05
R9339 8430 8431 1.648 0.8 13.184 37
I8431 8431 0 1.26158e-05
R9340 8431 8432 1.68 0.8 13.44 37
I8432 8432 0 1.33579e-05
R9341 8432 8433 1.648 0.8 13.184 37
I8433 8433 0 1.34816e-05
R9342 8433 8434 1.616 0.8 12.928 37
I8434 8434 0 1.24921e-05
R9343 8434 8435 1.696 0.8 13.568 37
I8435 8435 0 1.31105e-05
R9344 8435 8436 1.68 0.8 13.44 37
I8436 8436 0 1.32342e-05
R9345 8436 8437 1.68 0.8 13.44 37
I8437 8437 0 1.28631e-05
R9346 8437 8438 1.664 0.8 13.312 37
I8438 8438 0 1.23684e-05
R9347 8438 8439 1.712 0.8 13.696 37
I8439 8439 0 1.29868e-05
R9348 8439 8440 1.648 0.8 13.184 37
I8440 8440 0 1.33579e-05
R9349 8440 8441 1.648 0.8 13.184 37
I8441 8441 0 1.24921e-05
R9350 8441 8442 1.696 0.8 13.568 37
I8442 8442 0 1.32342e-05
R9351 8442 8443 1.616 0.8 12.928 37
I8443 8443 0 1.29868e-05
R9352 8443 8444 1.728 0.8 13.824 37
I8444 8444 0 1.32342e-05
R9353 8444 8445 1.744 0.8 13.952 37
I8445 8445 0 1.32342e-05
R9354 8445 8446 1.648 0.8 13.184 37
I8446 8446 0 1.26158e-05
R9355 8446 8447 1.616 0.8 12.928 37
I8447 8447 0 1.24921e-05
R9356 8447 8448 1.632 0.8 13.056 37
I8448 8448 0 1.31105e-05
R9357 8448 8449 1.632 0.8 13.056 37
I8449 8449 0 1.31105e-05
R9358 8449 8450 1.712 0.8 13.696 37
I8450 8450 0 1.33579e-05
R9359 8450 8451 1.632 0.8 13.056 37
I8451 8451 0 1.29868e-05
R9360 8451 8452 1.712 0.8 13.696 37
I8452 8452 0 1.34816e-05
R9361 8452 8453 1.744 0.8 13.952 37
I8453 8453 0 1.24921e-05
R9362 8453 8454 1.616 0.8 12.928 37
I8454 8454 0 1.32342e-05
R9363 8454 8455 1.728 0.8 13.824 37
I8455 8455 0 1.28631e-05
R9364 8455 8456 1.68 0.8 13.44 37
I8456 8456 0 1.28631e-05
R9365 8456 8457 1.728 0.8 13.824 37
I8457 8457 0 1.27395e-05
R9366 8457 8458 1.616 0.8 12.928 37
I8458 8458 0 1.24921e-05
R9367 8458 8459 1.616 0.8 12.928 37
I8459 8459 0 1.24921e-05
R9368 8459 8460 1.744 0.8 13.952 37
I8460 8460 0 1.23684e-05
R9369 8460 8461 1.6 0.8 12.8 37
I8461 8461 0 1.28631e-05
R9370 8461 8462 1.68 0.8 13.44 37
I8462 8462 0 1.24921e-05
R9371 8462 8463 1.68 0.8 13.44 37
I8463 8463 0 1.34816e-05
R9372 8463 8464 1.728 0.8 13.824 37
I8464 8464 0 1.32342e-05
R9373 8464 8465 1.68 0.8 13.44 37
I8465 8465 0 1.32342e-05
R9374 8465 8466 1.728 0.8 13.824 37
I8466 8466 0 1.34816e-05
R9375 8466 8467 1.632 0.8 13.056 37
I8467 8467 0 1.32342e-05
R9376 8467 8468 1.728 0.8 13.824 37
I8468 8468 0 1.26158e-05
R9377 8468 8469 1.744 0.8 13.952 37
I8469 8469 0 1.23684e-05
R9378 8469 8470 1.616 0.8 12.928 37
I8470 8470 0 1.34816e-05
R9379 8470 8471 1.696 0.8 13.568 37
I8471 8471 0 1.31105e-05
R9380 8471 8472 1.648 0.8 13.184 37
I8472 8472 0 1.31105e-05
R9381 8472 8473 1.616 0.8 12.928 37
I8473 8473 0 1.31105e-05
R9382 8473 8474 1.728 0.8 13.824 37
I8474 8474 0 1.28631e-05
R9383 8474 8475 1.712 0.8 13.696 37
I8475 8475 0 1.34816e-05
R9384 8475 8476 1.68 0.8 13.44 37
I8476 8476 0 1.32342e-05
R9385 8476 8477 1.68 0.8 13.44 37
I8477 8477 0 1.26158e-05
R9386 8477 8478 1.616 0.8 12.928 37
I8478 8478 0 1.27395e-05
R9387 8478 8479 1.616 0.8 12.928 37
I8479 8479 0 1.34816e-05
R9388 8479 8480 1.6 0.8 12.8 37
I8480 8480 0 1.34816e-05
R9389 8480 8481 1.728 0.8 13.824 37
I8481 8481 0 1.23684e-05
R9390 8481 8482 1.728 0.8 13.824 37
I8482 8482 0 1.24921e-05
R9391 8482 8483 1.728 0.8 13.824 37
I8483 8483 0 1.34816e-05
R9392 8483 8484 1.68 0.8 13.44 37
I8484 8484 0 1.34816e-05
R9393 8484 8485 1.744 0.8 13.952 37
I8485 8485 0 1.31105e-05
R9394 8485 8486 1.728 0.8 13.824 37
I8486 8486 0 1.32342e-05
R9395 8486 8487 1.664 0.8 13.312 37
I8487 8487 0 1.26158e-05
R9396 8487 8488 1.664 0.8 13.312 37
I8488 8488 0 1.32342e-05
R9397 8488 8489 1.728 0.8 13.824 37
I8489 8489 0 1.28631e-05
R9398 8489 8490 1.632 0.8 13.056 37
I8490 8490 0 1.33579e-05
R9399 8490 8491 1.68 0.8 13.44 37
I8491 8491 0 1.32342e-05
R9400 8491 8492 1.712 0.8 13.696 37
I8492 8492 0 1.23684e-05
R9401 8492 8493 1.744 0.8 13.952 37
I8493 8493 0 1.33579e-05
R9402 8493 8494 1.648 0.8 13.184 37
I8494 8494 0 1.26158e-05
R9403 8494 8495 1.744 0.8 13.952 37
I8495 8495 0 1.31105e-05
R9404 8495 8496 1.648 0.8 13.184 37
I8496 8496 0 1.33579e-05
R9405 8496 8497 1.696 0.8 13.568 37
I8497 8497 0 1.26158e-05
R9406 8497 8498 1.616 0.8 12.928 37
I8498 8498 0 1.31105e-05
R9407 8498 8499 1.616 0.8 12.928 37
I8499 8499 0 1.31105e-05
R9408 8499 8500 1.68 0.8 13.44 37
I8500 8500 0 1.26158e-05
R9409 8500 8501 1.664 0.8 13.312 37
I8501 8501 0 1.28631e-05
R9410 8501 8502 1.744 0.8 13.952 37
I8502 8502 0 1.33579e-05
R9411 8502 8503 1.728 0.8 13.824 37
I8503 8503 0 1.29868e-05
R9412 8503 8504 1.68 0.8 13.44 37
I8504 8504 0 1.31105e-05
R9413 8504 8505 1.744 0.8 13.952 37
I8505 8505 0 1.32342e-05
R9414 8505 8506 1.696 0.8 13.568 37
I8506 8506 0 1.28631e-05
R9415 8506 8507 1.696 0.8 13.568 37
I8507 8507 0 1.28631e-05
R9416 8507 8508 1.712 0.8 13.696 37
I8508 8508 0 1.32342e-05
R9417 8508 8509 1.632 0.8 13.056 37
I8509 8509 0 1.23684e-05
R9418 8509 8510 1.632 0.8 13.056 37
I8510 8510 0 1.28631e-05
R9419 8510 8511 1.728 0.8 13.824 37
I8511 8511 0 1.29868e-05
R9420 8511 8512 1.632 0.8 13.056 37
I8512 8512 0 1.29868e-05
R9421 8512 8513 1.744 0.8 13.952 37
I8513 8513 0 1.29868e-05
R9422 8513 8514 1.648 0.8 13.184 37
I8514 8514 0 1.26158e-05
R9423 8514 8515 1.616 0.8 12.928 37
I8515 8515 0 1.34816e-05
R9424 8515 8516 1.664 0.8 13.312 37
I8516 8516 0 1.32342e-05
R9425 8516 8517 1.68 0.8 13.44 37
I8517 8517 0 1.31105e-05
R9426 8517 8518 1.68 0.8 13.44 37
I8518 8518 0 1.27395e-05
R9427 8518 8519 1.648 0.8 13.184 37
I8519 8519 0 1.26158e-05
R9428 8519 8520 1.744 0.8 13.952 37
I8520 8520 0 1.27395e-05
R9429 8520 8521 1.632 0.8 13.056 37
I8521 8521 0 1.33579e-05
R9430 8521 8522 1.744 0.8 13.952 37
I8522 8522 0 1.23684e-05
R9431 8522 8523 1.632 0.8 13.056 37
I8523 8523 0 1.31105e-05
R9432 8523 8524 1.728 0.8 13.824 37
I8524 8524 0 1.31105e-05
R9433 8524 8525 1.744 0.8 13.952 37
I8525 8525 0 1.26158e-05
R9434 8525 8526 1.6 0.8 12.8 37
I8526 8526 0 1.32342e-05
R9435 8526 8527 1.712 0.8 13.696 37
I8527 8527 0 1.28631e-05
R9436 8527 8528 1.664 0.8 13.312 37
I8528 8528 0 1.32342e-05
R9437 8528 8529 1.744 0.8 13.952 37
I8529 8529 0 1.33579e-05
R9438 8529 8530 1.744 0.8 13.952 37
I8530 8530 0 1.26158e-05
R9439 8530 8531 1.744 0.8 13.952 37
I8531 8531 0 1.31105e-05
R9440 8531 8532 1.744 0.8 13.952 37
I8532 8532 0 1.28631e-05
R9441 8532 8533 1.664 0.8 13.312 37
I8533 8533 0 1.31105e-05
R9442 8533 8534 1.712 0.8 13.696 37
I8534 8534 0 1.32342e-05
R9443 8534 8535 1.744 0.8 13.952 37
I8535 8535 0 1.33579e-05
R9444 8535 8536 1.632 0.8 13.056 37
I8536 8536 0 1.27395e-05
R9445 8536 8537 1.696 0.8 13.568 37
I8537 8537 0 1.28631e-05
R9446 8537 8538 1.648 0.8 13.184 37
I8538 8538 0 1.33579e-05
R9447 8538 8539 1.632 0.8 13.056 37
I8539 8539 0 1.27395e-05
R9448 8539 8540 1.712 0.8 13.696 37
I8540 8540 0 1.24921e-05
R9449 8540 8541 1.68 0.8 13.44 37
I8541 8541 0 1.34816e-05
R9450 8541 8542 1.616 0.8 12.928 37
I8542 8542 0 1.27395e-05
R9451 8542 8543 1.664 0.8 13.312 37
I8543 8543 0 1.32342e-05
R9452 8543 8544 1.632 0.8 13.056 37
I8544 8544 0 1.29868e-05
R9453 8544 8545 1.68 0.8 13.44 37
I8545 8545 0 1.27395e-05
R9454 8545 8546 1.728 0.8 13.824 37
I8546 8546 0 1.31105e-05
R9455 8546 8547 1.616 0.8 12.928 37
I8547 8547 0 1.34816e-05
R9456 8547 8548 1.6 0.8 12.8 37
I8548 8548 0 1.29868e-05
R9457 8548 8549 1.696 0.8 13.568 37
I8549 8549 0 1.34816e-05
R9458 8549 8550 1.68 0.8 13.44 37
I8550 8550 0 1.32342e-05
R9459 8550 8551 1.728 0.8 13.824 37
I8551 8551 0 1.34816e-05
R9460 8551 8552 1.6 0.8 12.8 37
I8552 8552 0 1.31105e-05
R9461 8552 8553 1.648 0.8 13.184 37
I8553 8553 0 1.29868e-05
R9462 8553 8554 1.712 0.8 13.696 37
I8554 8554 0 1.31105e-05
R9463 8554 8555 1.744 0.8 13.952 37
I8555 8555 0 1.28631e-05
R9464 8555 8556 1.744 0.8 13.952 37
I8556 8556 0 1.28631e-05
R9465 8556 8557 1.648 0.8 13.184 37
I8557 8557 0 1.26158e-05
R9466 8557 8558 1.744 0.8 13.952 37
I8558 8558 0 1.34816e-05
R9467 8558 8559 1.6 0.8 12.8 37
I8559 8559 0 1.24921e-05
R9468 8559 8560 1.68 0.8 13.44 37
I8560 8560 0 1.32342e-05
R9469 8560 8561 1.68 0.8 13.44 37
I8561 8561 0 1.29868e-05
R9470 8561 8562 1.664 0.8 13.312 37
I8562 8562 0 1.31105e-05
R9471 8562 8563 1.664 0.8 13.312 37
I8563 8563 0 1.31105e-05
R9472 8563 8564 1.664 0.8 13.312 37
I8564 8564 0 1.26158e-05
R9473 8564 8565 1.696 0.8 13.568 37
I8565 8565 0 1.24921e-05
R9474 8565 8566 1.744 0.8 13.952 37
I8566 8566 0 1.28631e-05
R9475 8566 8567 1.6 0.8 12.8 37
I8567 8567 0 1.24921e-05
R9476 8567 8568 1.632 0.8 13.056 37
I8568 8568 0 1.31105e-05
R9477 8568 8569 1.744 0.8 13.952 37
I8569 8569 0 1.34816e-05
R9478 8569 8570 1.664 0.8 13.312 37
I8570 8570 0 1.33579e-05
R9479 8570 8571 1.648 0.8 13.184 37
I8571 8571 0 1.29868e-05
R9480 8571 8572 1.632 0.8 13.056 37
I8572 8572 0 1.34816e-05
R9481 8572 8573 1.728 0.8 13.824 37
I8573 8573 0 1.26158e-05
R9482 8573 8574 1.728 0.8 13.824 37
I8574 8574 0 1.33579e-05
R9483 8574 8575 1.68 0.8 13.44 37
I8575 8575 0 1.29868e-05
R9484 8575 8576 1.712 0.8 13.696 37
I8576 8576 0 1.26158e-05
R9485 8576 8577 1.6 0.8 12.8 37
I8577 8577 0 1.24921e-05
R9486 8577 8578 1.744 0.8 13.952 37
I8578 8578 0 1.32342e-05
R9487 8578 8579 1.728 0.8 13.824 37
I8579 8579 0 1.29868e-05
R9488 8579 8580 1.744 0.8 13.952 37
I8580 8580 0 1.31105e-05
R9489 8580 8581 1.696 0.8 13.568 37
I8581 8581 0 1.24921e-05
R9490 8581 8582 1.632 0.8 13.056 37
I8582 8582 0 1.33579e-05
R9491 8582 8583 1.664 0.8 13.312 37
I8583 8583 0 1.28631e-05
R9492 8583 8584 1.664 0.8 13.312 37
I8584 8584 0 1.27395e-05
R9493 8584 8585 1.664 0.8 13.312 37
I8585 8585 0 1.33579e-05
R9494 8585 8586 1.648 0.8 13.184 37
I8586 8586 0 1.34816e-05
R9495 8586 8587 1.664 0.8 13.312 37
I8587 8587 0 1.31105e-05
R9496 8587 8588 1.728 0.8 13.824 37
I8588 8588 0 1.26158e-05
R9497 8588 8589 1.6 0.8 12.8 37
I8589 8589 0 1.32342e-05
R9498 8589 8590 1.632 0.8 13.056 37
I8590 8590 0 1.32342e-05
R9499 8590 8591 1.632 0.8 13.056 37
I8591 8591 0 1.34816e-05
R9500 8591 8592 1.6 0.8 12.8 37
I8592 8592 0 1.29868e-05
R9501 8592 8593 1.648 0.8 13.184 37
I8593 8593 0 1.24921e-05
R9502 8593 8594 1.632 0.8 13.056 37
I8594 8594 0 1.27395e-05
R9503 8594 8595 1.696 0.8 13.568 37
I8595 8595 0 1.27395e-05
R9504 8595 8596 1.744 0.8 13.952 37
I8596 8596 0 1.28631e-05
R9505 8596 8597 1.696 0.8 13.568 37
I8597 8597 0 1.27395e-05
R9506 8597 8598 1.632 0.8 13.056 37
I8598 8598 0 1.27395e-05
R9507 8598 8599 1.712 0.8 13.696 37
I8599 8599 0 1.32342e-05
R9508 8599 8600 1.696 0.8 13.568 37
I8600 8600 0 1.27395e-05
R9509 8600 8601 1.712 0.8 13.696 37
I8601 8601 0 1.23684e-05
R9510 8601 8602 1.648 0.8 13.184 37
I8602 8602 0 1.24921e-05
R9511 8602 8603 1.728 0.8 13.824 37
I8603 8603 0 1.24921e-05
R9512 8603 8604 1.68 0.8 13.44 37
I8604 8604 0 1.23684e-05
R9513 8604 8605 1.6 0.8 12.8 37
I8605 8605 0 1.34816e-05
R9514 8605 8606 1.744 0.8 13.952 37
I8606 8606 0 1.29868e-05
R9515 8606 8607 1.616 0.8 12.928 37
I8607 8607 0 1.34816e-05
R9516 8607 8608 1.6 0.8 12.8 37
I8608 8608 0 1.31105e-05
R9517 8608 8609 1.6 0.8 12.8 37
I8609 8609 0 1.28631e-05
R9518 8609 8610 1.744 0.8 13.952 37
I8610 8610 0 1.33579e-05
R9519 8610 8611 1.744 0.8 13.952 37
I8611 8611 0 1.23684e-05
R9520 8611 8612 1.632 0.8 13.056 37
I8612 8612 0 1.31105e-05
R9521 8612 8613 1.648 0.8 13.184 37
I8613 8613 0 1.32342e-05
R9522 8613 8614 1.744 0.8 13.952 37
I8614 8614 0 1.26158e-05
R9523 8614 8615 1.664 0.8 13.312 37
I8615 8615 0 1.32342e-05
R9524 8615 8616 1.696 0.8 13.568 37
I8616 8616 0 1.27395e-05
R9525 8616 8617 1.744 0.8 13.952 37
I8617 8617 0 1.24921e-05
R9526 8617 8618 1.712 0.8 13.696 37
I8618 8618 0 1.34816e-05
R9527 8618 8619 1.664 0.8 13.312 37
I8619 8619 0 1.28631e-05
R9528 8619 8620 1.616 0.8 12.928 37
I8620 8620 0 1.29868e-05
R9529 8620 8621 1.664 0.8 13.312 37
I8621 8621 0 1.24921e-05
R9530 8621 8622 1.632 0.8 13.056 37
I8622 8622 0 1.32342e-05
R9531 8622 8623 1.6 0.8 12.8 37
I8623 8623 0 1.26158e-05
R9532 8623 8624 1.648 0.8 13.184 37
I8624 8624 0 1.27395e-05
R9533 8624 8625 1.728 0.8 13.824 37
I8625 8625 0 1.26158e-05
R9534 8625 8626 1.648 0.8 13.184 37
I8626 8626 0 1.32342e-05
R9535 8626 8627 1.664 0.8 13.312 37
I8627 8627 0 1.31105e-05
R9536 8627 8628 1.648 0.8 13.184 37
I8628 8628 0 1.34816e-05
R9537 8628 8629 1.68 0.8 13.44 37
I8629 8629 0 1.28631e-05
R9538 8629 8630 1.616 0.8 12.928 37
I8630 8630 0 1.24921e-05
R9539 8630 8631 1.664 0.8 13.312 37
I8631 8631 0 1.34816e-05
R9540 8631 8632 1.664 0.8 13.312 37
I8632 8632 0 1.29868e-05
R9541 8632 8633 1.632 0.8 13.056 37
I8633 8633 0 1.24921e-05
R9542 8633 8634 1.68 0.8 13.44 37
I8634 8634 0 1.32342e-05
R9543 8634 8635 1.696 0.8 13.568 37
I8635 8635 0 1.33579e-05
R9544 8635 8636 1.664 0.8 13.312 37
I8636 8636 0 1.26158e-05
R9545 8636 8637 1.744 0.8 13.952 37
I8637 8637 0 1.31105e-05
R9546 8637 8638 1.744 0.8 13.952 37
I8638 8638 0 1.26158e-05
R9547 8638 8639 1.6 0.8 12.8 37
I8639 8639 0 1.26158e-05
R9548 8639 8640 1.712 0.8 13.696 37
I8640 8640 0 1.33579e-05
R9549 8640 8641 1.696 0.8 13.568 37
I8641 8641 0 1.23684e-05
R9550 8641 8642 1.68 0.8 13.44 37
I8642 8642 0 1.23684e-05
R9551 8642 8643 1.728 0.8 13.824 37
I8643 8643 0 1.34816e-05
R9552 8643 8644 1.744 0.8 13.952 37
I8644 8644 0 1.27395e-05
R9553 8644 8645 1.68 0.8 13.44 37
I8645 8645 0 1.26158e-05
R9554 8645 8646 1.664 0.8 13.312 37
I8646 8646 0 1.34816e-05
R9555 8646 8647 1.664 0.8 13.312 37
I8647 8647 0 1.34816e-05
R9556 8647 8648 1.712 0.8 13.696 37
I8648 8648 0 1.31105e-05
R9557 8648 8649 1.632 0.8 13.056 37
I8649 8649 0 1.26158e-05
R9558 8649 8650 1.68 0.8 13.44 37
I8650 8650 0 1.23684e-05
R9559 8650 8651 1.632 0.8 13.056 37
I8651 8651 0 1.34816e-05
R9560 8651 8652 1.632 0.8 13.056 37
I8652 8652 0 1.26158e-05
R9561 8652 8653 1.712 0.8 13.696 37
I8653 8653 0 1.24921e-05
R9562 8653 8654 1.696 0.8 13.568 37
I8654 8654 0 1.32342e-05
R9563 8654 8655 1.68 0.8 13.44 37
I8655 8655 0 1.27395e-05
R9564 8655 8656 1.68 0.8 13.44 37
I8656 8656 0 1.24921e-05
R9565 8656 8657 1.648 0.8 13.184 37
I8657 8657 0 1.24921e-05
R9566 8657 8658 1.616 0.8 12.928 37
I8658 8658 0 1.26158e-05
R9567 8658 8659 1.632 0.8 13.056 37
I8659 8659 0 1.26158e-05
R9568 8659 8660 1.712 0.8 13.696 37
I8660 8660 0 1.32342e-05
R9569 8660 8661 1.712 0.8 13.696 37
I8661 8661 0 1.26158e-05
R9570 8661 8662 1.744 0.8 13.952 37
I8662 8662 0 1.24921e-05
R9571 8662 8663 1.648 0.8 13.184 37
I8663 8663 0 1.31105e-05
R9572 8663 8664 1.744 0.8 13.952 37
I8664 8664 0 1.32342e-05
R9573 8664 8665 1.6 0.8 12.8 37
I8665 8665 0 1.32342e-05
R9574 8665 8666 1.728 0.8 13.824 37
I8666 8666 0 1.26158e-05
R9575 8666 8667 1.728 0.8 13.824 37
I8667 8667 0 1.23684e-05
R9576 8667 8668 1.696 0.8 13.568 37
I8668 8668 0 1.31105e-05
R9577 8668 8669 1.664 0.8 13.312 37
I8669 8669 0 1.26158e-05
R9578 8669 8670 1.648 0.8 13.184 37
I8670 8670 0 1.34816e-05
R9579 8670 8671 1.712 0.8 13.696 37
I8671 8671 0 1.24921e-05
R9580 8671 8672 1.616 0.8 12.928 37
I8672 8672 0 1.27395e-05
R9581 8672 8673 1.632 0.8 13.056 37
I8673 8673 0 1.28631e-05
R9582 8673 8674 1.712 0.8 13.696 37
I8674 8674 0 1.31105e-05
R9583 8674 8675 1.712 0.8 13.696 37
I8675 8675 0 1.28631e-05
R9584 8675 8676 1.68 0.8 13.44 37
I8676 8676 0 1.28631e-05
R9585 8676 8677 1.728 0.8 13.824 37
I8677 8677 0 1.28631e-05
R9586 8677 8678 1.712 0.8 13.696 37
I8678 8678 0 1.24921e-05
R9587 8678 8679 1.632 0.8 13.056 37
I8679 8679 0 1.33579e-05
R9588 8679 8680 1.744 0.8 13.952 37
I8680 8680 0 1.28631e-05
R9589 8680 8681 1.68 0.8 13.44 37
I8681 8681 0 1.32342e-05
R9590 8681 8682 1.744 0.8 13.952 37
I8682 8682 0 1.31105e-05
R9591 8682 8683 1.744 0.8 13.952 37
I8683 8683 0 1.32342e-05
R9592 8683 8684 1.632 0.8 13.056 37
I8684 8684 0 1.27395e-05
R9593 8684 8685 1.632 0.8 13.056 37
I8685 8685 0 1.32342e-05
R9594 8685 8686 1.648 0.8 13.184 37
I8686 8686 0 1.34816e-05
R9595 8686 8687 1.728 0.8 13.824 37
I8687 8687 0 1.28631e-05
R9596 8687 8688 1.632 0.8 13.056 37
I8688 8688 0 1.26158e-05
R9597 8688 8689 1.6 0.8 12.8 37
I8689 8689 0 1.34816e-05
R9598 8689 8690 1.728 0.8 13.824 37
I8690 8690 0 1.32342e-05
R9599 8690 8691 1.696 0.8 13.568 37
I8691 8691 0 1.28631e-05
R9600 8691 8692 1.648 0.8 13.184 37
I8692 8692 0 1.28631e-05
R9601 8692 8693 1.6 0.8 12.8 37
I8693 8693 0 1.26158e-05
R9602 8693 8694 1.728 0.8 13.824 37
I8694 8694 0 1.29868e-05
R9603 8694 8695 1.616 0.8 12.928 37
I8695 8695 0 1.34816e-05
R9604 8695 8696 1.616 0.8 12.928 37
I8696 8696 0 1.33579e-05
R9605 8696 8697 1.728 0.8 13.824 37
I8697 8697 0 1.23684e-05
R9606 8697 8698 1.664 0.8 13.312 37
I8698 8698 0 1.32342e-05
R9607 8698 8699 1.6 0.8 12.8 37
I8699 8699 0 1.33579e-05
R9608 8699 8700 1.616 0.8 12.928 37
I8700 8700 0 1.26158e-05
R9609 8700 8701 1.728 0.8 13.824 37
I8701 8701 0 1.31105e-05
R9610 8701 8702 1.648 0.8 13.184 37
I8702 8702 0 1.31105e-05
R9611 8702 8703 1.632 0.8 13.056 37
I8703 8703 0 1.33579e-05
R9612 8703 8704 1.616 0.8 12.928 37
I8704 8704 0 1.26158e-05
R9613 8704 8705 1.744 0.8 13.952 37
I8705 8705 0 1.34816e-05
R9614 8705 8706 1.6 0.8 12.8 37
I8706 8706 0 1.29868e-05
R9615 8706 8707 1.68 0.8 13.44 37
I8707 8707 0 1.29868e-05
R9616 8707 8708 1.632 0.8 13.056 37
I8708 8708 0 1.31105e-05
R9617 8708 8709 1.6 0.8 12.8 37
I8709 8709 0 1.23684e-05
R9618 8709 8710 1.648 0.8 13.184 37
I8710 8710 0 1.27395e-05
R9619 8710 8711 1.744 0.8 13.952 37
I8711 8711 0 1.28631e-05
R9620 8711 8712 1.616 0.8 12.928 37
I8712 8712 0 1.32342e-05
R9621 8712 8713 1.712 0.8 13.696 37
I8713 8713 0 1.33579e-05
R9622 8713 8714 1.696 0.8 13.568 37
I8714 8714 0 1.32342e-05
R9623 8714 8715 1.728 0.8 13.824 37
I8715 8715 0 1.32342e-05
R9624 8715 8716 1.616 0.8 12.928 37
I8716 8716 0 1.31105e-05
R9625 8716 8717 1.68 0.8 13.44 37
I8717 8717 0 1.31105e-05
R9626 8717 8718 1.68 0.8 13.44 37
I8718 8718 0 1.32342e-05
R9627 8718 8719 1.664 0.8 13.312 37
I8719 8719 0 1.31105e-05
R9628 8719 8720 1.6 0.8 12.8 37
I8720 8720 0 1.28631e-05
R9629 8720 8721 1.712 0.8 13.696 37
I8721 8721 0 1.26158e-05
R9630 8721 8722 1.616 0.8 12.928 37
I8722 8722 0 1.27395e-05
R9631 8722 8723 1.744 0.8 13.952 37
I8723 8723 0 1.27395e-05
R9632 8723 8724 1.744 0.8 13.952 37
I8724 8724 0 1.34816e-05
R9633 8724 8725 1.648 0.8 13.184 37
I8725 8725 0 1.28631e-05
R9634 8725 8726 1.632 0.8 13.056 37
I8726 8726 0 1.28631e-05
R9635 8726 8727 1.728 0.8 13.824 37
I8727 8727 0 1.31105e-05
R9636 8727 8728 1.648 0.8 13.184 37
I8728 8728 0 1.32342e-05
R9637 8728 8729 1.664 0.8 13.312 37
I8729 8729 0 1.23684e-05
R9638 8729 8730 1.664 0.8 13.312 37
I8730 8730 0 1.28631e-05
R9639 8730 8731 1.744 0.8 13.952 37
I8731 8731 0 1.32342e-05
R9640 8731 8732 1.616 0.8 12.928 37
I8732 8732 0 1.29868e-05
R9641 8732 8733 1.664 0.8 13.312 37
I8733 8733 0 1.33579e-05
R9642 8733 8734 1.632 0.8 13.056 37
I8734 8734 0 1.33579e-05
R9643 8734 8735 1.664 0.8 13.312 37
I8735 8735 0 1.28631e-05
R9644 8735 8736 1.664 0.8 13.312 37
I8736 8736 0 1.24921e-05
R9645 8736 8737 1.696 0.8 13.568 37
I8737 8737 0 1.31105e-05
R9646 8737 8738 1.664 0.8 13.312 37
I8738 8738 0 1.31105e-05
R9647 8738 8739 1.616 0.8 12.928 37
I8739 8739 0 1.29868e-05
R9648 8739 8740 1.712 0.8 13.696 37
I8740 8740 0 1.32342e-05
R9649 8740 8741 1.744 0.8 13.952 37
I8741 8741 0 1.23684e-05
R9650 8741 8742 1.616 0.8 12.928 37
I8742 8742 0 1.23684e-05
R9651 8742 8743 1.696 0.8 13.568 37
I8743 8743 0 1.29868e-05
R9652 8743 8744 1.712 0.8 13.696 37
I8744 8744 0 1.26158e-05
R9653 8744 8745 1.68 0.8 13.44 37
I8745 8745 0 1.28631e-05
R9654 8745 8746 1.696 0.8 13.568 37
I8746 8746 0 1.28631e-05
R9655 8746 8747 1.616 0.8 12.928 37
I8747 8747 0 1.34816e-05
R9656 8747 8748 1.616 0.8 12.928 37
I8748 8748 0 1.32342e-05
R9657 8748 8749 1.712 0.8 13.696 37
I8749 8749 0 1.28631e-05
R9658 8749 8750 1.728 0.8 13.824 37
I8750 8750 0 1.24921e-05
R9659 8750 8751 1.728 0.8 13.824 37
I8751 8751 0 1.26158e-05
R9660 8751 8752 1.68 0.8 13.44 37
I8752 8752 0 1.32342e-05
R9661 8752 8753 1.6 0.8 12.8 37
I8753 8753 0 1.24921e-05
R9662 8753 8754 1.68 0.8 13.44 37
I8754 8754 0 1.28631e-05
R9663 8754 8755 1.712 0.8 13.696 37
I8755 8755 0 1.26158e-05
R9664 8755 8756 1.616 0.8 12.928 37
I8756 8756 0 1.33579e-05
R9665 8756 8757 1.664 0.8 13.312 37
I8757 8757 0 1.28631e-05
R9666 8757 8758 1.728 0.8 13.824 37
I8758 8758 0 1.23684e-05
R9667 8758 8759 1.744 0.8 13.952 37
I8759 8759 0 1.33579e-05
R9668 8759 8760 1.632 0.8 13.056 37
I8760 8760 0 1.31105e-05
R9669 8760 8761 1.632 0.8 13.056 37
I8761 8761 0 1.24921e-05
R9670 8761 8762 1.648 0.8 13.184 37
I8762 8762 0 1.29868e-05
R9671 8762 8763 1.632 0.8 13.056 37
I8763 8763 0 1.28631e-05
R9672 8763 8764 1.648 0.8 13.184 37
I8764 8764 0 1.23684e-05
R9673 8764 8765 1.6 0.8 12.8 37
I8765 8765 0 1.24921e-05
R9674 8765 8766 1.648 0.8 13.184 37
I8766 8766 0 1.34816e-05
R9675 8766 8767 1.68 0.8 13.44 37
I8767 8767 0 1.23684e-05
R9676 8767 8768 1.728 0.8 13.824 37
I8768 8768 0 1.33579e-05
R9677 8768 8769 1.632 0.8 13.056 37
I8769 8769 0 1.29868e-05
R9678 8769 8770 1.632 0.8 13.056 37
I8770 8770 0 1.34816e-05
R9679 8770 8771 1.712 0.8 13.696 37
I8771 8771 0 1.27395e-05
R9680 8771 8772 1.744 0.8 13.952 37
I8772 8772 0 1.26158e-05
R9681 8772 8773 1.712 0.8 13.696 37
I8773 8773 0 1.23684e-05
R9682 8773 8774 1.664 0.8 13.312 37
I8774 8774 0 1.34816e-05
R9683 8774 8775 1.728 0.8 13.824 37
I8775 8775 0 1.34816e-05
R9684 8775 8776 1.712 0.8 13.696 37
I8776 8776 0 1.26158e-05
R9685 8776 8777 1.632 0.8 13.056 37
I8777 8777 0 1.23684e-05
R9686 8777 8778 1.744 0.8 13.952 37
I8778 8778 0 1.28631e-05
R9687 8778 8779 1.712 0.8 13.696 37
I8779 8779 0 1.28631e-05
R9688 8779 8780 1.664 0.8 13.312 37
I8780 8780 0 1.32342e-05
R9689 8780 8781 1.712 0.8 13.696 37
I8781 8781 0 1.23684e-05
R9690 8781 8782 1.728 0.8 13.824 37
I8782 8782 0 1.27395e-05
R9691 8782 8783 1.6 0.8 12.8 37
I8783 8783 0 1.31105e-05
R9692 8783 8784 1.616 0.8 12.928 37
I8784 8784 0 1.26158e-05
R9693 8784 8785 1.648 0.8 13.184 37
I8785 8785 0 1.29868e-05
R9694 8785 8786 1.648 0.8 13.184 37
I8786 8786 0 1.24921e-05
R9695 8786 8787 1.6 0.8 12.8 37
I8787 8787 0 1.29868e-05
R9696 8787 8788 1.68 0.8 13.44 37
I8788 8788 0 1.34816e-05
R9697 8788 8789 1.68 0.8 13.44 37
I8789 8789 0 1.24921e-05
R9698 8789 8790 1.728 0.8 13.824 37
I8790 8790 0 1.29868e-05
R9699 8790 8791 1.6 0.8 12.8 37
I8791 8791 0 1.33579e-05
R9700 8791 8792 1.712 0.8 13.696 37
I8792 8792 0 1.28631e-05
R9701 8792 8793 1.6 0.8 12.8 37
I8793 8793 0 1.33579e-05
R9702 8793 8794 1.744 0.8 13.952 37
I8794 8794 0 1.32342e-05
R9703 8794 8795 1.648 0.8 13.184 37
I8795 8795 0 1.29868e-05
R9704 8795 8796 1.68 0.8 13.44 37
I8796 8796 0 1.23684e-05
R9705 8796 8797 1.68 0.8 13.44 37
I8797 8797 0 1.27395e-05
R9706 8797 8798 1.68 0.8 13.44 37
I8798 8798 0 1.33579e-05
R9707 8798 8799 1.632 0.8 13.056 37
I8799 8799 0 1.33579e-05
R9708 8799 8800 1.6 0.8 12.8 37
I8800 8800 0 1.29868e-05
R9709 8800 8801 1.648 0.8 13.184 37
I8801 8801 0 1.31105e-05
R9710 8801 8802 1.728 0.8 13.824 37
I8802 8802 0 1.27395e-05
R9711 8802 8803 1.616 0.8 12.928 37
I8803 8803 0 1.29868e-05
R9712 8803 8804 1.648 0.8 13.184 37
I8804 8804 0 1.31105e-05
R9713 8804 8805 1.744 0.8 13.952 37
I8805 8805 0 1.27395e-05
R9714 8805 8806 1.648 0.8 13.184 37
I8806 8806 0 1.24921e-05
R9715 8806 8807 1.648 0.8 13.184 37
I8807 8807 0 1.26158e-05
R9716 8807 8808 1.696 0.8 13.568 37
I8808 8808 0 1.28631e-05
R9717 8808 8809 1.6 0.8 12.8 37
I8809 8809 0 1.29868e-05
R9718 8809 8810 1.616 0.8 12.928 37
I8810 8810 0 1.27395e-05
R9719 8810 8811 1.6 0.8 12.8 37
I8811 8811 0 1.33579e-05
R9720 8811 8812 1.696 0.8 13.568 37
I8812 8812 0 1.31105e-05
R9721 8812 8813 1.664 0.8 13.312 37
I8813 8813 0 1.24921e-05
R9722 8813 8814 1.664 0.8 13.312 37
I8814 8814 0 1.31105e-05
R9723 8814 8815 1.6 0.8 12.8 37
I8815 8815 0 1.31105e-05
R9724 8815 8816 1.648 0.8 13.184 37
I8816 8816 0 1.27395e-05
R9725 8816 8817 1.632 0.8 13.056 37
I8817 8817 0 1.28631e-05
R9726 8817 8818 1.744 0.8 13.952 37
I8818 8818 0 1.29868e-05
R9727 8818 8819 1.616 0.8 12.928 37
I8819 8819 0 1.28631e-05
R9728 8819 8820 1.648 0.8 13.184 37
I8820 8820 0 1.23684e-05
R9729 8820 8821 1.744 0.8 13.952 37
I8821 8821 0 1.31105e-05
R9730 8821 8822 1.632 0.8 13.056 37
I8822 8822 0 1.27395e-05
R9731 8822 8823 1.728 0.8 13.824 37
I8823 8823 0 1.33579e-05
R9732 8823 8824 1.712 0.8 13.696 37
I8824 8824 0 1.34816e-05
R9733 8824 8825 1.68 0.8 13.44 37
I8825 8825 0 1.23684e-05
R9734 8825 8826 1.664 0.8 13.312 37
I8826 8826 0 1.29868e-05
R9735 8826 8827 1.744 0.8 13.952 37
I8827 8827 0 1.23684e-05
R9736 8827 8828 1.648 0.8 13.184 37
I8828 8828 0 1.27395e-05
R9737 8828 8829 1.632 0.8 13.056 37
I8829 8829 0 1.34816e-05
R9738 8829 8830 1.616 0.8 12.928 37
I8830 8830 0 1.26158e-05
R9739 8830 8831 1.728 0.8 13.824 37
I8831 8831 0 1.31105e-05
R9740 8831 8832 1.712 0.8 13.696 37
I8832 8832 0 1.26158e-05
R9741 8832 8833 1.6 0.8 12.8 37
I8833 8833 0 1.31105e-05
R9742 8833 8834 1.728 0.8 13.824 37
I8834 8834 0 1.28631e-05
R9743 8834 8835 1.6 0.8 12.8 37
I8835 8835 0 1.24921e-05
R9744 8835 8836 1.696 0.8 13.568 37
I8836 8836 0 1.23684e-05
R9745 8836 8837 1.6 0.8 12.8 37
I8837 8837 0 1.33579e-05
R9746 8837 8838 1.68 0.8 13.44 37
I8838 8838 0 1.33579e-05
R9747 8838 8839 1.728 0.8 13.824 37
I8839 8839 0 1.26158e-05
R9748 8839 8840 1.744 0.8 13.952 37
I8840 8840 0 1.29868e-05
R9749 8840 8841 1.632 0.8 13.056 37
I8841 8841 0 1.28631e-05
R9750 8841 8842 1.616 0.8 12.928 37
I8842 8842 0 1.27395e-05
R9751 8842 8843 1.696 0.8 13.568 37
I8843 8843 0 1.31105e-05
R9752 8843 8844 1.696 0.8 13.568 37
I8844 8844 0 1.33579e-05
R9753 8844 8845 1.696 0.8 13.568 37
I8845 8845 0 1.32342e-05
R9754 8845 8846 1.632 0.8 13.056 37
I8846 8846 0 1.31105e-05
R9755 8846 8847 1.696 0.8 13.568 37
I8847 8847 0 1.26158e-05
R9756 8847 8848 1.728 0.8 13.824 37
I8848 8848 0 1.33579e-05
R9757 8848 8849 1.728 0.8 13.824 37
I8849 8849 0 1.31105e-05
R9758 8849 8850 1.632 0.8 13.056 37
I8850 8850 0 1.24921e-05
R9759 8850 8851 1.6 0.8 12.8 37
I8851 8851 0 1.34816e-05
R9760 8851 8852 1.648 0.8 13.184 37
I8852 8852 0 1.23684e-05
R9761 8852 8853 1.744 0.8 13.952 37
I8853 8853 0 1.23684e-05
R9762 8853 8854 1.6 0.8 12.8 37
I8854 8854 0 1.23684e-05
R9763 8854 8855 1.632 0.8 13.056 37
I8855 8855 0 1.26158e-05
R9764 8855 8856 1.68 0.8 13.44 37
I8856 8856 0 1.31105e-05
R9765 8856 8857 1.728 0.8 13.824 37
I8857 8857 0 1.33579e-05
R9766 8857 8858 1.632 0.8 13.056 37
I8858 8858 0 1.28631e-05
R9767 8858 8859 1.68 0.8 13.44 37
I8859 8859 0 1.33579e-05
R9768 8859 8860 1.68 0.8 13.44 37
I8860 8860 0 1.27395e-05
R9769 8860 8861 1.728 0.8 13.824 37
I8861 8861 0 1.34816e-05
R9770 8861 8862 1.744 0.8 13.952 37
I8862 8862 0 1.28631e-05
R9771 8862 8863 1.616 0.8 12.928 37
I8863 8863 0 1.32342e-05
R9772 8863 8864 1.632 0.8 13.056 37
I8864 8864 0 1.26158e-05
R9773 8864 8865 1.696 0.8 13.568 37
I8865 8865 0 1.32342e-05
R9774 8865 8866 1.68 0.8 13.44 37
I8866 8866 0 1.33579e-05
R9775 8866 8867 1.728 0.8 13.824 37
I8867 8867 0 1.23684e-05
R9776 8867 8868 1.6 0.8 12.8 37
I8868 8868 0 1.32342e-05
R9777 8868 8869 1.6 0.8 12.8 37
I8869 8869 0 1.23684e-05
R9778 8869 8870 1.744 0.8 13.952 37
I8870 8870 0 1.28631e-05
R9779 8870 8871 1.632 0.8 13.056 37
I8871 8871 0 1.29868e-05
R9780 8871 8872 1.632 0.8 13.056 37
I8872 8872 0 1.26158e-05
R9781 8872 8873 1.648 0.8 13.184 37
I8873 8873 0 1.28631e-05
R9782 8873 8874 1.712 0.8 13.696 37
I8874 8874 0 1.23684e-05
R9783 8874 8875 1.648 0.8 13.184 37
I8875 8875 0 1.26158e-05
R9784 8875 8876 1.648 0.8 13.184 37
I8876 8876 0 1.27395e-05
R9785 8876 8877 1.648 0.8 13.184 37
I8877 8877 0 1.28631e-05
R9786 8877 8878 1.744 0.8 13.952 37
I8878 8878 0 1.29868e-05
R9787 8878 8879 1.632 0.8 13.056 37
I8879 8879 0 1.24921e-05
R9788 8879 8880 1.712 0.8 13.696 37
I8880 8880 0 1.23684e-05
R9789 8880 8881 1.6 0.8 12.8 37
I8881 8881 0 1.28631e-05
R9790 8881 8882 1.728 0.8 13.824 37
I8882 8882 0 1.33579e-05
R9791 8882 8883 1.664 0.8 13.312 37
I8883 8883 0 1.33579e-05
R9792 8883 8884 1.696 0.8 13.568 37
I8884 8884 0 1.28631e-05
R9793 8884 8885 1.6 0.8 12.8 37
I8885 8885 0 1.32342e-05
R9794 8885 8886 1.728 0.8 13.824 37
I8886 8886 0 1.29868e-05
R9795 8886 8887 1.632 0.8 13.056 37
I8887 8887 0 1.23684e-05
R9796 8887 8888 1.712 0.8 13.696 37
I8888 8888 0 1.33579e-05
R9797 8888 8889 1.68 0.8 13.44 37
I8889 8889 0 1.28631e-05
R9798 8889 8890 1.6 0.8 12.8 37
I8890 8890 0 1.23684e-05
R9799 8890 8891 1.728 0.8 13.824 37
I8891 8891 0 1.28631e-05
R9800 8891 8892 1.68 0.8 13.44 37
I8892 8892 0 1.26158e-05
R9801 8892 8893 1.728 0.8 13.824 37
I8893 8893 0 1.28631e-05
R9802 8893 8894 1.744 0.8 13.952 37
I8894 8894 0 1.26158e-05
R9803 8894 8895 1.712 0.8 13.696 37
I8895 8895 0 1.31105e-05
R9804 8895 8896 1.664 0.8 13.312 37
I8896 8896 0 1.33579e-05
R9805 8896 8897 1.6 0.8 12.8 37
I8897 8897 0 1.26158e-05
R9806 8897 8898 1.696 0.8 13.568 37
I8898 8898 0 1.28631e-05
R9807 8898 8899 1.6 0.8 12.8 37
I8899 8899 0 1.28631e-05
R9808 8899 8900 1.6 0.8 12.8 37
I8900 8900 0 1.27395e-05
R9809 8900 8901 1.632 0.8 13.056 37
I8901 8901 0 1.33579e-05
R9810 8901 8902 1.728 0.8 13.824 37
I8902 8902 0 1.31105e-05
R9811 8902 8903 1.6 0.8 12.8 37
I8903 8903 0 1.29868e-05
R9812 8903 8904 1.696 0.8 13.568 37
I8904 8904 0 1.32342e-05
R9813 8904 8905 1.632 0.8 13.056 37
I8905 8905 0 1.32342e-05
R9814 8905 8906 1.744 0.8 13.952 37
I8906 8906 0 1.23684e-05
R9815 8906 8907 1.648 0.8 13.184 37
I8907 8907 0 1.28631e-05
R9816 8907 8908 1.664 0.8 13.312 37
I8908 8908 0 1.27395e-05
R9817 8908 8909 1.6 0.8 12.8 37
I8909 8909 0 1.27395e-05
R9818 8909 8910 1.696 0.8 13.568 37
I8910 8910 0 1.33579e-05
R9819 8910 8911 1.616 0.8 12.928 37
I8911 8911 0 1.26158e-05
R9820 8911 8912 1.728 0.8 13.824 37
I8912 8912 0 1.24921e-05
R9821 8912 8913 1.68 0.8 13.44 37
I8913 8913 0 1.28631e-05
R9822 8913 8914 1.712 0.8 13.696 37
I8914 8914 0 1.32342e-05
R9823 8914 8915 1.616 0.8 12.928 37
I8915 8915 0 1.34816e-05
R9824 8915 8916 1.6 0.8 12.8 37
I8916 8916 0 1.29868e-05
R9825 8916 8917 1.744 0.8 13.952 37
I8917 8917 0 1.33579e-05
R9826 8917 8918 1.648 0.8 13.184 37
I8918 8918 0 1.26158e-05
R9827 8918 8919 1.696 0.8 13.568 37
I8919 8919 0 1.23684e-05
R9828 8919 8920 1.744 0.8 13.952 37
I8920 8920 0 1.33579e-05
R9829 8920 8921 1.744 0.8 13.952 37
I8921 8921 0 1.24921e-05
R9830 8921 8922 1.6 0.8 12.8 37
I8922 8922 0 1.26158e-05
R9831 8922 8923 1.712 0.8 13.696 37
I8923 8923 0 1.29868e-05
R9832 8923 8924 1.68 0.8 13.44 37
I8924 8924 0 1.33579e-05
R9833 8924 8925 1.728 0.8 13.824 37
I8925 8925 0 1.27395e-05
R9834 8925 8926 1.728 0.8 13.824 37
I8926 8926 0 1.23684e-05
R9835 8926 8927 1.696 0.8 13.568 37
I8927 8927 0 1.31105e-05
R9836 8927 8928 1.648 0.8 13.184 37
I8928 8928 0 1.24921e-05
R9837 8928 8929 1.632 0.8 13.056 37
I8929 8929 0 1.27395e-05
R9838 8929 8930 1.6 0.8 12.8 37
I8930 8930 0 1.27395e-05
R9839 8930 8931 1.664 0.8 13.312 37
I8931 8931 0 1.24921e-05
R9840 8931 8932 1.6 0.8 12.8 37
I8932 8932 0 1.28631e-05
R9841 8932 8933 1.616 0.8 12.928 37
I8933 8933 0 1.28631e-05
R9842 8933 8934 1.696 0.8 13.568 37
I8934 8934 0 1.32342e-05
R9843 8934 8935 1.696 0.8 13.568 37
I8935 8935 0 1.32342e-05
R9844 8935 8936 1.68 0.8 13.44 37
I8936 8936 0 1.29868e-05
R9845 8936 8937 1.728 0.8 13.824 37
I8937 8937 0 1.31105e-05
R9846 8937 8938 1.712 0.8 13.696 37
I8938 8938 0 1.31105e-05
R9847 8938 8939 1.648 0.8 13.184 37
I8939 8939 0 1.28631e-05
R9848 8939 8940 1.696 0.8 13.568 37
I8940 8940 0 1.24921e-05
R9849 8940 8941 1.728 0.8 13.824 37
I8941 8941 0 1.31105e-05
R9850 8941 8942 1.648 0.8 13.184 37
I8942 8942 0 1.28631e-05
R9851 8942 8943 1.632 0.8 13.056 37
I8943 8943 0 1.34816e-05
R9852 8943 8944 1.712 0.8 13.696 37
I8944 8944 0 1.31105e-05
R9853 8944 8945 1.664 0.8 13.312 37
I8945 8945 0 1.34816e-05
R9854 8945 8946 1.632 0.8 13.056 37
I8946 8946 0 1.33579e-05
R9855 8946 8947 1.6 0.8 12.8 37
I8947 8947 0 1.26158e-05
R9856 8947 8948 1.632 0.8 13.056 37
I8948 8948 0 1.26158e-05
R9857 8948 8949 1.728 0.8 13.824 37
I8949 8949 0 1.33579e-05
R9858 8949 8950 1.616 0.8 12.928 37
I8950 8950 0 1.28631e-05
R9859 8950 8951 1.728 0.8 13.824 37
I8951 8951 0 1.32342e-05
R9860 8951 8952 1.744 0.8 13.952 37
I8952 8952 0 1.31105e-05
R9861 8952 8953 1.68 0.8 13.44 37
I8953 8953 0 1.33579e-05
R9862 8953 8954 1.664 0.8 13.312 37
I8954 8954 0 1.33579e-05
R9863 8954 8955 1.648 0.8 13.184 37
I8955 8955 0 1.26158e-05
R9864 8955 8956 1.616 0.8 12.928 37
I8956 8956 0 1.24921e-05
R9865 8956 8957 1.728 0.8 13.824 37
I8957 8957 0 1.32342e-05
R9866 8957 8958 1.712 0.8 13.696 37
I8958 8958 0 1.26158e-05
R9867 8958 8959 1.696 0.8 13.568 37
I8959 8959 0 1.31105e-05
R9868 8959 8960 1.744 0.8 13.952 37
I8960 8960 0 1.23684e-05
R9869 8960 8961 1.68 0.8 13.44 37
I8961 8961 0 1.24921e-05
R9870 8961 8962 1.728 0.8 13.824 37
I8962 8962 0 1.33579e-05
R9871 8962 8963 1.648 0.8 13.184 37
I8963 8963 0 1.27395e-05
R9872 8963 8964 1.632 0.8 13.056 37
I8964 8964 0 1.26158e-05
R9873 8964 8965 1.648 0.8 13.184 37
I8965 8965 0 1.27395e-05
R9874 8965 8966 1.728 0.8 13.824 37
I8966 8966 0 1.24921e-05
R9875 8966 8967 1.6 0.8 12.8 37
I8967 8967 0 1.33579e-05
R9876 8967 8968 1.6 0.8 12.8 37
I8968 8968 0 1.32342e-05
R9877 8968 8969 1.696 0.8 13.568 37
I8969 8969 0 1.28631e-05
R9878 8969 8970 1.712 0.8 13.696 37
I8970 8970 0 1.34816e-05
R9879 8970 8971 1.744 0.8 13.952 37
I8971 8971 0 1.34816e-05
R9880 8971 8972 1.632 0.8 13.056 37
I8972 8972 0 1.32342e-05
R9881 8972 8973 1.728 0.8 13.824 37
I8973 8973 0 1.34816e-05
R9882 8973 8974 1.632 0.8 13.056 37
I8974 8974 0 1.28631e-05
R9883 8974 8975 1.712 0.8 13.696 37
I8975 8975 0 1.24921e-05
R9884 8975 8976 1.696 0.8 13.568 37
I8976 8976 0 1.27395e-05
R9885 8976 8977 1.632 0.8 13.056 37
I8977 8977 0 1.31105e-05
R9886 8977 8978 1.648 0.8 13.184 37
I8978 8978 0 1.32342e-05
R9887 8978 8979 1.744 0.8 13.952 37
I8979 8979 0 1.29868e-05
R9888 8979 8980 1.616 0.8 12.928 37
I8980 8980 0 1.29868e-05
R9889 8980 8981 1.728 0.8 13.824 37
I8981 8981 0 1.23684e-05
R9890 8981 8982 1.696 0.8 13.568 37
I8982 8982 0 1.24921e-05
R9891 8982 8983 1.728 0.8 13.824 37
I8983 8983 0 1.31105e-05
R9892 8983 8984 1.728 0.8 13.824 37
I8984 8984 0 1.31105e-05
R9893 8984 8985 1.648 0.8 13.184 37
I8985 8985 0 1.33579e-05
R9894 8985 8986 1.728 0.8 13.824 37
I8986 8986 0 1.26158e-05
R9895 8986 8987 1.712 0.8 13.696 37
I8987 8987 0 1.23684e-05
R9896 8987 8988 1.616 0.8 12.928 37
I8988 8988 0 1.32342e-05
R9897 8988 8989 1.632 0.8 13.056 37
I8989 8989 0 1.27395e-05
R9898 8989 8990 1.616 0.8 12.928 37
I8990 8990 0 1.34816e-05
R9899 8990 8991 1.696 0.8 13.568 37
I8991 8991 0 1.34816e-05
R9900 8991 8992 1.664 0.8 13.312 37
I8992 8992 0 1.33579e-05
R9901 8992 8993 1.712 0.8 13.696 37
I8993 8993 0 1.32342e-05
R9902 8993 8994 1.728 0.8 13.824 37
I8994 8994 0 1.32342e-05
R9903 8994 8995 1.632 0.8 13.056 37
I8995 8995 0 1.34816e-05
R9904 8995 8996 1.664 0.8 13.312 37
I8996 8996 0 1.27395e-05
R9905 8996 8997 1.744 0.8 13.952 37
I8997 8997 0 1.26158e-05
R9906 8997 8998 1.664 0.8 13.312 37
I8998 8998 0 1.34816e-05
R9907 8998 8999 1.616 0.8 12.928 37
I8999 8999 0 1.28631e-05
R9908 8999 9000 1.696 0.8 13.568 37
I9000 9000 0 1.23684e-05
R9909 9000 10001 0.5 10 50 37
*seg: 10
R9910 10001 9001 0.4 20 80 37
I9001 9001 0 1.28631e-05
R9911 9001 9002 1.632 0.8 13.056 37
I9002 9002 0 1.31105e-05
R9912 9002 9003 1.728 0.8 13.824 37
I9003 9003 0 1.24921e-05
R9913 9003 9004 1.696 0.8 13.568 37
I9004 9004 0 1.24921e-05
R9914 9004 9005 1.728 0.8 13.824 37
I9005 9005 0 1.33579e-05
R9915 9005 9006 1.712 0.8 13.696 37
I9006 9006 0 1.24921e-05
R9916 9006 9007 1.6 0.8 12.8 37
I9007 9007 0 1.27395e-05
R9917 9007 9008 1.6 0.8 12.8 37
I9008 9008 0 1.28631e-05
R9918 9008 9009 1.664 0.8 13.312 37
I9009 9009 0 1.33579e-05
R9919 9009 9010 1.664 0.8 13.312 37
I9010 9010 0 1.26158e-05
R9920 9010 9011 1.712 0.8 13.696 37
I9011 9011 0 1.33579e-05
R9921 9011 9012 1.616 0.8 12.928 37
I9012 9012 0 1.24921e-05
R9922 9012 9013 1.616 0.8 12.928 37
I9013 9013 0 1.27395e-05
R9923 9013 9014 1.68 0.8 13.44 37
I9014 9014 0 1.29868e-05
R9924 9014 9015 1.632 0.8 13.056 37
I9015 9015 0 1.31105e-05
R9925 9015 9016 1.6 0.8 12.8 37
I9016 9016 0 1.23684e-05
R9926 9016 9017 1.6 0.8 12.8 37
I9017 9017 0 1.26158e-05
R9927 9017 9018 1.696 0.8 13.568 37
I9018 9018 0 1.23684e-05
R9928 9018 9019 1.696 0.8 13.568 37
I9019 9019 0 1.29868e-05
R9929 9019 9020 1.632 0.8 13.056 37
I9020 9020 0 1.28631e-05
R9930 9020 9021 1.648 0.8 13.184 37
I9021 9021 0 1.24921e-05
R9931 9021 9022 1.696 0.8 13.568 37
I9022 9022 0 1.29868e-05
R9932 9022 9023 1.664 0.8 13.312 37
I9023 9023 0 1.33579e-05
R9933 9023 9024 1.6 0.8 12.8 37
I9024 9024 0 1.33579e-05
R9934 9024 9025 1.728 0.8 13.824 37
I9025 9025 0 1.31105e-05
R9935 9025 9026 1.632 0.8 13.056 37
I9026 9026 0 1.29868e-05
R9936 9026 9027 1.664 0.8 13.312 37
I9027 9027 0 1.28631e-05
R9937 9027 9028 1.728 0.8 13.824 37
I9028 9028 0 1.31105e-05
R9938 9028 9029 1.744 0.8 13.952 37
I9029 9029 0 1.28631e-05
R9939 9029 9030 1.616 0.8 12.928 37
I9030 9030 0 1.27395e-05
R9940 9030 9031 1.6 0.8 12.8 37
I9031 9031 0 1.27395e-05
R9941 9031 9032 1.664 0.8 13.312 37
I9032 9032 0 1.27395e-05
R9942 9032 9033 1.728 0.8 13.824 37
I9033 9033 0 1.26158e-05
R9943 9033 9034 1.68 0.8 13.44 37
I9034 9034 0 1.28631e-05
R9944 9034 9035 1.712 0.8 13.696 37
I9035 9035 0 1.34816e-05
R9945 9035 9036 1.728 0.8 13.824 37
I9036 9036 0 1.27395e-05
R9946 9036 9037 1.6 0.8 12.8 37
I9037 9037 0 1.31105e-05
R9947 9037 9038 1.728 0.8 13.824 37
I9038 9038 0 1.32342e-05
R9948 9038 9039 1.68 0.8 13.44 37
I9039 9039 0 1.23684e-05
R9949 9039 9040 1.68 0.8 13.44 37
I9040 9040 0 1.27395e-05
R9950 9040 9041 1.696 0.8 13.568 37
I9041 9041 0 1.33579e-05
R9951 9041 9042 1.616 0.8 12.928 37
I9042 9042 0 1.27395e-05
R9952 9042 9043 1.664 0.8 13.312 37
I9043 9043 0 1.24921e-05
R9953 9043 9044 1.744 0.8 13.952 37
I9044 9044 0 1.27395e-05
R9954 9044 9045 1.712 0.8 13.696 37
I9045 9045 0 1.23684e-05
R9955 9045 9046 1.728 0.8 13.824 37
I9046 9046 0 1.33579e-05
R9956 9046 9047 1.696 0.8 13.568 37
I9047 9047 0 1.26158e-05
R9957 9047 9048 1.648 0.8 13.184 37
I9048 9048 0 1.28631e-05
R9958 9048 9049 1.712 0.8 13.696 37
I9049 9049 0 1.33579e-05
R9959 9049 9050 1.728 0.8 13.824 37
I9050 9050 0 1.31105e-05
R9960 9050 9051 1.6 0.8 12.8 37
I9051 9051 0 1.33579e-05
R9961 9051 9052 1.616 0.8 12.928 37
I9052 9052 0 1.23684e-05
R9962 9052 9053 1.68 0.8 13.44 37
I9053 9053 0 1.26158e-05
R9963 9053 9054 1.712 0.8 13.696 37
I9054 9054 0 1.26158e-05
R9964 9054 9055 1.664 0.8 13.312 37
I9055 9055 0 1.29868e-05
R9965 9055 9056 1.712 0.8 13.696 37
I9056 9056 0 1.27395e-05
R9966 9056 9057 1.68 0.8 13.44 37
I9057 9057 0 1.23684e-05
R9967 9057 9058 1.696 0.8 13.568 37
I9058 9058 0 1.24921e-05
R9968 9058 9059 1.632 0.8 13.056 37
I9059 9059 0 1.29868e-05
R9969 9059 9060 1.696 0.8 13.568 37
I9060 9060 0 1.34816e-05
R9970 9060 9061 1.712 0.8 13.696 37
I9061 9061 0 1.28631e-05
R9971 9061 9062 1.744 0.8 13.952 37
I9062 9062 0 1.27395e-05
R9972 9062 9063 1.744 0.8 13.952 37
I9063 9063 0 1.28631e-05
R9973 9063 9064 1.712 0.8 13.696 37
I9064 9064 0 1.31105e-05
R9974 9064 9065 1.68 0.8 13.44 37
I9065 9065 0 1.32342e-05
R9975 9065 9066 1.664 0.8 13.312 37
I9066 9066 0 1.29868e-05
R9976 9066 9067 1.696 0.8 13.568 37
I9067 9067 0 1.31105e-05
R9977 9067 9068 1.68 0.8 13.44 37
I9068 9068 0 1.27395e-05
R9978 9068 9069 1.728 0.8 13.824 37
I9069 9069 0 1.29868e-05
R9979 9069 9070 1.712 0.8 13.696 37
I9070 9070 0 1.26158e-05
R9980 9070 9071 1.6 0.8 12.8 37
I9071 9071 0 1.31105e-05
R9981 9071 9072 1.712 0.8 13.696 37
I9072 9072 0 1.29868e-05
R9982 9072 9073 1.712 0.8 13.696 37
I9073 9073 0 1.27395e-05
R9983 9073 9074 1.696 0.8 13.568 37
I9074 9074 0 1.24921e-05
R9984 9074 9075 1.728 0.8 13.824 37
I9075 9075 0 1.28631e-05
R9985 9075 9076 1.632 0.8 13.056 37
I9076 9076 0 1.31105e-05
R9986 9076 9077 1.728 0.8 13.824 37
I9077 9077 0 1.28631e-05
R9987 9077 9078 1.616 0.8 12.928 37
I9078 9078 0 1.32342e-05
R9988 9078 9079 1.728 0.8 13.824 37
I9079 9079 0 1.24921e-05
R9989 9079 9080 1.648 0.8 13.184 37
I9080 9080 0 1.27395e-05
R9990 9080 9081 1.728 0.8 13.824 37
I9081 9081 0 1.33579e-05
R9991 9081 9082 1.728 0.8 13.824 37
I9082 9082 0 1.31105e-05
R9992 9082 9083 1.696 0.8 13.568 37
I9083 9083 0 1.31105e-05
R9993 9083 9084 1.616 0.8 12.928 37
I9084 9084 0 1.31105e-05
R9994 9084 9085 1.616 0.8 12.928 37
I9085 9085 0 1.23684e-05
R9995 9085 9086 1.6 0.8 12.8 37
I9086 9086 0 1.27395e-05
R9996 9086 9087 1.712 0.8 13.696 37
I9087 9087 0 1.33579e-05
R9997 9087 9088 1.6 0.8 12.8 37
I9088 9088 0 1.31105e-05
R9998 9088 9089 1.616 0.8 12.928 37
I9089 9089 0 1.33579e-05
R9999 9089 9090 1.744 0.8 13.952 37
I9090 9090 0 1.23684e-05
R10000 9090 9091 1.632 0.8 13.056 37
I9091 9091 0 1.24921e-05
R10001 9091 9092 1.728 0.8 13.824 37
I9092 9092 0 1.23684e-05
R10002 9092 9093 1.68 0.8 13.44 37
I9093 9093 0 1.34816e-05
R10003 9093 9094 1.728 0.8 13.824 37
I9094 9094 0 1.28631e-05
R10004 9094 9095 1.632 0.8 13.056 37
I9095 9095 0 1.27395e-05
R10005 9095 9096 1.744 0.8 13.952 37
I9096 9096 0 1.24921e-05
R10006 9096 9097 1.648 0.8 13.184 37
I9097 9097 0 1.23684e-05
R10007 9097 9098 1.744 0.8 13.952 37
I9098 9098 0 1.34816e-05
R10008 9098 9099 1.696 0.8 13.568 37
I9099 9099 0 1.24921e-05
R10009 9099 9100 1.68 0.8 13.44 37
I9100 9100 0 1.34816e-05
R10010 9100 9101 1.616 0.8 12.928 37
I9101 9101 0 1.31105e-05
R10011 9101 9102 1.664 0.8 13.312 37
I9102 9102 0 1.23684e-05
R10012 9102 9103 1.664 0.8 13.312 37
I9103 9103 0 1.28631e-05
R10013 9103 9104 1.728 0.8 13.824 37
I9104 9104 0 1.32342e-05
R10014 9104 9105 1.632 0.8 13.056 37
I9105 9105 0 1.32342e-05
R10015 9105 9106 1.712 0.8 13.696 37
I9106 9106 0 1.28631e-05
R10016 9106 9107 1.616 0.8 12.928 37
I9107 9107 0 1.32342e-05
R10017 9107 9108 1.696 0.8 13.568 37
I9108 9108 0 1.31105e-05
R10018 9108 9109 1.744 0.8 13.952 37
I9109 9109 0 1.28631e-05
R10019 9109 9110 1.632 0.8 13.056 37
I9110 9110 0 1.24921e-05
R10020 9110 9111 1.6 0.8 12.8 37
I9111 9111 0 1.26158e-05
R10021 9111 9112 1.664 0.8 13.312 37
I9112 9112 0 1.27395e-05
R10022 9112 9113 1.664 0.8 13.312 37
I9113 9113 0 1.28631e-05
R10023 9113 9114 1.68 0.8 13.44 37
I9114 9114 0 1.23684e-05
R10024 9114 9115 1.68 0.8 13.44 37
I9115 9115 0 1.23684e-05
R10025 9115 9116 1.616 0.8 12.928 37
I9116 9116 0 1.33579e-05
R10026 9116 9117 1.728 0.8 13.824 37
I9117 9117 0 1.29868e-05
R10027 9117 9118 1.616 0.8 12.928 37
I9118 9118 0 1.28631e-05
R10028 9118 9119 1.616 0.8 12.928 37
I9119 9119 0 1.24921e-05
R10029 9119 9120 1.632 0.8 13.056 37
I9120 9120 0 1.27395e-05
R10030 9120 9121 1.744 0.8 13.952 37
I9121 9121 0 1.24921e-05
R10031 9121 9122 1.744 0.8 13.952 37
I9122 9122 0 1.23684e-05
R10032 9122 9123 1.744 0.8 13.952 37
I9123 9123 0 1.32342e-05
R10033 9123 9124 1.728 0.8 13.824 37
I9124 9124 0 1.33579e-05
R10034 9124 9125 1.664 0.8 13.312 37
I9125 9125 0 1.24921e-05
R10035 9125 9126 1.616 0.8 12.928 37
I9126 9126 0 1.28631e-05
R10036 9126 9127 1.68 0.8 13.44 37
I9127 9127 0 1.31105e-05
R10037 9127 9128 1.712 0.8 13.696 37
I9128 9128 0 1.34816e-05
R10038 9128 9129 1.6 0.8 12.8 37
I9129 9129 0 1.26158e-05
R10039 9129 9130 1.616 0.8 12.928 37
I9130 9130 0 1.32342e-05
R10040 9130 9131 1.68 0.8 13.44 37
I9131 9131 0 1.28631e-05
R10041 9131 9132 1.712 0.8 13.696 37
I9132 9132 0 1.27395e-05
R10042 9132 9133 1.616 0.8 12.928 37
I9133 9133 0 1.33579e-05
R10043 9133 9134 1.728 0.8 13.824 37
I9134 9134 0 1.26158e-05
R10044 9134 9135 1.6 0.8 12.8 37
I9135 9135 0 1.26158e-05
R10045 9135 9136 1.68 0.8 13.44 37
I9136 9136 0 1.24921e-05
R10046 9136 9137 1.648 0.8 13.184 37
I9137 9137 0 1.31105e-05
R10047 9137 9138 1.648 0.8 13.184 37
I9138 9138 0 1.26158e-05
R10048 9138 9139 1.648 0.8 13.184 37
I9139 9139 0 1.24921e-05
R10049 9139 9140 1.632 0.8 13.056 37
I9140 9140 0 1.32342e-05
R10050 9140 9141 1.664 0.8 13.312 37
I9141 9141 0 1.28631e-05
R10051 9141 9142 1.648 0.8 13.184 37
I9142 9142 0 1.34816e-05
R10052 9142 9143 1.632 0.8 13.056 37
I9143 9143 0 1.24921e-05
R10053 9143 9144 1.6 0.8 12.8 37
I9144 9144 0 1.26158e-05
R10054 9144 9145 1.68 0.8 13.44 37
I9145 9145 0 1.27395e-05
R10055 9145 9146 1.616 0.8 12.928 37
I9146 9146 0 1.26158e-05
R10056 9146 9147 1.712 0.8 13.696 37
I9147 9147 0 1.33579e-05
R10057 9147 9148 1.728 0.8 13.824 37
I9148 9148 0 1.33579e-05
R10058 9148 9149 1.744 0.8 13.952 37
I9149 9149 0 1.33579e-05
R10059 9149 9150 1.632 0.8 13.056 37
I9150 9150 0 1.24921e-05
R10060 9150 9151 1.6 0.8 12.8 37
I9151 9151 0 1.32342e-05
R10061 9151 9152 1.632 0.8 13.056 37
I9152 9152 0 1.27395e-05
R10062 9152 9153 1.68 0.8 13.44 37
I9153 9153 0 1.29868e-05
R10063 9153 9154 1.696 0.8 13.568 37
I9154 9154 0 1.24921e-05
R10064 9154 9155 1.728 0.8 13.824 37
I9155 9155 0 1.23684e-05
R10065 9155 9156 1.728 0.8 13.824 37
I9156 9156 0 1.27395e-05
R10066 9156 9157 1.664 0.8 13.312 37
I9157 9157 0 1.26158e-05
R10067 9157 9158 1.664 0.8 13.312 37
I9158 9158 0 1.33579e-05
R10068 9158 9159 1.68 0.8 13.44 37
I9159 9159 0 1.32342e-05
R10069 9159 9160 1.6 0.8 12.8 37
I9160 9160 0 1.26158e-05
R10070 9160 9161 1.6 0.8 12.8 37
I9161 9161 0 1.24921e-05
R10071 9161 9162 1.712 0.8 13.696 37
I9162 9162 0 1.23684e-05
R10072 9162 9163 1.632 0.8 13.056 37
I9163 9163 0 1.29868e-05
R10073 9163 9164 1.6 0.8 12.8 37
I9164 9164 0 1.24921e-05
R10074 9164 9165 1.648 0.8 13.184 37
I9165 9165 0 1.27395e-05
R10075 9165 9166 1.632 0.8 13.056 37
I9166 9166 0 1.27395e-05
R10076 9166 9167 1.632 0.8 13.056 37
I9167 9167 0 1.31105e-05
R10077 9167 9168 1.696 0.8 13.568 37
I9168 9168 0 1.23684e-05
R10078 9168 9169 1.648 0.8 13.184 37
I9169 9169 0 1.28631e-05
R10079 9169 9170 1.616 0.8 12.928 37
I9170 9170 0 1.24921e-05
R10080 9170 9171 1.68 0.8 13.44 37
I9171 9171 0 1.24921e-05
R10081 9171 9172 1.696 0.8 13.568 37
I9172 9172 0 1.24921e-05
R10082 9172 9173 1.68 0.8 13.44 37
I9173 9173 0 1.27395e-05
R10083 9173 9174 1.6 0.8 12.8 37
I9174 9174 0 1.26158e-05
R10084 9174 9175 1.6 0.8 12.8 37
I9175 9175 0 1.26158e-05
R10085 9175 9176 1.68 0.8 13.44 37
I9176 9176 0 1.26158e-05
R10086 9176 9177 1.696 0.8 13.568 37
I9177 9177 0 1.28631e-05
R10087 9177 9178 1.664 0.8 13.312 37
I9178 9178 0 1.33579e-05
R10088 9178 9179 1.744 0.8 13.952 37
I9179 9179 0 1.29868e-05
R10089 9179 9180 1.744 0.8 13.952 37
I9180 9180 0 1.28631e-05
R10090 9180 9181 1.6 0.8 12.8 37
I9181 9181 0 1.27395e-05
R10091 9181 9182 1.712 0.8 13.696 37
I9182 9182 0 1.28631e-05
R10092 9182 9183 1.744 0.8 13.952 37
I9183 9183 0 1.29868e-05
R10093 9183 9184 1.664 0.8 13.312 37
I9184 9184 0 1.28631e-05
R10094 9184 9185 1.632 0.8 13.056 37
I9185 9185 0 1.29868e-05
R10095 9185 9186 1.712 0.8 13.696 37
I9186 9186 0 1.34816e-05
R10096 9186 9187 1.744 0.8 13.952 37
I9187 9187 0 1.31105e-05
R10097 9187 9188 1.632 0.8 13.056 37
I9188 9188 0 1.28631e-05
R10098 9188 9189 1.744 0.8 13.952 37
I9189 9189 0 1.28631e-05
R10099 9189 9190 1.712 0.8 13.696 37
I9190 9190 0 1.24921e-05
R10100 9190 9191 1.712 0.8 13.696 37
I9191 9191 0 1.28631e-05
R10101 9191 9192 1.648 0.8 13.184 37
I9192 9192 0 1.27395e-05
R10102 9192 9193 1.728 0.8 13.824 37
I9193 9193 0 1.23684e-05
R10103 9193 9194 1.616 0.8 12.928 37
I9194 9194 0 1.32342e-05
R10104 9194 9195 1.712 0.8 13.696 37
I9195 9195 0 1.26158e-05
R10105 9195 9196 1.648 0.8 13.184 37
I9196 9196 0 1.32342e-05
R10106 9196 9197 1.712 0.8 13.696 37
I9197 9197 0 1.23684e-05
R10107 9197 9198 1.616 0.8 12.928 37
I9198 9198 0 1.33579e-05
R10108 9198 9199 1.712 0.8 13.696 37
I9199 9199 0 1.33579e-05
R10109 9199 9200 1.632 0.8 13.056 37
I9200 9200 0 1.24921e-05
R10110 9200 9201 1.68 0.8 13.44 37
I9201 9201 0 1.24921e-05
R10111 9201 9202 1.632 0.8 13.056 37
I9202 9202 0 1.28631e-05
R10112 9202 9203 1.712 0.8 13.696 37
I9203 9203 0 1.29868e-05
R10113 9203 9204 1.744 0.8 13.952 37
I9204 9204 0 1.31105e-05
R10114 9204 9205 1.744 0.8 13.952 37
I9205 9205 0 1.31105e-05
R10115 9205 9206 1.744 0.8 13.952 37
I9206 9206 0 1.31105e-05
R10116 9206 9207 1.632 0.8 13.056 37
I9207 9207 0 1.29868e-05
R10117 9207 9208 1.616 0.8 12.928 37
I9208 9208 0 1.23684e-05
R10118 9208 9209 1.68 0.8 13.44 37
I9209 9209 0 1.28631e-05
R10119 9209 9210 1.744 0.8 13.952 37
I9210 9210 0 1.26158e-05
R10120 9210 9211 1.728 0.8 13.824 37
I9211 9211 0 1.26158e-05
R10121 9211 9212 1.616 0.8 12.928 37
I9212 9212 0 1.29868e-05
R10122 9212 9213 1.664 0.8 13.312 37
I9213 9213 0 1.28631e-05
R10123 9213 9214 1.648 0.8 13.184 37
I9214 9214 0 1.27395e-05
R10124 9214 9215 1.632 0.8 13.056 37
I9215 9215 0 1.32342e-05
R10125 9215 9216 1.68 0.8 13.44 37
I9216 9216 0 1.33579e-05
R10126 9216 9217 1.744 0.8 13.952 37
I9217 9217 0 1.32342e-05
R10127 9217 9218 1.632 0.8 13.056 37
I9218 9218 0 1.31105e-05
R10128 9218 9219 1.632 0.8 13.056 37
I9219 9219 0 1.27395e-05
R10129 9219 9220 1.68 0.8 13.44 37
I9220 9220 0 1.28631e-05
R10130 9220 9221 1.616 0.8 12.928 37
I9221 9221 0 1.31105e-05
R10131 9221 9222 1.6 0.8 12.8 37
I9222 9222 0 1.27395e-05
R10132 9222 9223 1.616 0.8 12.928 37
I9223 9223 0 1.28631e-05
R10133 9223 9224 1.648 0.8 13.184 37
I9224 9224 0 1.31105e-05
R10134 9224 9225 1.728 0.8 13.824 37
I9225 9225 0 1.26158e-05
R10135 9225 9226 1.6 0.8 12.8 37
I9226 9226 0 1.32342e-05
R10136 9226 9227 1.664 0.8 13.312 37
I9227 9227 0 1.24921e-05
R10137 9227 9228 1.664 0.8 13.312 37
I9228 9228 0 1.33579e-05
R10138 9228 9229 1.696 0.8 13.568 37
I9229 9229 0 1.33579e-05
R10139 9229 9230 1.664 0.8 13.312 37
I9230 9230 0 1.33579e-05
R10140 9230 9231 1.712 0.8 13.696 37
I9231 9231 0 1.34816e-05
R10141 9231 9232 1.728 0.8 13.824 37
I9232 9232 0 1.33579e-05
R10142 9232 9233 1.728 0.8 13.824 37
I9233 9233 0 1.27395e-05
R10143 9233 9234 1.68 0.8 13.44 37
I9234 9234 0 1.24921e-05
R10144 9234 9235 1.696 0.8 13.568 37
I9235 9235 0 1.26158e-05
R10145 9235 9236 1.712 0.8 13.696 37
I9236 9236 0 1.33579e-05
R10146 9236 9237 1.728 0.8 13.824 37
I9237 9237 0 1.32342e-05
R10147 9237 9238 1.648 0.8 13.184 37
I9238 9238 0 1.23684e-05
R10148 9238 9239 1.648 0.8 13.184 37
I9239 9239 0 1.32342e-05
R10149 9239 9240 1.728 0.8 13.824 37
I9240 9240 0 1.26158e-05
R10150 9240 9241 1.616 0.8 12.928 37
I9241 9241 0 1.24921e-05
R10151 9241 9242 1.616 0.8 12.928 37
I9242 9242 0 1.33579e-05
R10152 9242 9243 1.632 0.8 13.056 37
I9243 9243 0 1.29868e-05
R10153 9243 9244 1.728 0.8 13.824 37
I9244 9244 0 1.23684e-05
R10154 9244 9245 1.68 0.8 13.44 37
I9245 9245 0 1.26158e-05
R10155 9245 9246 1.616 0.8 12.928 37
I9246 9246 0 1.27395e-05
R10156 9246 9247 1.648 0.8 13.184 37
I9247 9247 0 1.34816e-05
R10157 9247 9248 1.616 0.8 12.928 37
I9248 9248 0 1.26158e-05
R10158 9248 9249 1.664 0.8 13.312 37
I9249 9249 0 1.33579e-05
R10159 9249 9250 1.68 0.8 13.44 37
I9250 9250 0 1.24921e-05
R10160 9250 9251 1.632 0.8 13.056 37
I9251 9251 0 1.26158e-05
R10161 9251 9252 1.616 0.8 12.928 37
I9252 9252 0 1.27395e-05
R10162 9252 9253 1.616 0.8 12.928 37
I9253 9253 0 1.28631e-05
R10163 9253 9254 1.68 0.8 13.44 37
I9254 9254 0 1.29868e-05
R10164 9254 9255 1.648 0.8 13.184 37
I9255 9255 0 1.27395e-05
R10165 9255 9256 1.712 0.8 13.696 37
I9256 9256 0 1.32342e-05
R10166 9256 9257 1.664 0.8 13.312 37
I9257 9257 0 1.23684e-05
R10167 9257 9258 1.712 0.8 13.696 37
I9258 9258 0 1.34816e-05
R10168 9258 9259 1.68 0.8 13.44 37
I9259 9259 0 1.29868e-05
R10169 9259 9260 1.744 0.8 13.952 37
I9260 9260 0 1.24921e-05
R10170 9260 9261 1.6 0.8 12.8 37
I9261 9261 0 1.26158e-05
R10171 9261 9262 1.696 0.8 13.568 37
I9262 9262 0 1.27395e-05
R10172 9262 9263 1.664 0.8 13.312 37
I9263 9263 0 1.34816e-05
R10173 9263 9264 1.68 0.8 13.44 37
I9264 9264 0 1.33579e-05
R10174 9264 9265 1.6 0.8 12.8 37
I9265 9265 0 1.23684e-05
R10175 9265 9266 1.616 0.8 12.928 37
I9266 9266 0 1.26158e-05
R10176 9266 9267 1.632 0.8 13.056 37
I9267 9267 0 1.26158e-05
R10177 9267 9268 1.68 0.8 13.44 37
I9268 9268 0 1.28631e-05
R10178 9268 9269 1.744 0.8 13.952 37
I9269 9269 0 1.23684e-05
R10179 9269 9270 1.744 0.8 13.952 37
I9270 9270 0 1.28631e-05
R10180 9270 9271 1.696 0.8 13.568 37
I9271 9271 0 1.33579e-05
R10181 9271 9272 1.648 0.8 13.184 37
I9272 9272 0 1.26158e-05
R10182 9272 9273 1.728 0.8 13.824 37
I9273 9273 0 1.23684e-05
R10183 9273 9274 1.648 0.8 13.184 37
I9274 9274 0 1.29868e-05
R10184 9274 9275 1.696 0.8 13.568 37
I9275 9275 0 1.29868e-05
R10185 9275 9276 1.728 0.8 13.824 37
I9276 9276 0 1.31105e-05
R10186 9276 9277 1.712 0.8 13.696 37
I9277 9277 0 1.28631e-05
R10187 9277 9278 1.744 0.8 13.952 37
I9278 9278 0 1.24921e-05
R10188 9278 9279 1.696 0.8 13.568 37
I9279 9279 0 1.32342e-05
R10189 9279 9280 1.632 0.8 13.056 37
I9280 9280 0 1.31105e-05
R10190 9280 9281 1.712 0.8 13.696 37
I9281 9281 0 1.27395e-05
R10191 9281 9282 1.6 0.8 12.8 37
I9282 9282 0 1.26158e-05
R10192 9282 9283 1.728 0.8 13.824 37
I9283 9283 0 1.33579e-05
R10193 9283 9284 1.728 0.8 13.824 37
I9284 9284 0 1.32342e-05
R10194 9284 9285 1.728 0.8 13.824 37
I9285 9285 0 1.34816e-05
R10195 9285 9286 1.648 0.8 13.184 37
I9286 9286 0 1.31105e-05
R10196 9286 9287 1.744 0.8 13.952 37
I9287 9287 0 1.32342e-05
R10197 9287 9288 1.616 0.8 12.928 37
I9288 9288 0 1.32342e-05
R10198 9288 9289 1.712 0.8 13.696 37
I9289 9289 0 1.31105e-05
R10199 9289 9290 1.664 0.8 13.312 37
I9290 9290 0 1.29868e-05
R10200 9290 9291 1.616 0.8 12.928 37
I9291 9291 0 1.27395e-05
R10201 9291 9292 1.648 0.8 13.184 37
I9292 9292 0 1.24921e-05
R10202 9292 9293 1.744 0.8 13.952 37
I9293 9293 0 1.29868e-05
R10203 9293 9294 1.664 0.8 13.312 37
I9294 9294 0 1.29868e-05
R10204 9294 9295 1.632 0.8 13.056 37
I9295 9295 0 1.31105e-05
R10205 9295 9296 1.648 0.8 13.184 37
I9296 9296 0 1.24921e-05
R10206 9296 9297 1.6 0.8 12.8 37
I9297 9297 0 1.28631e-05
R10207 9297 9298 1.68 0.8 13.44 37
I9298 9298 0 1.33579e-05
R10208 9298 9299 1.632 0.8 13.056 37
I9299 9299 0 1.27395e-05
R10209 9299 9300 1.712 0.8 13.696 37
I9300 9300 0 1.26158e-05
R10210 9300 9301 1.632 0.8 13.056 37
I9301 9301 0 1.26158e-05
R10211 9301 9302 1.616 0.8 12.928 37
I9302 9302 0 1.24921e-05
R10212 9302 9303 1.744 0.8 13.952 37
I9303 9303 0 1.28631e-05
R10213 9303 9304 1.6 0.8 12.8 37
I9304 9304 0 1.34816e-05
R10214 9304 9305 1.6 0.8 12.8 37
I9305 9305 0 1.29868e-05
R10215 9305 9306 1.664 0.8 13.312 37
I9306 9306 0 1.28631e-05
R10216 9306 9307 1.6 0.8 12.8 37
I9307 9307 0 1.33579e-05
R10217 9307 9308 1.68 0.8 13.44 37
I9308 9308 0 1.34816e-05
R10218 9308 9309 1.648 0.8 13.184 37
I9309 9309 0 1.24921e-05
R10219 9309 9310 1.712 0.8 13.696 37
I9310 9310 0 1.32342e-05
R10220 9310 9311 1.728 0.8 13.824 37
I9311 9311 0 1.23684e-05
R10221 9311 9312 1.728 0.8 13.824 37
I9312 9312 0 1.23684e-05
R10222 9312 9313 1.696 0.8 13.568 37
I9313 9313 0 1.28631e-05
R10223 9313 9314 1.6 0.8 12.8 37
I9314 9314 0 1.23684e-05
R10224 9314 9315 1.744 0.8 13.952 37
I9315 9315 0 1.34816e-05
R10225 9315 9316 1.648 0.8 13.184 37
I9316 9316 0 1.28631e-05
R10226 9316 9317 1.616 0.8 12.928 37
I9317 9317 0 1.31105e-05
R10227 9317 9318 1.68 0.8 13.44 37
I9318 9318 0 1.27395e-05
R10228 9318 9319 1.6 0.8 12.8 37
I9319 9319 0 1.33579e-05
R10229 9319 9320 1.632 0.8 13.056 37
I9320 9320 0 1.23684e-05
R10230 9320 9321 1.68 0.8 13.44 37
I9321 9321 0 1.33579e-05
R10231 9321 9322 1.664 0.8 13.312 37
I9322 9322 0 1.29868e-05
R10232 9322 9323 1.728 0.8 13.824 37
I9323 9323 0 1.24921e-05
R10233 9323 9324 1.664 0.8 13.312 37
I9324 9324 0 1.27395e-05
R10234 9324 9325 1.648 0.8 13.184 37
I9325 9325 0 1.27395e-05
R10235 9325 9326 1.632 0.8 13.056 37
I9326 9326 0 1.27395e-05
R10236 9326 9327 1.664 0.8 13.312 37
I9327 9327 0 1.24921e-05
R10237 9327 9328 1.68 0.8 13.44 37
I9328 9328 0 1.26158e-05
R10238 9328 9329 1.712 0.8 13.696 37
I9329 9329 0 1.32342e-05
R10239 9329 9330 1.648 0.8 13.184 37
I9330 9330 0 1.33579e-05
R10240 9330 9331 1.696 0.8 13.568 37
I9331 9331 0 1.31105e-05
R10241 9331 9332 1.632 0.8 13.056 37
I9332 9332 0 1.34816e-05
R10242 9332 9333 1.632 0.8 13.056 37
I9333 9333 0 1.23684e-05
R10243 9333 9334 1.664 0.8 13.312 37
I9334 9334 0 1.28631e-05
R10244 9334 9335 1.728 0.8 13.824 37
I9335 9335 0 1.33579e-05
R10245 9335 9336 1.664 0.8 13.312 37
I9336 9336 0 1.27395e-05
R10246 9336 9337 1.744 0.8 13.952 37
I9337 9337 0 1.24921e-05
R10247 9337 9338 1.728 0.8 13.824 37
I9338 9338 0 1.32342e-05
R10248 9338 9339 1.664 0.8 13.312 37
I9339 9339 0 1.28631e-05
R10249 9339 9340 1.648 0.8 13.184 37
I9340 9340 0 1.32342e-05
R10250 9340 9341 1.728 0.8 13.824 37
I9341 9341 0 1.29868e-05
R10251 9341 9342 1.632 0.8 13.056 37
I9342 9342 0 1.28631e-05
R10252 9342 9343 1.728 0.8 13.824 37
I9343 9343 0 1.34816e-05
R10253 9343 9344 1.696 0.8 13.568 37
I9344 9344 0 1.32342e-05
R10254 9344 9345 1.696 0.8 13.568 37
I9345 9345 0 1.34816e-05
R10255 9345 9346 1.696 0.8 13.568 37
I9346 9346 0 1.28631e-05
R10256 9346 9347 1.712 0.8 13.696 37
I9347 9347 0 1.33579e-05
R10257 9347 9348 1.664 0.8 13.312 37
I9348 9348 0 1.24921e-05
R10258 9348 9349 1.728 0.8 13.824 37
I9349 9349 0 1.23684e-05
R10259 9349 9350 1.68 0.8 13.44 37
I9350 9350 0 1.33579e-05
R10260 9350 9351 1.744 0.8 13.952 37
I9351 9351 0 1.26158e-05
R10261 9351 9352 1.616 0.8 12.928 37
I9352 9352 0 1.33579e-05
R10262 9352 9353 1.648 0.8 13.184 37
I9353 9353 0 1.24921e-05
R10263 9353 9354 1.712 0.8 13.696 37
I9354 9354 0 1.34816e-05
R10264 9354 9355 1.696 0.8 13.568 37
I9355 9355 0 1.23684e-05
R10265 9355 9356 1.744 0.8 13.952 37
I9356 9356 0 1.31105e-05
R10266 9356 9357 1.696 0.8 13.568 37
I9357 9357 0 1.24921e-05
R10267 9357 9358 1.6 0.8 12.8 37
I9358 9358 0 1.28631e-05
R10268 9358 9359 1.616 0.8 12.928 37
I9359 9359 0 1.31105e-05
R10269 9359 9360 1.632 0.8 13.056 37
I9360 9360 0 1.32342e-05
R10270 9360 9361 1.728 0.8 13.824 37
I9361 9361 0 1.33579e-05
R10271 9361 9362 1.664 0.8 13.312 37
I9362 9362 0 1.29868e-05
R10272 9362 9363 1.728 0.8 13.824 37
I9363 9363 0 1.23684e-05
R10273 9363 9364 1.712 0.8 13.696 37
I9364 9364 0 1.34816e-05
R10274 9364 9365 1.6 0.8 12.8 37
I9365 9365 0 1.28631e-05
R10275 9365 9366 1.712 0.8 13.696 37
I9366 9366 0 1.24921e-05
R10276 9366 9367 1.696 0.8 13.568 37
I9367 9367 0 1.24921e-05
R10277 9367 9368 1.744 0.8 13.952 37
I9368 9368 0 1.24921e-05
R10278 9368 9369 1.632 0.8 13.056 37
I9369 9369 0 1.32342e-05
R10279 9369 9370 1.616 0.8 12.928 37
I9370 9370 0 1.23684e-05
R10280 9370 9371 1.744 0.8 13.952 37
I9371 9371 0 1.23684e-05
R10281 9371 9372 1.696 0.8 13.568 37
I9372 9372 0 1.29868e-05
R10282 9372 9373 1.648 0.8 13.184 37
I9373 9373 0 1.31105e-05
R10283 9373 9374 1.632 0.8 13.056 37
I9374 9374 0 1.28631e-05
R10284 9374 9375 1.68 0.8 13.44 37
I9375 9375 0 1.28631e-05
R10285 9375 9376 1.664 0.8 13.312 37
I9376 9376 0 1.27395e-05
R10286 9376 9377 1.664 0.8 13.312 37
I9377 9377 0 1.33579e-05
R10287 9377 9378 1.6 0.8 12.8 37
I9378 9378 0 1.28631e-05
R10288 9378 9379 1.728 0.8 13.824 37
I9379 9379 0 1.34816e-05
R10289 9379 9380 1.648 0.8 13.184 37
I9380 9380 0 1.33579e-05
R10290 9380 9381 1.664 0.8 13.312 37
I9381 9381 0 1.24921e-05
R10291 9381 9382 1.6 0.8 12.8 37
I9382 9382 0 1.23684e-05
R10292 9382 9383 1.664 0.8 13.312 37
I9383 9383 0 1.24921e-05
R10293 9383 9384 1.664 0.8 13.312 37
I9384 9384 0 1.31105e-05
R10294 9384 9385 1.6 0.8 12.8 37
I9385 9385 0 1.29868e-05
R10295 9385 9386 1.712 0.8 13.696 37
I9386 9386 0 1.23684e-05
R10296 9386 9387 1.712 0.8 13.696 37
I9387 9387 0 1.29868e-05
R10297 9387 9388 1.712 0.8 13.696 37
I9388 9388 0 1.23684e-05
R10298 9388 9389 1.664 0.8 13.312 37
I9389 9389 0 1.34816e-05
R10299 9389 9390 1.68 0.8 13.44 37
I9390 9390 0 1.34816e-05
R10300 9390 9391 1.68 0.8 13.44 37
I9391 9391 0 1.24921e-05
R10301 9391 9392 1.664 0.8 13.312 37
I9392 9392 0 1.24921e-05
R10302 9392 9393 1.744 0.8 13.952 37
I9393 9393 0 1.28631e-05
R10303 9393 9394 1.696 0.8 13.568 37
I9394 9394 0 1.34816e-05
R10304 9394 9395 1.664 0.8 13.312 37
I9395 9395 0 1.34816e-05
R10305 9395 9396 1.744 0.8 13.952 37
I9396 9396 0 1.23684e-05
R10306 9396 9397 1.632 0.8 13.056 37
I9397 9397 0 1.24921e-05
R10307 9397 9398 1.632 0.8 13.056 37
I9398 9398 0 1.31105e-05
R10308 9398 9399 1.648 0.8 13.184 37
I9399 9399 0 1.31105e-05
R10309 9399 9400 1.68 0.8 13.44 37
I9400 9400 0 1.29868e-05
R10310 9400 9401 1.616 0.8 12.928 37
I9401 9401 0 1.28631e-05
R10311 9401 9402 1.712 0.8 13.696 37
I9402 9402 0 1.33579e-05
R10312 9402 9403 1.744 0.8 13.952 37
I9403 9403 0 1.29868e-05
R10313 9403 9404 1.616 0.8 12.928 37
I9404 9404 0 1.27395e-05
R10314 9404 9405 1.696 0.8 13.568 37
I9405 9405 0 1.31105e-05
R10315 9405 9406 1.664 0.8 13.312 37
I9406 9406 0 1.26158e-05
R10316 9406 9407 1.712 0.8 13.696 37
I9407 9407 0 1.33579e-05
R10317 9407 9408 1.648 0.8 13.184 37
I9408 9408 0 1.33579e-05
R10318 9408 9409 1.68 0.8 13.44 37
I9409 9409 0 1.24921e-05
R10319 9409 9410 1.712 0.8 13.696 37
I9410 9410 0 1.34816e-05
R10320 9410 9411 1.616 0.8 12.928 37
I9411 9411 0 1.33579e-05
R10321 9411 9412 1.616 0.8 12.928 37
I9412 9412 0 1.29868e-05
R10322 9412 9413 1.6 0.8 12.8 37
I9413 9413 0 1.27395e-05
R10323 9413 9414 1.664 0.8 13.312 37
I9414 9414 0 1.29868e-05
R10324 9414 9415 1.6 0.8 12.8 37
I9415 9415 0 1.34816e-05
R10325 9415 9416 1.6 0.8 12.8 37
I9416 9416 0 1.27395e-05
R10326 9416 9417 1.648 0.8 13.184 37
I9417 9417 0 1.33579e-05
R10327 9417 9418 1.664 0.8 13.312 37
I9418 9418 0 1.28631e-05
R10328 9418 9419 1.68 0.8 13.44 37
I9419 9419 0 1.29868e-05
R10329 9419 9420 1.728 0.8 13.824 37
I9420 9420 0 1.24921e-05
R10330 9420 9421 1.648 0.8 13.184 37
I9421 9421 0 1.28631e-05
R10331 9421 9422 1.648 0.8 13.184 37
I9422 9422 0 1.26158e-05
R10332 9422 9423 1.648 0.8 13.184 37
I9423 9423 0 1.34816e-05
R10333 9423 9424 1.6 0.8 12.8 37
I9424 9424 0 1.33579e-05
R10334 9424 9425 1.6 0.8 12.8 37
I9425 9425 0 1.34816e-05
R10335 9425 9426 1.744 0.8 13.952 37
I9426 9426 0 1.27395e-05
R10336 9426 9427 1.744 0.8 13.952 37
I9427 9427 0 1.23684e-05
R10337 9427 9428 1.744 0.8 13.952 37
I9428 9428 0 1.34816e-05
R10338 9428 9429 1.648 0.8 13.184 37
I9429 9429 0 1.29868e-05
R10339 9429 9430 1.664 0.8 13.312 37
I9430 9430 0 1.29868e-05
R10340 9430 9431 1.664 0.8 13.312 37
I9431 9431 0 1.32342e-05
R10341 9431 9432 1.616 0.8 12.928 37
I9432 9432 0 1.34816e-05
R10342 9432 9433 1.68 0.8 13.44 37
I9433 9433 0 1.29868e-05
R10343 9433 9434 1.648 0.8 13.184 37
I9434 9434 0 1.26158e-05
R10344 9434 9435 1.632 0.8 13.056 37
I9435 9435 0 1.27395e-05
R10345 9435 9436 1.648 0.8 13.184 37
I9436 9436 0 1.29868e-05
R10346 9436 9437 1.728 0.8 13.824 37
I9437 9437 0 1.34816e-05
R10347 9437 9438 1.744 0.8 13.952 37
I9438 9438 0 1.27395e-05
R10348 9438 9439 1.728 0.8 13.824 37
I9439 9439 0 1.24921e-05
R10349 9439 9440 1.616 0.8 12.928 37
I9440 9440 0 1.23684e-05
R10350 9440 9441 1.6 0.8 12.8 37
I9441 9441 0 1.26158e-05
R10351 9441 9442 1.696 0.8 13.568 37
I9442 9442 0 1.24921e-05
R10352 9442 9443 1.632 0.8 13.056 37
I9443 9443 0 1.29868e-05
R10353 9443 9444 1.616 0.8 12.928 37
I9444 9444 0 1.32342e-05
R10354 9444 9445 1.632 0.8 13.056 37
I9445 9445 0 1.32342e-05
R10355 9445 9446 1.68 0.8 13.44 37
I9446 9446 0 1.31105e-05
R10356 9446 9447 1.664 0.8 13.312 37
I9447 9447 0 1.31105e-05
R10357 9447 9448 1.712 0.8 13.696 37
I9448 9448 0 1.24921e-05
R10358 9448 9449 1.648 0.8 13.184 37
I9449 9449 0 1.23684e-05
R10359 9449 9450 1.68 0.8 13.44 37
I9450 9450 0 1.29868e-05
R10360 9450 9451 1.696 0.8 13.568 37
I9451 9451 0 1.34816e-05
R10361 9451 9452 1.632 0.8 13.056 37
I9452 9452 0 1.31105e-05
R10362 9452 9453 1.728 0.8 13.824 37
I9453 9453 0 1.24921e-05
R10363 9453 9454 1.744 0.8 13.952 37
I9454 9454 0 1.33579e-05
R10364 9454 9455 1.632 0.8 13.056 37
I9455 9455 0 1.26158e-05
R10365 9455 9456 1.728 0.8 13.824 37
I9456 9456 0 1.28631e-05
R10366 9456 9457 1.664 0.8 13.312 37
I9457 9457 0 1.28631e-05
R10367 9457 9458 1.68 0.8 13.44 37
I9458 9458 0 1.33579e-05
R10368 9458 9459 1.616 0.8 12.928 37
I9459 9459 0 1.33579e-05
R10369 9459 9460 1.68 0.8 13.44 37
I9460 9460 0 1.27395e-05
R10370 9460 9461 1.696 0.8 13.568 37
I9461 9461 0 1.26158e-05
R10371 9461 9462 1.616 0.8 12.928 37
I9462 9462 0 1.26158e-05
R10372 9462 9463 1.728 0.8 13.824 37
I9463 9463 0 1.33579e-05
R10373 9463 9464 1.696 0.8 13.568 37
I9464 9464 0 1.27395e-05
R10374 9464 9465 1.616 0.8 12.928 37
I9465 9465 0 1.24921e-05
R10375 9465 9466 1.728 0.8 13.824 37
I9466 9466 0 1.32342e-05
R10376 9466 9467 1.632 0.8 13.056 37
I9467 9467 0 1.26158e-05
R10377 9467 9468 1.648 0.8 13.184 37
I9468 9468 0 1.23684e-05
R10378 9468 9469 1.648 0.8 13.184 37
I9469 9469 0 1.28631e-05
R10379 9469 9470 1.728 0.8 13.824 37
I9470 9470 0 1.29868e-05
R10380 9470 9471 1.696 0.8 13.568 37
I9471 9471 0 1.34816e-05
R10381 9471 9472 1.616 0.8 12.928 37
I9472 9472 0 1.23684e-05
R10382 9472 9473 1.648 0.8 13.184 37
I9473 9473 0 1.32342e-05
R10383 9473 9474 1.728 0.8 13.824 37
I9474 9474 0 1.32342e-05
R10384 9474 9475 1.68 0.8 13.44 37
I9475 9475 0 1.29868e-05
R10385 9475 9476 1.6 0.8 12.8 37
I9476 9476 0 1.27395e-05
R10386 9476 9477 1.728 0.8 13.824 37
I9477 9477 0 1.28631e-05
R10387 9477 9478 1.728 0.8 13.824 37
I9478 9478 0 1.33579e-05
R10388 9478 9479 1.632 0.8 13.056 37
I9479 9479 0 1.31105e-05
R10389 9479 9480 1.664 0.8 13.312 37
I9480 9480 0 1.29868e-05
R10390 9480 9481 1.712 0.8 13.696 37
I9481 9481 0 1.26158e-05
R10391 9481 9482 1.632 0.8 13.056 37
I9482 9482 0 1.23684e-05
R10392 9482 9483 1.712 0.8 13.696 37
I9483 9483 0 1.32342e-05
R10393 9483 9484 1.632 0.8 13.056 37
I9484 9484 0 1.23684e-05
R10394 9484 9485 1.616 0.8 12.928 37
I9485 9485 0 1.24921e-05
R10395 9485 9486 1.728 0.8 13.824 37
I9486 9486 0 1.32342e-05
R10396 9486 9487 1.6 0.8 12.8 37
I9487 9487 0 1.34816e-05
R10397 9487 9488 1.744 0.8 13.952 37
I9488 9488 0 1.29868e-05
R10398 9488 9489 1.728 0.8 13.824 37
I9489 9489 0 1.32342e-05
R10399 9489 9490 1.632 0.8 13.056 37
I9490 9490 0 1.31105e-05
R10400 9490 9491 1.68 0.8 13.44 37
I9491 9491 0 1.29868e-05
R10401 9491 9492 1.616 0.8 12.928 37
I9492 9492 0 1.29868e-05
R10402 9492 9493 1.616 0.8 12.928 37
I9493 9493 0 1.34816e-05
R10403 9493 9494 1.68 0.8 13.44 37
I9494 9494 0 1.27395e-05
R10404 9494 9495 1.68 0.8 13.44 37
I9495 9495 0 1.34816e-05
R10405 9495 9496 1.744 0.8 13.952 37
I9496 9496 0 1.29868e-05
R10406 9496 9497 1.632 0.8 13.056 37
I9497 9497 0 1.27395e-05
R10407 9497 9498 1.712 0.8 13.696 37
I9498 9498 0 1.34816e-05
R10408 9498 9499 1.648 0.8 13.184 37
I9499 9499 0 1.24921e-05
R10409 9499 9500 1.616 0.8 12.928 37
I9500 9500 0 1.28631e-05
R10410 9500 9501 1.632 0.8 13.056 37
I9501 9501 0 1.34816e-05
R10411 9501 9502 1.664 0.8 13.312 37
I9502 9502 0 1.28631e-05
R10412 9502 9503 1.616 0.8 12.928 37
I9503 9503 0 1.27395e-05
R10413 9503 9504 1.632 0.8 13.056 37
I9504 9504 0 1.24921e-05
R10414 9504 9505 1.616 0.8 12.928 37
I9505 9505 0 1.31105e-05
R10415 9505 9506 1.712 0.8 13.696 37
I9506 9506 0 1.31105e-05
R10416 9506 9507 1.616 0.8 12.928 37
I9507 9507 0 1.34816e-05
R10417 9507 9508 1.648 0.8 13.184 37
I9508 9508 0 1.26158e-05
R10418 9508 9509 1.6 0.8 12.8 37
I9509 9509 0 1.33579e-05
R10419 9509 9510 1.728 0.8 13.824 37
I9510 9510 0 1.33579e-05
R10420 9510 9511 1.728 0.8 13.824 37
I9511 9511 0 1.34816e-05
R10421 9511 9512 1.68 0.8 13.44 37
I9512 9512 0 1.26158e-05
R10422 9512 9513 1.664 0.8 13.312 37
I9513 9513 0 1.28631e-05
R10423 9513 9514 1.648 0.8 13.184 37
I9514 9514 0 1.32342e-05
R10424 9514 9515 1.68 0.8 13.44 37
I9515 9515 0 1.28631e-05
R10425 9515 9516 1.632 0.8 13.056 37
I9516 9516 0 1.23684e-05
R10426 9516 9517 1.696 0.8 13.568 37
I9517 9517 0 1.33579e-05
R10427 9517 9518 1.664 0.8 13.312 37
I9518 9518 0 1.34816e-05
R10428 9518 9519 1.616 0.8 12.928 37
I9519 9519 0 1.33579e-05
R10429 9519 9520 1.6 0.8 12.8 37
I9520 9520 0 1.26158e-05
R10430 9520 9521 1.68 0.8 13.44 37
I9521 9521 0 1.23684e-05
R10431 9521 9522 1.6 0.8 12.8 37
I9522 9522 0 1.33579e-05
R10432 9522 9523 1.616 0.8 12.928 37
I9523 9523 0 1.27395e-05
R10433 9523 9524 1.648 0.8 13.184 37
I9524 9524 0 1.24921e-05
R10434 9524 9525 1.632 0.8 13.056 37
I9525 9525 0 1.27395e-05
R10435 9525 9526 1.616 0.8 12.928 37
I9526 9526 0 1.26158e-05
R10436 9526 9527 1.632 0.8 13.056 37
I9527 9527 0 1.31105e-05
R10437 9527 9528 1.664 0.8 13.312 37
I9528 9528 0 1.33579e-05
R10438 9528 9529 1.632 0.8 13.056 37
I9529 9529 0 1.32342e-05
R10439 9529 9530 1.696 0.8 13.568 37
I9530 9530 0 1.33579e-05
R10440 9530 9531 1.616 0.8 12.928 37
I9531 9531 0 1.23684e-05
R10441 9531 9532 1.728 0.8 13.824 37
I9532 9532 0 1.34816e-05
R10442 9532 9533 1.728 0.8 13.824 37
I9533 9533 0 1.28631e-05
R10443 9533 9534 1.728 0.8 13.824 37
I9534 9534 0 1.34816e-05
R10444 9534 9535 1.648 0.8 13.184 37
I9535 9535 0 1.24921e-05
R10445 9535 9536 1.664 0.8 13.312 37
I9536 9536 0 1.33579e-05
R10446 9536 9537 1.616 0.8 12.928 37
I9537 9537 0 1.31105e-05
R10447 9537 9538 1.696 0.8 13.568 37
I9538 9538 0 1.26158e-05
R10448 9538 9539 1.632 0.8 13.056 37
I9539 9539 0 1.24921e-05
R10449 9539 9540 1.68 0.8 13.44 37
I9540 9540 0 1.28631e-05
R10450 9540 9541 1.664 0.8 13.312 37
I9541 9541 0 1.34816e-05
R10451 9541 9542 1.728 0.8 13.824 37
I9542 9542 0 1.31105e-05
R10452 9542 9543 1.712 0.8 13.696 37
I9543 9543 0 1.26158e-05
R10453 9543 9544 1.712 0.8 13.696 37
I9544 9544 0 1.23684e-05
R10454 9544 9545 1.744 0.8 13.952 37
I9545 9545 0 1.27395e-05
R10455 9545 9546 1.728 0.8 13.824 37
I9546 9546 0 1.26158e-05
R10456 9546 9547 1.648 0.8 13.184 37
I9547 9547 0 1.31105e-05
R10457 9547 9548 1.664 0.8 13.312 37
I9548 9548 0 1.27395e-05
R10458 9548 9549 1.6 0.8 12.8 37
I9549 9549 0 1.26158e-05
R10459 9549 9550 1.632 0.8 13.056 37
I9550 9550 0 1.29868e-05
R10460 9550 9551 1.68 0.8 13.44 37
I9551 9551 0 1.33579e-05
R10461 9551 9552 1.648 0.8 13.184 37
I9552 9552 0 1.31105e-05
R10462 9552 9553 1.68 0.8 13.44 37
I9553 9553 0 1.26158e-05
R10463 9553 9554 1.6 0.8 12.8 37
I9554 9554 0 1.32342e-05
R10464 9554 9555 1.648 0.8 13.184 37
I9555 9555 0 1.33579e-05
R10465 9555 9556 1.648 0.8 13.184 37
I9556 9556 0 1.33579e-05
R10466 9556 9557 1.712 0.8 13.696 37
I9557 9557 0 1.24921e-05
R10467 9557 9558 1.696 0.8 13.568 37
I9558 9558 0 1.28631e-05
R10468 9558 9559 1.68 0.8 13.44 37
I9559 9559 0 1.27395e-05
R10469 9559 9560 1.696 0.8 13.568 37
I9560 9560 0 1.28631e-05
R10470 9560 9561 1.728 0.8 13.824 37
I9561 9561 0 1.28631e-05
R10471 9561 9562 1.728 0.8 13.824 37
I9562 9562 0 1.27395e-05
R10472 9562 9563 1.632 0.8 13.056 37
I9563 9563 0 1.26158e-05
R10473 9563 9564 1.696 0.8 13.568 37
I9564 9564 0 1.29868e-05
R10474 9564 9565 1.712 0.8 13.696 37
I9565 9565 0 1.24921e-05
R10475 9565 9566 1.6 0.8 12.8 37
I9566 9566 0 1.26158e-05
R10476 9566 9567 1.616 0.8 12.928 37
I9567 9567 0 1.31105e-05
R10477 9567 9568 1.744 0.8 13.952 37
I9568 9568 0 1.31105e-05
R10478 9568 9569 1.728 0.8 13.824 37
I9569 9569 0 1.24921e-05
R10479 9569 9570 1.68 0.8 13.44 37
I9570 9570 0 1.27395e-05
R10480 9570 9571 1.744 0.8 13.952 37
I9571 9571 0 1.33579e-05
R10481 9571 9572 1.648 0.8 13.184 37
I9572 9572 0 1.33579e-05
R10482 9572 9573 1.616 0.8 12.928 37
I9573 9573 0 1.23684e-05
R10483 9573 9574 1.648 0.8 13.184 37
I9574 9574 0 1.31105e-05
R10484 9574 9575 1.68 0.8 13.44 37
I9575 9575 0 1.24921e-05
R10485 9575 9576 1.632 0.8 13.056 37
I9576 9576 0 1.31105e-05
R10486 9576 9577 1.696 0.8 13.568 37
I9577 9577 0 1.24921e-05
R10487 9577 9578 1.744 0.8 13.952 37
I9578 9578 0 1.23684e-05
R10488 9578 9579 1.648 0.8 13.184 37
I9579 9579 0 1.33579e-05
R10489 9579 9580 1.68 0.8 13.44 37
I9580 9580 0 1.23684e-05
R10490 9580 9581 1.744 0.8 13.952 37
I9581 9581 0 1.31105e-05
R10491 9581 9582 1.648 0.8 13.184 37
I9582 9582 0 1.23684e-05
R10492 9582 9583 1.664 0.8 13.312 37
I9583 9583 0 1.28631e-05
R10493 9583 9584 1.744 0.8 13.952 37
I9584 9584 0 1.26158e-05
R10494 9584 9585 1.68 0.8 13.44 37
I9585 9585 0 1.28631e-05
R10495 9585 9586 1.712 0.8 13.696 37
I9586 9586 0 1.29868e-05
R10496 9586 9587 1.68 0.8 13.44 37
I9587 9587 0 1.24921e-05
R10497 9587 9588 1.68 0.8 13.44 37
I9588 9588 0 1.31105e-05
R10498 9588 9589 1.648 0.8 13.184 37
I9589 9589 0 1.33579e-05
R10499 9589 9590 1.68 0.8 13.44 37
I9590 9590 0 1.23684e-05
R10500 9590 9591 1.6 0.8 12.8 37
I9591 9591 0 1.32342e-05
R10501 9591 9592 1.696 0.8 13.568 37
I9592 9592 0 1.33579e-05
R10502 9592 9593 1.728 0.8 13.824 37
I9593 9593 0 1.31105e-05
R10503 9593 9594 1.728 0.8 13.824 37
I9594 9594 0 1.28631e-05
R10504 9594 9595 1.664 0.8 13.312 37
I9595 9595 0 1.31105e-05
R10505 9595 9596 1.696 0.8 13.568 37
I9596 9596 0 1.29868e-05
R10506 9596 9597 1.664 0.8 13.312 37
I9597 9597 0 1.34816e-05
R10507 9597 9598 1.712 0.8 13.696 37
I9598 9598 0 1.33579e-05
R10508 9598 9599 1.68 0.8 13.44 37
I9599 9599 0 1.33579e-05
R10509 9599 9600 1.632 0.8 13.056 37
I9600 9600 0 1.24921e-05
R10510 9600 9601 1.648 0.8 13.184 37
I9601 9601 0 1.34816e-05
R10511 9601 9602 1.728 0.8 13.824 37
I9602 9602 0 1.23684e-05
R10512 9602 9603 1.6 0.8 12.8 37
I9603 9603 0 1.27395e-05
R10513 9603 9604 1.728 0.8 13.824 37
I9604 9604 0 1.29868e-05
R10514 9604 9605 1.664 0.8 13.312 37
I9605 9605 0 1.27395e-05
R10515 9605 9606 1.696 0.8 13.568 37
I9606 9606 0 1.31105e-05
R10516 9606 9607 1.616 0.8 12.928 37
I9607 9607 0 1.26158e-05
R10517 9607 9608 1.696 0.8 13.568 37
I9608 9608 0 1.24921e-05
R10518 9608 9609 1.6 0.8 12.8 37
I9609 9609 0 1.31105e-05
R10519 9609 9610 1.68 0.8 13.44 37
I9610 9610 0 1.28631e-05
R10520 9610 9611 1.632 0.8 13.056 37
I9611 9611 0 1.28631e-05
R10521 9611 9612 1.616 0.8 12.928 37
I9612 9612 0 1.31105e-05
R10522 9612 9613 1.648 0.8 13.184 37
I9613 9613 0 1.24921e-05
R10523 9613 9614 1.664 0.8 13.312 37
I9614 9614 0 1.24921e-05
R10524 9614 9615 1.744 0.8 13.952 37
I9615 9615 0 1.33579e-05
R10525 9615 9616 1.664 0.8 13.312 37
I9616 9616 0 1.28631e-05
R10526 9616 9617 1.728 0.8 13.824 37
I9617 9617 0 1.28631e-05
R10527 9617 9618 1.664 0.8 13.312 37
I9618 9618 0 1.23684e-05
R10528 9618 9619 1.744 0.8 13.952 37
I9619 9619 0 1.27395e-05
R10529 9619 9620 1.696 0.8 13.568 37
I9620 9620 0 1.27395e-05
R10530 9620 9621 1.696 0.8 13.568 37
I9621 9621 0 1.28631e-05
R10531 9621 9622 1.616 0.8 12.928 37
I9622 9622 0 1.34816e-05
R10532 9622 9623 1.696 0.8 13.568 37
I9623 9623 0 1.32342e-05
R10533 9623 9624 1.648 0.8 13.184 37
I9624 9624 0 1.34816e-05
R10534 9624 9625 1.664 0.8 13.312 37
I9625 9625 0 1.23684e-05
R10535 9625 9626 1.648 0.8 13.184 37
I9626 9626 0 1.33579e-05
R10536 9626 9627 1.664 0.8 13.312 37
I9627 9627 0 1.32342e-05
R10537 9627 9628 1.68 0.8 13.44 37
I9628 9628 0 1.23684e-05
R10538 9628 9629 1.728 0.8 13.824 37
I9629 9629 0 1.24921e-05
R10539 9629 9630 1.616 0.8 12.928 37
I9630 9630 0 1.32342e-05
R10540 9630 9631 1.6 0.8 12.8 37
I9631 9631 0 1.29868e-05
R10541 9631 9632 1.632 0.8 13.056 37
I9632 9632 0 1.23684e-05
R10542 9632 9633 1.744 0.8 13.952 37
I9633 9633 0 1.33579e-05
R10543 9633 9634 1.6 0.8 12.8 37
I9634 9634 0 1.33579e-05
R10544 9634 9635 1.616 0.8 12.928 37
I9635 9635 0 1.33579e-05
R10545 9635 9636 1.664 0.8 13.312 37
I9636 9636 0 1.23684e-05
R10546 9636 9637 1.632 0.8 13.056 37
I9637 9637 0 1.29868e-05
R10547 9637 9638 1.616 0.8 12.928 37
I9638 9638 0 1.24921e-05
R10548 9638 9639 1.68 0.8 13.44 37
I9639 9639 0 1.28631e-05
R10549 9639 9640 1.6 0.8 12.8 37
I9640 9640 0 1.24921e-05
R10550 9640 9641 1.68 0.8 13.44 37
I9641 9641 0 1.29868e-05
R10551 9641 9642 1.744 0.8 13.952 37
I9642 9642 0 1.24921e-05
R10552 9642 9643 1.664 0.8 13.312 37
I9643 9643 0 1.31105e-05
R10553 9643 9644 1.616 0.8 12.928 37
I9644 9644 0 1.26158e-05
R10554 9644 9645 1.728 0.8 13.824 37
I9645 9645 0 1.26158e-05
R10555 9645 9646 1.632 0.8 13.056 37
I9646 9646 0 1.23684e-05
R10556 9646 9647 1.744 0.8 13.952 37
I9647 9647 0 1.28631e-05
R10557 9647 9648 1.6 0.8 12.8 37
I9648 9648 0 1.33579e-05
R10558 9648 9649 1.632 0.8 13.056 37
I9649 9649 0 1.23684e-05
R10559 9649 9650 1.744 0.8 13.952 37
I9650 9650 0 1.31105e-05
R10560 9650 9651 1.616 0.8 12.928 37
I9651 9651 0 1.29868e-05
R10561 9651 9652 1.728 0.8 13.824 37
I9652 9652 0 1.29868e-05
R10562 9652 9653 1.632 0.8 13.056 37
I9653 9653 0 1.34816e-05
R10563 9653 9654 1.696 0.8 13.568 37
I9654 9654 0 1.32342e-05
R10564 9654 9655 1.664 0.8 13.312 37
I9655 9655 0 1.33579e-05
R10565 9655 9656 1.6 0.8 12.8 37
I9656 9656 0 1.24921e-05
R10566 9656 9657 1.696 0.8 13.568 37
I9657 9657 0 1.26158e-05
R10567 9657 9658 1.632 0.8 13.056 37
I9658 9658 0 1.23684e-05
R10568 9658 9659 1.728 0.8 13.824 37
I9659 9659 0 1.31105e-05
R10569 9659 9660 1.68 0.8 13.44 37
I9660 9660 0 1.33579e-05
R10570 9660 9661 1.728 0.8 13.824 37
I9661 9661 0 1.32342e-05
R10571 9661 9662 1.728 0.8 13.824 37
I9662 9662 0 1.33579e-05
R10572 9662 9663 1.648 0.8 13.184 37
I9663 9663 0 1.33579e-05
R10573 9663 9664 1.728 0.8 13.824 37
I9664 9664 0 1.32342e-05
R10574 9664 9665 1.616 0.8 12.928 37
I9665 9665 0 1.34816e-05
R10575 9665 9666 1.648 0.8 13.184 37
I9666 9666 0 1.28631e-05
R10576 9666 9667 1.664 0.8 13.312 37
I9667 9667 0 1.24921e-05
R10577 9667 9668 1.744 0.8 13.952 37
I9668 9668 0 1.32342e-05
R10578 9668 9669 1.648 0.8 13.184 37
I9669 9669 0 1.33579e-05
R10579 9669 9670 1.696 0.8 13.568 37
I9670 9670 0 1.34816e-05
R10580 9670 9671 1.696 0.8 13.568 37
I9671 9671 0 1.32342e-05
R10581 9671 9672 1.632 0.8 13.056 37
I9672 9672 0 1.28631e-05
R10582 9672 9673 1.744 0.8 13.952 37
I9673 9673 0 1.28631e-05
R10583 9673 9674 1.68 0.8 13.44 37
I9674 9674 0 1.34816e-05
R10584 9674 9675 1.6 0.8 12.8 37
I9675 9675 0 1.23684e-05
R10585 9675 9676 1.728 0.8 13.824 37
I9676 9676 0 1.24921e-05
R10586 9676 9677 1.744 0.8 13.952 37
I9677 9677 0 1.31105e-05
R10587 9677 9678 1.616 0.8 12.928 37
I9678 9678 0 1.26158e-05
R10588 9678 9679 1.712 0.8 13.696 37
I9679 9679 0 1.24921e-05
R10589 9679 9680 1.744 0.8 13.952 37
I9680 9680 0 1.33579e-05
R10590 9680 9681 1.616 0.8 12.928 37
I9681 9681 0 1.29868e-05
R10591 9681 9682 1.632 0.8 13.056 37
I9682 9682 0 1.32342e-05
R10592 9682 9683 1.728 0.8 13.824 37
I9683 9683 0 1.27395e-05
R10593 9683 9684 1.696 0.8 13.568 37
I9684 9684 0 1.27395e-05
R10594 9684 9685 1.616 0.8 12.928 37
I9685 9685 0 1.27395e-05
R10595 9685 9686 1.632 0.8 13.056 37
I9686 9686 0 1.23684e-05
R10596 9686 9687 1.632 0.8 13.056 37
I9687 9687 0 1.28631e-05
R10597 9687 9688 1.664 0.8 13.312 37
I9688 9688 0 1.27395e-05
R10598 9688 9689 1.616 0.8 12.928 37
I9689 9689 0 1.24921e-05
R10599 9689 9690 1.632 0.8 13.056 37
I9690 9690 0 1.27395e-05
R10600 9690 9691 1.616 0.8 12.928 37
I9691 9691 0 1.23684e-05
R10601 9691 9692 1.664 0.8 13.312 37
I9692 9692 0 1.26158e-05
R10602 9692 9693 1.712 0.8 13.696 37
I9693 9693 0 1.32342e-05
R10603 9693 9694 1.664 0.8 13.312 37
I9694 9694 0 1.28631e-05
R10604 9694 9695 1.744 0.8 13.952 37
I9695 9695 0 1.31105e-05
R10605 9695 9696 1.664 0.8 13.312 37
I9696 9696 0 1.26158e-05
R10606 9696 9697 1.648 0.8 13.184 37
I9697 9697 0 1.33579e-05
R10607 9697 9698 1.616 0.8 12.928 37
I9698 9698 0 1.27395e-05
R10608 9698 9699 1.648 0.8 13.184 37
I9699 9699 0 1.33579e-05
R10609 9699 9700 1.712 0.8 13.696 37
I9700 9700 0 1.29868e-05
R10610 9700 9701 1.616 0.8 12.928 37
I9701 9701 0 1.34816e-05
R10611 9701 9702 1.68 0.8 13.44 37
I9702 9702 0 1.27395e-05
R10612 9702 9703 1.696 0.8 13.568 37
I9703 9703 0 1.24921e-05
R10613 9703 9704 1.696 0.8 13.568 37
I9704 9704 0 1.32342e-05
R10614 9704 9705 1.648 0.8 13.184 37
I9705 9705 0 1.23684e-05
R10615 9705 9706 1.6 0.8 12.8 37
I9706 9706 0 1.31105e-05
R10616 9706 9707 1.616 0.8 12.928 37
I9707 9707 0 1.29868e-05
R10617 9707 9708 1.744 0.8 13.952 37
I9708 9708 0 1.23684e-05
R10618 9708 9709 1.664 0.8 13.312 37
I9709 9709 0 1.27395e-05
R10619 9709 9710 1.664 0.8 13.312 37
I9710 9710 0 1.27395e-05
R10620 9710 9711 1.616 0.8 12.928 37
I9711 9711 0 1.23684e-05
R10621 9711 9712 1.712 0.8 13.696 37
I9712 9712 0 1.31105e-05
R10622 9712 9713 1.6 0.8 12.8 37
I9713 9713 0 1.34816e-05
R10623 9713 9714 1.6 0.8 12.8 37
I9714 9714 0 1.27395e-05
R10624 9714 9715 1.712 0.8 13.696 37
I9715 9715 0 1.32342e-05
R10625 9715 9716 1.6 0.8 12.8 37
I9716 9716 0 1.23684e-05
R10626 9716 9717 1.728 0.8 13.824 37
I9717 9717 0 1.29868e-05
R10627 9717 9718 1.68 0.8 13.44 37
I9718 9718 0 1.28631e-05
R10628 9718 9719 1.712 0.8 13.696 37
I9719 9719 0 1.27395e-05
R10629 9719 9720 1.616 0.8 12.928 37
I9720 9720 0 1.23684e-05
R10630 9720 9721 1.648 0.8 13.184 37
I9721 9721 0 1.28631e-05
R10631 9721 9722 1.696 0.8 13.568 37
I9722 9722 0 1.28631e-05
R10632 9722 9723 1.616 0.8 12.928 37
I9723 9723 0 1.32342e-05
R10633 9723 9724 1.664 0.8 13.312 37
I9724 9724 0 1.29868e-05
R10634 9724 9725 1.616 0.8 12.928 37
I9725 9725 0 1.23684e-05
R10635 9725 9726 1.616 0.8 12.928 37
I9726 9726 0 1.28631e-05
R10636 9726 9727 1.632 0.8 13.056 37
I9727 9727 0 1.33579e-05
R10637 9727 9728 1.616 0.8 12.928 37
I9728 9728 0 1.26158e-05
R10638 9728 9729 1.744 0.8 13.952 37
I9729 9729 0 1.27395e-05
R10639 9729 9730 1.728 0.8 13.824 37
I9730 9730 0 1.31105e-05
R10640 9730 9731 1.6 0.8 12.8 37
I9731 9731 0 1.33579e-05
R10641 9731 9732 1.696 0.8 13.568 37
I9732 9732 0 1.23684e-05
R10642 9732 9733 1.696 0.8 13.568 37
I9733 9733 0 1.24921e-05
R10643 9733 9734 1.712 0.8 13.696 37
I9734 9734 0 1.29868e-05
R10644 9734 9735 1.664 0.8 13.312 37
I9735 9735 0 1.33579e-05
R10645 9735 9736 1.712 0.8 13.696 37
I9736 9736 0 1.33579e-05
R10646 9736 9737 1.632 0.8 13.056 37
I9737 9737 0 1.27395e-05
R10647 9737 9738 1.664 0.8 13.312 37
I9738 9738 0 1.29868e-05
R10648 9738 9739 1.648 0.8 13.184 37
I9739 9739 0 1.34816e-05
R10649 9739 9740 1.616 0.8 12.928 37
I9740 9740 0 1.28631e-05
R10650 9740 9741 1.616 0.8 12.928 37
I9741 9741 0 1.26158e-05
R10651 9741 9742 1.6 0.8 12.8 37
I9742 9742 0 1.28631e-05
R10652 9742 9743 1.632 0.8 13.056 37
I9743 9743 0 1.27395e-05
R10653 9743 9744 1.728 0.8 13.824 37
I9744 9744 0 1.26158e-05
R10654 9744 9745 1.696 0.8 13.568 37
I9745 9745 0 1.31105e-05
R10655 9745 9746 1.6 0.8 12.8 37
I9746 9746 0 1.33579e-05
R10656 9746 9747 1.712 0.8 13.696 37
I9747 9747 0 1.32342e-05
R10657 9747 9748 1.744 0.8 13.952 37
I9748 9748 0 1.27395e-05
R10658 9748 9749 1.6 0.8 12.8 37
I9749 9749 0 1.31105e-05
R10659 9749 9750 1.728 0.8 13.824 37
I9750 9750 0 1.32342e-05
R10660 9750 9751 1.696 0.8 13.568 37
I9751 9751 0 1.29868e-05
R10661 9751 9752 1.712 0.8 13.696 37
I9752 9752 0 1.24921e-05
R10662 9752 9753 1.6 0.8 12.8 37
I9753 9753 0 1.27395e-05
R10663 9753 9754 1.696 0.8 13.568 37
I9754 9754 0 1.27395e-05
R10664 9754 9755 1.632 0.8 13.056 37
I9755 9755 0 1.34816e-05
R10665 9755 9756 1.744 0.8 13.952 37
I9756 9756 0 1.31105e-05
R10666 9756 9757 1.616 0.8 12.928 37
I9757 9757 0 1.26158e-05
R10667 9757 9758 1.6 0.8 12.8 37
I9758 9758 0 1.28631e-05
R10668 9758 9759 1.68 0.8 13.44 37
I9759 9759 0 1.33579e-05
R10669 9759 9760 1.728 0.8 13.824 37
I9760 9760 0 1.26158e-05
R10670 9760 9761 1.712 0.8 13.696 37
I9761 9761 0 1.33579e-05
R10671 9761 9762 1.6 0.8 12.8 37
I9762 9762 0 1.28631e-05
R10672 9762 9763 1.712 0.8 13.696 37
I9763 9763 0 1.24921e-05
R10673 9763 9764 1.744 0.8 13.952 37
I9764 9764 0 1.33579e-05
R10674 9764 9765 1.712 0.8 13.696 37
I9765 9765 0 1.32342e-05
R10675 9765 9766 1.712 0.8 13.696 37
I9766 9766 0 1.31105e-05
R10676 9766 9767 1.664 0.8 13.312 37
I9767 9767 0 1.31105e-05
R10677 9767 9768 1.744 0.8 13.952 37
I9768 9768 0 1.28631e-05
R10678 9768 9769 1.744 0.8 13.952 37
I9769 9769 0 1.29868e-05
R10679 9769 9770 1.6 0.8 12.8 37
I9770 9770 0 1.28631e-05
R10680 9770 9771 1.68 0.8 13.44 37
I9771 9771 0 1.24921e-05
R10681 9771 9772 1.6 0.8 12.8 37
I9772 9772 0 1.33579e-05
R10682 9772 9773 1.648 0.8 13.184 37
I9773 9773 0 1.23684e-05
R10683 9773 9774 1.664 0.8 13.312 37
I9774 9774 0 1.34816e-05
R10684 9774 9775 1.6 0.8 12.8 37
I9775 9775 0 1.26158e-05
R10685 9775 9776 1.616 0.8 12.928 37
I9776 9776 0 1.34816e-05
R10686 9776 9777 1.616 0.8 12.928 37
I9777 9777 0 1.27395e-05
R10687 9777 9778 1.648 0.8 13.184 37
I9778 9778 0 1.33579e-05
R10688 9778 9779 1.68 0.8 13.44 37
I9779 9779 0 1.26158e-05
R10689 9779 9780 1.728 0.8 13.824 37
I9780 9780 0 1.28631e-05
R10690 9780 9781 1.616 0.8 12.928 37
I9781 9781 0 1.32342e-05
R10691 9781 9782 1.6 0.8 12.8 37
I9782 9782 0 1.29868e-05
R10692 9782 9783 1.648 0.8 13.184 37
I9783 9783 0 1.34816e-05
R10693 9783 9784 1.632 0.8 13.056 37
I9784 9784 0 1.29868e-05
R10694 9784 9785 1.712 0.8 13.696 37
I9785 9785 0 1.26158e-05
R10695 9785 9786 1.744 0.8 13.952 37
I9786 9786 0 1.28631e-05
R10696 9786 9787 1.648 0.8 13.184 37
I9787 9787 0 1.24921e-05
R10697 9787 9788 1.632 0.8 13.056 37
I9788 9788 0 1.34816e-05
R10698 9788 9789 1.616 0.8 12.928 37
I9789 9789 0 1.32342e-05
R10699 9789 9790 1.728 0.8 13.824 37
I9790 9790 0 1.27395e-05
R10700 9790 9791 1.616 0.8 12.928 37
I9791 9791 0 1.24921e-05
R10701 9791 9792 1.648 0.8 13.184 37
I9792 9792 0 1.28631e-05
R10702 9792 9793 1.664 0.8 13.312 37
I9793 9793 0 1.33579e-05
R10703 9793 9794 1.68 0.8 13.44 37
I9794 9794 0 1.34816e-05
R10704 9794 9795 1.648 0.8 13.184 37
I9795 9795 0 1.29868e-05
R10705 9795 9796 1.664 0.8 13.312 37
I9796 9796 0 1.28631e-05
R10706 9796 9797 1.648 0.8 13.184 37
I9797 9797 0 1.31105e-05
R10707 9797 9798 1.632 0.8 13.056 37
I9798 9798 0 1.33579e-05
R10708 9798 9799 1.728 0.8 13.824 37
I9799 9799 0 1.31105e-05
R10709 9799 9800 1.648 0.8 13.184 37
I9800 9800 0 1.29868e-05
R10710 9800 9801 1.6 0.8 12.8 37
I9801 9801 0 1.28631e-05
R10711 9801 9802 1.744 0.8 13.952 37
I9802 9802 0 1.29868e-05
R10712 9802 9803 1.68 0.8 13.44 37
I9803 9803 0 1.27395e-05
R10713 9803 9804 1.664 0.8 13.312 37
I9804 9804 0 1.33579e-05
R10714 9804 9805 1.632 0.8 13.056 37
I9805 9805 0 1.26158e-05
R10715 9805 9806 1.664 0.8 13.312 37
I9806 9806 0 1.28631e-05
R10716 9806 9807 1.648 0.8 13.184 37
I9807 9807 0 1.34816e-05
R10717 9807 9808 1.728 0.8 13.824 37
I9808 9808 0 1.33579e-05
R10718 9808 9809 1.712 0.8 13.696 37
I9809 9809 0 1.27395e-05
R10719 9809 9810 1.744 0.8 13.952 37
I9810 9810 0 1.26158e-05
R10720 9810 9811 1.744 0.8 13.952 37
I9811 9811 0 1.27395e-05
R10721 9811 9812 1.744 0.8 13.952 37
I9812 9812 0 1.28631e-05
R10722 9812 9813 1.632 0.8 13.056 37
I9813 9813 0 1.24921e-05
R10723 9813 9814 1.664 0.8 13.312 37
I9814 9814 0 1.23684e-05
R10724 9814 9815 1.744 0.8 13.952 37
I9815 9815 0 1.23684e-05
R10725 9815 9816 1.68 0.8 13.44 37
I9816 9816 0 1.34816e-05
R10726 9816 9817 1.664 0.8 13.312 37
I9817 9817 0 1.31105e-05
R10727 9817 9818 1.664 0.8 13.312 37
I9818 9818 0 1.26158e-05
R10728 9818 9819 1.744 0.8 13.952 37
I9819 9819 0 1.34816e-05
R10729 9819 9820 1.632 0.8 13.056 37
I9820 9820 0 1.26158e-05
R10730 9820 9821 1.648 0.8 13.184 37
I9821 9821 0 1.31105e-05
R10731 9821 9822 1.728 0.8 13.824 37
I9822 9822 0 1.32342e-05
R10732 9822 9823 1.68 0.8 13.44 37
I9823 9823 0 1.33579e-05
R10733 9823 9824 1.712 0.8 13.696 37
I9824 9824 0 1.27395e-05
R10734 9824 9825 1.632 0.8 13.056 37
I9825 9825 0 1.31105e-05
R10735 9825 9826 1.712 0.8 13.696 37
I9826 9826 0 1.27395e-05
R10736 9826 9827 1.632 0.8 13.056 37
I9827 9827 0 1.31105e-05
R10737 9827 9828 1.744 0.8 13.952 37
I9828 9828 0 1.28631e-05
R10738 9828 9829 1.744 0.8 13.952 37
I9829 9829 0 1.27395e-05
R10739 9829 9830 1.664 0.8 13.312 37
I9830 9830 0 1.33579e-05
R10740 9830 9831 1.648 0.8 13.184 37
I9831 9831 0 1.24921e-05
R10741 9831 9832 1.712 0.8 13.696 37
I9832 9832 0 1.33579e-05
R10742 9832 9833 1.744 0.8 13.952 37
I9833 9833 0 1.26158e-05
R10743 9833 9834 1.632 0.8 13.056 37
I9834 9834 0 1.33579e-05
R10744 9834 9835 1.648 0.8 13.184 37
I9835 9835 0 1.28631e-05
R10745 9835 9836 1.632 0.8 13.056 37
I9836 9836 0 1.31105e-05
R10746 9836 9837 1.616 0.8 12.928 37
I9837 9837 0 1.26158e-05
R10747 9837 9838 1.68 0.8 13.44 37
I9838 9838 0 1.31105e-05
R10748 9838 9839 1.616 0.8 12.928 37
I9839 9839 0 1.26158e-05
R10749 9839 9840 1.616 0.8 12.928 37
I9840 9840 0 1.29868e-05
R10750 9840 9841 1.616 0.8 12.928 37
I9841 9841 0 1.24921e-05
R10751 9841 9842 1.728 0.8 13.824 37
I9842 9842 0 1.27395e-05
R10752 9842 9843 1.712 0.8 13.696 37
I9843 9843 0 1.32342e-05
R10753 9843 9844 1.744 0.8 13.952 37
I9844 9844 0 1.32342e-05
R10754 9844 9845 1.6 0.8 12.8 37
I9845 9845 0 1.27395e-05
R10755 9845 9846 1.68 0.8 13.44 37
I9846 9846 0 1.31105e-05
R10756 9846 9847 1.696 0.8 13.568 37
I9847 9847 0 1.27395e-05
R10757 9847 9848 1.664 0.8 13.312 37
I9848 9848 0 1.29868e-05
R10758 9848 9849 1.712 0.8 13.696 37
I9849 9849 0 1.33579e-05
R10759 9849 9850 1.68 0.8 13.44 37
I9850 9850 0 1.26158e-05
R10760 9850 9851 1.632 0.8 13.056 37
I9851 9851 0 1.23684e-05
R10761 9851 9852 1.728 0.8 13.824 37
I9852 9852 0 1.29868e-05
R10762 9852 9853 1.664 0.8 13.312 37
I9853 9853 0 1.31105e-05
R10763 9853 9854 1.632 0.8 13.056 37
I9854 9854 0 1.29868e-05
R10764 9854 9855 1.728 0.8 13.824 37
I9855 9855 0 1.29868e-05
R10765 9855 9856 1.6 0.8 12.8 37
I9856 9856 0 1.34816e-05
R10766 9856 9857 1.696 0.8 13.568 37
I9857 9857 0 1.23684e-05
R10767 9857 9858 1.664 0.8 13.312 37
I9858 9858 0 1.31105e-05
R10768 9858 9859 1.712 0.8 13.696 37
I9859 9859 0 1.27395e-05
R10769 9859 9860 1.648 0.8 13.184 37
I9860 9860 0 1.23684e-05
R10770 9860 9861 1.728 0.8 13.824 37
I9861 9861 0 1.23684e-05
R10771 9861 9862 1.696 0.8 13.568 37
I9862 9862 0 1.28631e-05
R10772 9862 9863 1.648 0.8 13.184 37
I9863 9863 0 1.26158e-05
R10773 9863 9864 1.616 0.8 12.928 37
I9864 9864 0 1.26158e-05
R10774 9864 9865 1.6 0.8 12.8 37
I9865 9865 0 1.34816e-05
R10775 9865 9866 1.696 0.8 13.568 37
I9866 9866 0 1.28631e-05
R10776 9866 9867 1.616 0.8 12.928 37
I9867 9867 0 1.32342e-05
R10777 9867 9868 1.6 0.8 12.8 37
I9868 9868 0 1.29868e-05
R10778 9868 9869 1.648 0.8 13.184 37
I9869 9869 0 1.28631e-05
R10779 9869 9870 1.616 0.8 12.928 37
I9870 9870 0 1.24921e-05
R10780 9870 9871 1.616 0.8 12.928 37
I9871 9871 0 1.27395e-05
R10781 9871 9872 1.648 0.8 13.184 37
I9872 9872 0 1.23684e-05
R10782 9872 9873 1.664 0.8 13.312 37
I9873 9873 0 1.32342e-05
R10783 9873 9874 1.696 0.8 13.568 37
I9874 9874 0 1.24921e-05
R10784 9874 9875 1.616 0.8 12.928 37
I9875 9875 0 1.34816e-05
R10785 9875 9876 1.648 0.8 13.184 37
I9876 9876 0 1.34816e-05
R10786 9876 9877 1.744 0.8 13.952 37
I9877 9877 0 1.24921e-05
R10787 9877 9878 1.696 0.8 13.568 37
I9878 9878 0 1.29868e-05
R10788 9878 9879 1.648 0.8 13.184 37
I9879 9879 0 1.34816e-05
R10789 9879 9880 1.744 0.8 13.952 37
I9880 9880 0 1.29868e-05
R10790 9880 9881 1.728 0.8 13.824 37
I9881 9881 0 1.31105e-05
R10791 9881 9882 1.6 0.8 12.8 37
I9882 9882 0 1.34816e-05
R10792 9882 9883 1.648 0.8 13.184 37
I9883 9883 0 1.23684e-05
R10793 9883 9884 1.68 0.8 13.44 37
I9884 9884 0 1.31105e-05
R10794 9884 9885 1.664 0.8 13.312 37
I9885 9885 0 1.33579e-05
R10795 9885 9886 1.744 0.8 13.952 37
I9886 9886 0 1.29868e-05
R10796 9886 9887 1.616 0.8 12.928 37
I9887 9887 0 1.26158e-05
R10797 9887 9888 1.68 0.8 13.44 37
I9888 9888 0 1.29868e-05
R10798 9888 9889 1.6 0.8 12.8 37
I9889 9889 0 1.27395e-05
R10799 9889 9890 1.744 0.8 13.952 37
I9890 9890 0 1.27395e-05
R10800 9890 9891 1.632 0.8 13.056 37
I9891 9891 0 1.28631e-05
R10801 9891 9892 1.632 0.8 13.056 37
I9892 9892 0 1.28631e-05
R10802 9892 9893 1.696 0.8 13.568 37
I9893 9893 0 1.23684e-05
R10803 9893 9894 1.616 0.8 12.928 37
I9894 9894 0 1.34816e-05
R10804 9894 9895 1.6 0.8 12.8 37
I9895 9895 0 1.26158e-05
R10805 9895 9896 1.68 0.8 13.44 37
I9896 9896 0 1.33579e-05
R10806 9896 9897 1.6 0.8 12.8 37
I9897 9897 0 1.32342e-05
R10807 9897 9898 1.6 0.8 12.8 37
I9898 9898 0 1.27395e-05
R10808 9898 9899 1.712 0.8 13.696 37
I9899 9899 0 1.32342e-05
R10809 9899 9900 1.616 0.8 12.928 37
I9900 9900 0 1.27395e-05
R10810 9900 9901 1.68 0.8 13.44 37
I9901 9901 0 1.27395e-05
R10811 9901 9902 1.6 0.8 12.8 37
I9902 9902 0 1.33579e-05
R10812 9902 9903 1.68 0.8 13.44 37
I9903 9903 0 1.33579e-05
R10813 9903 9904 1.696 0.8 13.568 37
I9904 9904 0 1.32342e-05
R10814 9904 9905 1.616 0.8 12.928 37
I9905 9905 0 1.29868e-05
R10815 9905 9906 1.632 0.8 13.056 37
I9906 9906 0 1.31105e-05
R10816 9906 9907 1.616 0.8 12.928 37
I9907 9907 0 1.32342e-05
R10817 9907 9908 1.6 0.8 12.8 37
I9908 9908 0 1.32342e-05
R10818 9908 9909 1.712 0.8 13.696 37
I9909 9909 0 1.27395e-05
R10819 9909 9910 1.744 0.8 13.952 37
I9910 9910 0 1.32342e-05
R10820 9910 9911 1.68 0.8 13.44 37
I9911 9911 0 1.28631e-05
R10821 9911 9912 1.728 0.8 13.824 37
I9912 9912 0 1.33579e-05
R10822 9912 9913 1.648 0.8 13.184 37
I9913 9913 0 1.23684e-05
R10823 9913 9914 1.648 0.8 13.184 37
I9914 9914 0 1.26158e-05
R10824 9914 9915 1.712 0.8 13.696 37
I9915 9915 0 1.29868e-05
R10825 9915 9916 1.68 0.8 13.44 37
I9916 9916 0 1.28631e-05
R10826 9916 9917 1.6 0.8 12.8 37
I9917 9917 0 1.29868e-05
R10827 9917 9918 1.632 0.8 13.056 37
I9918 9918 0 1.32342e-05
R10828 9918 9919 1.648 0.8 13.184 37
I9919 9919 0 1.23684e-05
R10829 9919 9920 1.68 0.8 13.44 37
I9920 9920 0 1.32342e-05
R10830 9920 9921 1.68 0.8 13.44 37
I9921 9921 0 1.34816e-05
R10831 9921 9922 1.648 0.8 13.184 37
I9922 9922 0 1.32342e-05
R10832 9922 9923 1.696 0.8 13.568 37
I9923 9923 0 1.29868e-05
R10833 9923 9924 1.696 0.8 13.568 37
I9924 9924 0 1.28631e-05
R10834 9924 9925 1.728 0.8 13.824 37
I9925 9925 0 1.29868e-05
R10835 9925 9926 1.648 0.8 13.184 37
I9926 9926 0 1.29868e-05
R10836 9926 9927 1.616 0.8 12.928 37
I9927 9927 0 1.27395e-05
R10837 9927 9928 1.648 0.8 13.184 37
I9928 9928 0 1.28631e-05
R10838 9928 9929 1.648 0.8 13.184 37
I9929 9929 0 1.34816e-05
R10839 9929 9930 1.696 0.8 13.568 37
I9930 9930 0 1.23684e-05
R10840 9930 9931 1.696 0.8 13.568 37
I9931 9931 0 1.27395e-05
R10841 9931 9932 1.696 0.8 13.568 37
I9932 9932 0 1.31105e-05
R10842 9932 9933 1.744 0.8 13.952 37
I9933 9933 0 1.34816e-05
R10843 9933 9934 1.648 0.8 13.184 37
I9934 9934 0 1.28631e-05
R10844 9934 9935 1.744 0.8 13.952 37
I9935 9935 0 1.23684e-05
R10845 9935 9936 1.616 0.8 12.928 37
I9936 9936 0 1.32342e-05
R10846 9936 9937 1.6 0.8 12.8 37
I9937 9937 0 1.28631e-05
R10847 9937 9938 1.696 0.8 13.568 37
I9938 9938 0 1.31105e-05
R10848 9938 9939 1.744 0.8 13.952 37
I9939 9939 0 1.28631e-05
R10849 9939 9940 1.6 0.8 12.8 37
I9940 9940 0 1.34816e-05
R10850 9940 9941 1.6 0.8 12.8 37
I9941 9941 0 1.31105e-05
R10851 9941 9942 1.712 0.8 13.696 37
I9942 9942 0 1.24921e-05
R10852 9942 9943 1.744 0.8 13.952 37
I9943 9943 0 1.26158e-05
R10853 9943 9944 1.728 0.8 13.824 37
I9944 9944 0 1.27395e-05
R10854 9944 9945 1.616 0.8 12.928 37
I9945 9945 0 1.28631e-05
R10855 9945 9946 1.68 0.8 13.44 37
I9946 9946 0 1.32342e-05
R10856 9946 9947 1.728 0.8 13.824 37
I9947 9947 0 1.26158e-05
R10857 9947 9948 1.648 0.8 13.184 37
I9948 9948 0 1.34816e-05
R10858 9948 9949 1.648 0.8 13.184 37
I9949 9949 0 1.34816e-05
R10859 9949 9950 1.68 0.8 13.44 37
I9950 9950 0 1.28631e-05
R10860 9950 9951 1.744 0.8 13.952 37
I9951 9951 0 1.32342e-05
R10861 9951 9952 1.648 0.8 13.184 37
I9952 9952 0 1.34816e-05
R10862 9952 9953 1.648 0.8 13.184 37
I9953 9953 0 1.34816e-05
R10863 9953 9954 1.728 0.8 13.824 37
I9954 9954 0 1.29868e-05
R10864 9954 9955 1.696 0.8 13.568 37
I9955 9955 0 1.23684e-05
R10865 9955 9956 1.696 0.8 13.568 37
I9956 9956 0 1.31105e-05
R10866 9956 9957 1.696 0.8 13.568 37
I9957 9957 0 1.27395e-05
R10867 9957 9958 1.744 0.8 13.952 37
I9958 9958 0 1.31105e-05
R10868 9958 9959 1.728 0.8 13.824 37
I9959 9959 0 1.32342e-05
R10869 9959 9960 1.616 0.8 12.928 37
I9960 9960 0 1.24921e-05
R10870 9960 9961 1.664 0.8 13.312 37
I9961 9961 0 1.31105e-05
R10871 9961 9962 1.744 0.8 13.952 37
I9962 9962 0 1.28631e-05
R10872 9962 9963 1.728 0.8 13.824 37
I9963 9963 0 1.28631e-05
R10873 9963 9964 1.68 0.8 13.44 37
I9964 9964 0 1.24921e-05
R10874 9964 9965 1.68 0.8 13.44 37
I9965 9965 0 1.23684e-05
R10875 9965 9966 1.696 0.8 13.568 37
I9966 9966 0 1.29868e-05
R10876 9966 9967 1.712 0.8 13.696 37
I9967 9967 0 1.34816e-05
R10877 9967 9968 1.696 0.8 13.568 37
I9968 9968 0 1.27395e-05
R10878 9968 9969 1.616 0.8 12.928 37
I9969 9969 0 1.28631e-05
R10879 9969 9970 1.728 0.8 13.824 37
I9970 9970 0 1.34816e-05
R10880 9970 9971 1.712 0.8 13.696 37
I9971 9971 0 1.31105e-05
R10881 9971 9972 1.68 0.8 13.44 37
I9972 9972 0 1.27395e-05
R10882 9972 9973 1.6 0.8 12.8 37
I9973 9973 0 1.31105e-05
R10883 9973 9974 1.616 0.8 12.928 37
I9974 9974 0 1.23684e-05
R10884 9974 9975 1.696 0.8 13.568 37
I9975 9975 0 1.26158e-05
R10885 9975 9976 1.616 0.8 12.928 37
I9976 9976 0 1.23684e-05
R10886 9976 9977 1.616 0.8 12.928 37
I9977 9977 0 1.26158e-05
R10887 9977 9978 1.696 0.8 13.568 37
I9978 9978 0 1.34816e-05
R10888 9978 9979 1.712 0.8 13.696 37
I9979 9979 0 1.24921e-05
R10889 9979 9980 1.648 0.8 13.184 37
I9980 9980 0 1.28631e-05
R10890 9980 9981 1.616 0.8 12.928 37
I9981 9981 0 1.24921e-05
R10891 9981 9982 1.744 0.8 13.952 37
I9982 9982 0 1.24921e-05
R10892 9982 9983 1.632 0.8 13.056 37
I9983 9983 0 1.33579e-05
R10893 9983 9984 1.696 0.8 13.568 37
I9984 9984 0 1.29868e-05
R10894 9984 9985 1.664 0.8 13.312 37
I9985 9985 0 1.28631e-05
R10895 9985 9986 1.664 0.8 13.312 37
I9986 9986 0 1.24921e-05
R10896 9986 9987 1.6 0.8 12.8 37
I9987 9987 0 1.24921e-05
R10897 9987 9988 1.68 0.8 13.44 37
I9988 9988 0 1.26158e-05
R10898 9988 9989 1.728 0.8 13.824 37
I9989 9989 0 1.33579e-05
R10899 9989 9990 1.664 0.8 13.312 37
I9990 9990 0 1.28631e-05
R10900 9990 9991 1.616 0.8 12.928 37
I9991 9991 0 1.31105e-05
R10901 9991 9992 1.696 0.8 13.568 37
I9992 9992 0 1.28631e-05
R10902 9992 9993 1.728 0.8 13.824 37
I9993 9993 0 1.26158e-05
R10903 9993 9994 1.648 0.8 13.184 37
I9994 9994 0 1.32342e-05
R10904 9994 9995 1.648 0.8 13.184 37
I9995 9995 0 1.33579e-05
R10905 9995 9996 1.632 0.8 13.056 37
I9996 9996 0 1.31105e-05
R10906 9996 9997 1.744 0.8 13.952 37
I9997 9997 0 1.27395e-05
R10907 9997 9998 1.744 0.8 13.952 37
I9998 9998 0 1.28631e-05
R10908 9998 9999 1.616 0.8 12.928 37
I9999 9999 0 1.29868e-05
R10909 9999 10000 1.744 0.8 13.952 37
I10000 10000 0 1.23684e-05
R10910 10000 10001 0.5 10 50 37
V1 10001 0 5

.op
.end
