num_node 1001
matrix_size 1002

* 10 x 100 ground network
*seg: 1
* inter-segment connection
R1 10 110 6.16 0.8 49.28 37
R2 20 120 6.16 0.8 49.28 37
R3 30 130 6.16 0.8 49.28 37
R4 40 140 6.16 0.8 49.28 37
R5 50 150 6.16 0.8 49.28 37
R6 60 160 6.16 0.8 49.28 37
R7 70 170 6.16 0.8 49.28 37
R8 80 180 6.16 0.8 49.28 37
R9 90 190 6.16 0.8 49.28 37
R10 100 200 6.16 0.8 49.28 37
R11 1001 1 0.4 20 80 37
I1 1 0 1.27395e-05
R12 1 2 1.696 0.8 13.568 37
I2 2 0 1.32342e-05
R13 2 3 1.68 0.8 13.44 37
I3 3 0 1.27395e-05
R14 3 4 1.68 0.8 13.44 37
I4 4 0 1.31105e-05
R15 4 5 1.632 0.8 13.056 37
I5 5 0 1.34816e-05
R16 5 6 1.616 0.8 12.928 37
I6 6 0 1.26158e-05
R17 6 7 1.712 0.8 13.696 37
I7 7 0 1.23684e-05
R18 7 8 1.744 0.8 13.952 37
I8 8 0 1.27395e-05
R19 8 9 1.696 0.8 13.568 37
I9 9 0 1.23684e-05
R20 9 10 1.696 0.8 13.568 37
I10 10 0 1.26158e-05
R21 10 11 1.696 0.8 13.568 37
I11 11 0 1.24921e-05
R22 11 12 1.728 0.8 13.824 37
I12 12 0 1.32342e-05
R23 12 13 1.744 0.8 13.952 37
I13 13 0 1.26158e-05
R24 13 14 1.6 0.8 12.8 37
I14 14 0 1.26158e-05
R25 14 15 1.648 0.8 13.184 37
I15 15 0 1.32342e-05
R26 15 16 1.68 0.8 13.44 37
I16 16 0 1.34816e-05
R27 16 17 1.632 0.8 13.056 37
I17 17 0 1.26158e-05
R28 17 18 1.728 0.8 13.824 37
I18 18 0 1.34816e-05
R29 18 19 1.712 0.8 13.696 37
I19 19 0 1.27395e-05
R30 19 20 1.696 0.8 13.568 37
I20 20 0 1.24921e-05
R31 20 21 1.632 0.8 13.056 37
I21 21 0 1.34816e-05
R32 21 22 1.648 0.8 13.184 37
I22 22 0 1.24921e-05
R33 22 23 1.744 0.8 13.952 37
I23 23 0 1.28631e-05
R34 23 24 1.712 0.8 13.696 37
I24 24 0 1.33579e-05
R35 24 25 1.664 0.8 13.312 37
I25 25 0 1.29868e-05
R36 25 26 1.6 0.8 12.8 37
I26 26 0 1.27395e-05
R37 26 27 1.696 0.8 13.568 37
I27 27 0 1.24921e-05
R38 27 28 1.6 0.8 12.8 37
I28 28 0 1.31105e-05
R39 28 29 1.648 0.8 13.184 37
I29 29 0 1.26158e-05
R40 29 30 1.6 0.8 12.8 37
I30 30 0 1.31105e-05
R41 30 31 1.616 0.8 12.928 37
I31 31 0 1.29868e-05
R42 31 32 1.68 0.8 13.44 37
I32 32 0 1.28631e-05
R43 32 33 1.712 0.8 13.696 37
I33 33 0 1.31105e-05
R44 33 34 1.68 0.8 13.44 37
I34 34 0 1.31105e-05
R45 34 35 1.744 0.8 13.952 37
I35 35 0 1.27395e-05
R46 35 36 1.712 0.8 13.696 37
I36 36 0 1.28631e-05
R47 36 37 1.68 0.8 13.44 37
I37 37 0 1.26158e-05
R48 37 38 1.68 0.8 13.44 37
I38 38 0 1.28631e-05
R49 38 39 1.712 0.8 13.696 37
I39 39 0 1.28631e-05
R50 39 40 1.664 0.8 13.312 37
I40 40 0 1.27395e-05
R51 40 41 1.6 0.8 12.8 37
I41 41 0 1.32342e-05
R52 41 42 1.728 0.8 13.824 37
I42 42 0 1.31105e-05
R53 42 43 1.728 0.8 13.824 37
I43 43 0 1.33579e-05
R54 43 44 1.664 0.8 13.312 37
I44 44 0 1.27395e-05
R55 44 45 1.616 0.8 12.928 37
I45 45 0 1.28631e-05
R56 45 46 1.744 0.8 13.952 37
I46 46 0 1.26158e-05
R57 46 47 1.6 0.8 12.8 37
I47 47 0 1.31105e-05
R58 47 48 1.728 0.8 13.824 37
I48 48 0 1.34816e-05
R59 48 49 1.632 0.8 13.056 37
I49 49 0 1.31105e-05
R60 49 50 1.696 0.8 13.568 37
I50 50 0 1.28631e-05
R61 50 51 1.744 0.8 13.952 37
I51 51 0 1.29868e-05
R62 51 52 1.6 0.8 12.8 37
I52 52 0 1.28631e-05
R63 52 53 1.728 0.8 13.824 37
I53 53 0 1.32342e-05
R64 53 54 1.616 0.8 12.928 37
I54 54 0 1.32342e-05
R65 54 55 1.632 0.8 13.056 37
I55 55 0 1.32342e-05
R66 55 56 1.632 0.8 13.056 37
I56 56 0 1.26158e-05
R67 56 57 1.696 0.8 13.568 37
I57 57 0 1.24921e-05
R68 57 58 1.6 0.8 12.8 37
I58 58 0 1.31105e-05
R69 58 59 1.616 0.8 12.928 37
I59 59 0 1.29868e-05
R70 59 60 1.744 0.8 13.952 37
I60 60 0 1.28631e-05
R71 60 61 1.744 0.8 13.952 37
I61 61 0 1.23684e-05
R72 61 62 1.744 0.8 13.952 37
I62 62 0 1.24921e-05
R73 62 63 1.712 0.8 13.696 37
I63 63 0 1.32342e-05
R74 63 64 1.616 0.8 12.928 37
I64 64 0 1.24921e-05
R75 64 65 1.68 0.8 13.44 37
I65 65 0 1.34816e-05
R76 65 66 1.712 0.8 13.696 37
I66 66 0 1.32342e-05
R77 66 67 1.696 0.8 13.568 37
I67 67 0 1.32342e-05
R78 67 68 1.648 0.8 13.184 37
I68 68 0 1.31105e-05
R79 68 69 1.68 0.8 13.44 37
I69 69 0 1.31105e-05
R80 69 70 1.648 0.8 13.184 37
I70 70 0 1.34816e-05
R81 70 71 1.664 0.8 13.312 37
I71 71 0 1.33579e-05
R82 71 72 1.616 0.8 12.928 37
I72 72 0 1.26158e-05
R83 72 73 1.744 0.8 13.952 37
I73 73 0 1.27395e-05
R84 73 74 1.744 0.8 13.952 37
I74 74 0 1.23684e-05
R85 74 75 1.728 0.8 13.824 37
I75 75 0 1.33579e-05
R86 75 76 1.68 0.8 13.44 37
I76 76 0 1.23684e-05
R87 76 77 1.744 0.8 13.952 37
I77 77 0 1.31105e-05
R88 77 78 1.648 0.8 13.184 37
I78 78 0 1.33579e-05
R89 78 79 1.68 0.8 13.44 37
I79 79 0 1.31105e-05
R90 79 80 1.616 0.8 12.928 37
I80 80 0 1.24921e-05
R91 80 81 1.68 0.8 13.44 37
I81 81 0 1.34816e-05
R92 81 82 1.728 0.8 13.824 37
I82 82 0 1.28631e-05
R93 82 83 1.728 0.8 13.824 37
I83 83 0 1.24921e-05
R94 83 84 1.6 0.8 12.8 37
I84 84 0 1.27395e-05
R95 84 85 1.6 0.8 12.8 37
I85 85 0 1.28631e-05
R96 85 86 1.664 0.8 13.312 37
I86 86 0 1.28631e-05
R97 86 87 1.664 0.8 13.312 37
I87 87 0 1.32342e-05
R98 87 88 1.696 0.8 13.568 37
I88 88 0 1.27395e-05
R99 88 89 1.616 0.8 12.928 37
I89 89 0 1.32342e-05
R100 89 90 1.68 0.8 13.44 37
I90 90 0 1.34816e-05
R101 90 91 1.696 0.8 13.568 37
I91 91 0 1.26158e-05
R102 91 92 1.616 0.8 12.928 37
I92 92 0 1.32342e-05
R103 92 93 1.728 0.8 13.824 37
I93 93 0 1.29868e-05
R104 93 94 1.712 0.8 13.696 37
I94 94 0 1.28631e-05
R105 94 95 1.616 0.8 12.928 37
I95 95 0 1.33579e-05
R106 95 96 1.68 0.8 13.44 37
I96 96 0 1.34816e-05
R107 96 97 1.712 0.8 13.696 37
I97 97 0 1.29868e-05
R108 97 98 1.648 0.8 13.184 37
I98 98 0 1.33579e-05
R109 98 99 1.728 0.8 13.824 37
I99 99 0 1.27395e-05
R110 99 100 1.616 0.8 12.928 37
I100 100 0 1.23684e-05
R111 100 1001 0.5 10 50 37
*seg: 2
* inter-segment connection
R112 110 210 6.16 0.8 49.28 37
R113 120 220 6.16 0.8 49.28 37
R114 130 230 6.16 0.8 49.28 37
R115 140 240 6.16 0.8 49.28 37
R116 150 250 6.16 0.8 49.28 37
R117 160 260 6.16 0.8 49.28 37
R118 170 270 6.16 0.8 49.28 37
R119 180 280 6.16 0.8 49.28 37
R120 190 290 6.16 0.8 49.28 37
R121 200 300 6.16 0.8 49.28 37
R122 1001 101 0.4 20 80 37
I101 101 0 1.33579e-05
R123 101 102 1.744 0.8 13.952 37
I102 102 0 1.31105e-05
R124 102 103 1.664 0.8 13.312 37
I103 103 0 1.27395e-05
R125 103 104 1.648 0.8 13.184 37
I104 104 0 1.27395e-05
R126 104 105 1.728 0.8 13.824 37
I105 105 0 1.31105e-05
R127 105 106 1.6 0.8 12.8 37
I106 106 0 1.28631e-05
R128 106 107 1.728 0.8 13.824 37
I107 107 0 1.33579e-05
R129 107 108 1.728 0.8 13.824 37
I108 108 0 1.34816e-05
R130 108 109 1.712 0.8 13.696 37
I109 109 0 1.32342e-05
R131 109 110 1.696 0.8 13.568 37
I110 110 0 1.28631e-05
R132 110 111 1.648 0.8 13.184 37
I111 111 0 1.23684e-05
R133 111 112 1.648 0.8 13.184 37
I112 112 0 1.23684e-05
R134 112 113 1.744 0.8 13.952 37
I113 113 0 1.26158e-05
R135 113 114 1.68 0.8 13.44 37
I114 114 0 1.28631e-05
R136 114 115 1.6 0.8 12.8 37
I115 115 0 1.29868e-05
R137 115 116 1.744 0.8 13.952 37
I116 116 0 1.28631e-05
R138 116 117 1.696 0.8 13.568 37
I117 117 0 1.34816e-05
R139 117 118 1.632 0.8 13.056 37
I118 118 0 1.26158e-05
R140 118 119 1.664 0.8 13.312 37
I119 119 0 1.32342e-05
R141 119 120 1.712 0.8 13.696 37
I120 120 0 1.29868e-05
R142 120 121 1.664 0.8 13.312 37
I121 121 0 1.33579e-05
R143 121 122 1.616 0.8 12.928 37
I122 122 0 1.26158e-05
R144 122 123 1.728 0.8 13.824 37
I123 123 0 1.34816e-05
R145 123 124 1.648 0.8 13.184 37
I124 124 0 1.31105e-05
R146 124 125 1.728 0.8 13.824 37
I125 125 0 1.23684e-05
R147 125 126 1.632 0.8 13.056 37
I126 126 0 1.24921e-05
R148 126 127 1.6 0.8 12.8 37
I127 127 0 1.29868e-05
R149 127 128 1.616 0.8 12.928 37
I128 128 0 1.24921e-05
R150 128 129 1.6 0.8 12.8 37
I129 129 0 1.33579e-05
R151 129 130 1.68 0.8 13.44 37
I130 130 0 1.23684e-05
R152 130 131 1.696 0.8 13.568 37
I131 131 0 1.28631e-05
R153 131 132 1.696 0.8 13.568 37
I132 132 0 1.26158e-05
R154 132 133 1.68 0.8 13.44 37
I133 133 0 1.33579e-05
R155 133 134 1.696 0.8 13.568 37
I134 134 0 1.26158e-05
R156 134 135 1.728 0.8 13.824 37
I135 135 0 1.28631e-05
R157 135 136 1.712 0.8 13.696 37
I136 136 0 1.26158e-05
R158 136 137 1.664 0.8 13.312 37
I137 137 0 1.23684e-05
R159 137 138 1.696 0.8 13.568 37
I138 138 0 1.26158e-05
R160 138 139 1.744 0.8 13.952 37
I139 139 0 1.34816e-05
R161 139 140 1.6 0.8 12.8 37
I140 140 0 1.33579e-05
R162 140 141 1.616 0.8 12.928 37
I141 141 0 1.27395e-05
R163 141 142 1.616 0.8 12.928 37
I142 142 0 1.24921e-05
R164 142 143 1.6 0.8 12.8 37
I143 143 0 1.27395e-05
R165 143 144 1.664 0.8 13.312 37
I144 144 0 1.23684e-05
R166 144 145 1.648 0.8 13.184 37
I145 145 0 1.34816e-05
R167 145 146 1.616 0.8 12.928 37
I146 146 0 1.34816e-05
R168 146 147 1.696 0.8 13.568 37
I147 147 0 1.34816e-05
R169 147 148 1.648 0.8 13.184 37
I148 148 0 1.27395e-05
R170 148 149 1.728 0.8 13.824 37
I149 149 0 1.23684e-05
R171 149 150 1.68 0.8 13.44 37
I150 150 0 1.31105e-05
R172 150 151 1.696 0.8 13.568 37
I151 151 0 1.28631e-05
R173 151 152 1.6 0.8 12.8 37
I152 152 0 1.23684e-05
R174 152 153 1.664 0.8 13.312 37
I153 153 0 1.31105e-05
R175 153 154 1.632 0.8 13.056 37
I154 154 0 1.31105e-05
R176 154 155 1.712 0.8 13.696 37
I155 155 0 1.29868e-05
R177 155 156 1.696 0.8 13.568 37
I156 156 0 1.34816e-05
R178 156 157 1.728 0.8 13.824 37
I157 157 0 1.32342e-05
R179 157 158 1.632 0.8 13.056 37
I158 158 0 1.33579e-05
R180 158 159 1.632 0.8 13.056 37
I159 159 0 1.34816e-05
R181 159 160 1.744 0.8 13.952 37
I160 160 0 1.31105e-05
R182 160 161 1.6 0.8 12.8 37
I161 161 0 1.26158e-05
R183 161 162 1.712 0.8 13.696 37
I162 162 0 1.31105e-05
R184 162 163 1.616 0.8 12.928 37
I163 163 0 1.27395e-05
R185 163 164 1.632 0.8 13.056 37
I164 164 0 1.24921e-05
R186 164 165 1.68 0.8 13.44 37
I165 165 0 1.34816e-05
R187 165 166 1.744 0.8 13.952 37
I166 166 0 1.24921e-05
R188 166 167 1.664 0.8 13.312 37
I167 167 0 1.34816e-05
R189 167 168 1.616 0.8 12.928 37
I168 168 0 1.23684e-05
R190 168 169 1.712 0.8 13.696 37
I169 169 0 1.29868e-05
R191 169 170 1.728 0.8 13.824 37
I170 170 0 1.32342e-05
R192 170 171 1.6 0.8 12.8 37
I171 171 0 1.28631e-05
R193 171 172 1.728 0.8 13.824 37
I172 172 0 1.23684e-05
R194 172 173 1.664 0.8 13.312 37
I173 173 0 1.26158e-05
R195 173 174 1.744 0.8 13.952 37
I174 174 0 1.31105e-05
R196 174 175 1.616 0.8 12.928 37
I175 175 0 1.23684e-05
R197 175 176 1.664 0.8 13.312 37
I176 176 0 1.26158e-05
R198 176 177 1.632 0.8 13.056 37
I177 177 0 1.26158e-05
R199 177 178 1.6 0.8 12.8 37
I178 178 0 1.29868e-05
R200 178 179 1.68 0.8 13.44 37
I179 179 0 1.26158e-05
R201 179 180 1.744 0.8 13.952 37
I180 180 0 1.23684e-05
R202 180 181 1.632 0.8 13.056 37
I181 181 0 1.33579e-05
R203 181 182 1.648 0.8 13.184 37
I182 182 0 1.33579e-05
R204 182 183 1.6 0.8 12.8 37
I183 183 0 1.28631e-05
R205 183 184 1.6 0.8 12.8 37
I184 184 0 1.34816e-05
R206 184 185 1.616 0.8 12.928 37
I185 185 0 1.34816e-05
R207 185 186 1.696 0.8 13.568 37
I186 186 0 1.26158e-05
R208 186 187 1.68 0.8 13.44 37
I187 187 0 1.28631e-05
R209 187 188 1.664 0.8 13.312 37
I188 188 0 1.34816e-05
R210 188 189 1.744 0.8 13.952 37
I189 189 0 1.27395e-05
R211 189 190 1.696 0.8 13.568 37
I190 190 0 1.23684e-05
R212 190 191 1.68 0.8 13.44 37
I191 191 0 1.23684e-05
R213 191 192 1.632 0.8 13.056 37
I192 192 0 1.34816e-05
R214 192 193 1.664 0.8 13.312 37
I193 193 0 1.27395e-05
R215 193 194 1.68 0.8 13.44 37
I194 194 0 1.24921e-05
R216 194 195 1.712 0.8 13.696 37
I195 195 0 1.28631e-05
R217 195 196 1.648 0.8 13.184 37
I196 196 0 1.24921e-05
R218 196 197 1.664 0.8 13.312 37
I197 197 0 1.31105e-05
R219 197 198 1.744 0.8 13.952 37
I198 198 0 1.28631e-05
R220 198 199 1.632 0.8 13.056 37
I199 199 0 1.26158e-05
R221 199 200 1.696 0.8 13.568 37
I200 200 0 1.23684e-05
R222 200 1001 0.5 10 50 37
*seg: 3
* inter-segment connection
R223 210 310 6.16 0.8 49.28 37
R224 220 320 6.16 0.8 49.28 37
R225 230 330 6.16 0.8 49.28 37
R226 240 340 6.16 0.8 49.28 37
R227 250 350 6.16 0.8 49.28 37
R228 260 360 6.16 0.8 49.28 37
R229 270 370 6.16 0.8 49.28 37
R230 280 380 6.16 0.8 49.28 37
R231 290 390 6.16 0.8 49.28 37
R232 300 400 6.16 0.8 49.28 37
R233 1001 201 0.4 20 80 37
I201 201 0 1.28631e-05
R234 201 202 1.616 0.8 12.928 37
I202 202 0 1.26158e-05
R235 202 203 1.728 0.8 13.824 37
I203 203 0 1.33579e-05
R236 203 204 1.744 0.8 13.952 37
I204 204 0 1.26158e-05
R237 204 205 1.728 0.8 13.824 37
I205 205 0 1.33579e-05
R238 205 206 1.728 0.8 13.824 37
I206 206 0 1.31105e-05
R239 206 207 1.728 0.8 13.824 37
I207 207 0 1.27395e-05
R240 207 208 1.728 0.8 13.824 37
I208 208 0 1.27395e-05
R241 208 209 1.648 0.8 13.184 37
I209 209 0 1.27395e-05
R242 209 210 1.728 0.8 13.824 37
I210 210 0 1.23684e-05
R243 210 211 1.664 0.8 13.312 37
I211 211 0 1.32342e-05
R244 211 212 1.696 0.8 13.568 37
I212 212 0 1.33579e-05
R245 212 213 1.744 0.8 13.952 37
I213 213 0 1.23684e-05
R246 213 214 1.696 0.8 13.568 37
I214 214 0 1.33579e-05
R247 214 215 1.712 0.8 13.696 37
I215 215 0 1.34816e-05
R248 215 216 1.6 0.8 12.8 37
I216 216 0 1.27395e-05
R249 216 217 1.648 0.8 13.184 37
I217 217 0 1.27395e-05
R250 217 218 1.712 0.8 13.696 37
I218 218 0 1.27395e-05
R251 218 219 1.632 0.8 13.056 37
I219 219 0 1.31105e-05
R252 219 220 1.68 0.8 13.44 37
I220 220 0 1.26158e-05
R253 220 221 1.696 0.8 13.568 37
I221 221 0 1.29868e-05
R254 221 222 1.728 0.8 13.824 37
I222 222 0 1.32342e-05
R255 222 223 1.744 0.8 13.952 37
I223 223 0 1.31105e-05
R256 223 224 1.6 0.8 12.8 37
I224 224 0 1.28631e-05
R257 224 225 1.616 0.8 12.928 37
I225 225 0 1.23684e-05
R258 225 226 1.664 0.8 13.312 37
I226 226 0 1.33579e-05
R259 226 227 1.712 0.8 13.696 37
I227 227 0 1.23684e-05
R260 227 228 1.728 0.8 13.824 37
I228 228 0 1.31105e-05
R261 228 229 1.632 0.8 13.056 37
I229 229 0 1.28631e-05
R262 229 230 1.712 0.8 13.696 37
I230 230 0 1.34816e-05
R263 230 231 1.648 0.8 13.184 37
I231 231 0 1.34816e-05
R264 231 232 1.632 0.8 13.056 37
I232 232 0 1.33579e-05
R265 232 233 1.648 0.8 13.184 37
I233 233 0 1.23684e-05
R266 233 234 1.616 0.8 12.928 37
I234 234 0 1.32342e-05
R267 234 235 1.728 0.8 13.824 37
I235 235 0 1.34816e-05
R268 235 236 1.616 0.8 12.928 37
I236 236 0 1.29868e-05
R269 236 237 1.664 0.8 13.312 37
I237 237 0 1.34816e-05
R270 237 238 1.632 0.8 13.056 37
I238 238 0 1.29868e-05
R271 238 239 1.712 0.8 13.696 37
I239 239 0 1.28631e-05
R272 239 240 1.744 0.8 13.952 37
I240 240 0 1.34816e-05
R273 240 241 1.664 0.8 13.312 37
I241 241 0 1.29868e-05
R274 241 242 1.744 0.8 13.952 37
I242 242 0 1.27395e-05
R275 242 243 1.68 0.8 13.44 37
I243 243 0 1.32342e-05
R276 243 244 1.6 0.8 12.8 37
I244 244 0 1.33579e-05
R277 244 245 1.616 0.8 12.928 37
I245 245 0 1.34816e-05
R278 245 246 1.744 0.8 13.952 37
I246 246 0 1.32342e-05
R279 246 247 1.728 0.8 13.824 37
I247 247 0 1.26158e-05
R280 247 248 1.68 0.8 13.44 37
I248 248 0 1.27395e-05
R281 248 249 1.664 0.8 13.312 37
I249 249 0 1.34816e-05
R282 249 250 1.6 0.8 12.8 37
I250 250 0 1.26158e-05
R283 250 251 1.6 0.8 12.8 37
I251 251 0 1.24921e-05
R284 251 252 1.744 0.8 13.952 37
I252 252 0 1.31105e-05
R285 252 253 1.632 0.8 13.056 37
I253 253 0 1.24921e-05
R286 253 254 1.632 0.8 13.056 37
I254 254 0 1.23684e-05
R287 254 255 1.712 0.8 13.696 37
I255 255 0 1.27395e-05
R288 255 256 1.616 0.8 12.928 37
I256 256 0 1.24921e-05
R289 256 257 1.744 0.8 13.952 37
I257 257 0 1.23684e-05
R290 257 258 1.68 0.8 13.44 37
I258 258 0 1.31105e-05
R291 258 259 1.712 0.8 13.696 37
I259 259 0 1.32342e-05
R292 259 260 1.664 0.8 13.312 37
I260 260 0 1.23684e-05
R293 260 261 1.696 0.8 13.568 37
I261 261 0 1.28631e-05
R294 261 262 1.712 0.8 13.696 37
I262 262 0 1.28631e-05
R295 262 263 1.728 0.8 13.824 37
I263 263 0 1.29868e-05
R296 263 264 1.728 0.8 13.824 37
I264 264 0 1.26158e-05
R297 264 265 1.696 0.8 13.568 37
I265 265 0 1.23684e-05
R298 265 266 1.696 0.8 13.568 37
I266 266 0 1.31105e-05
R299 266 267 1.664 0.8 13.312 37
I267 267 0 1.31105e-05
R300 267 268 1.632 0.8 13.056 37
I268 268 0 1.33579e-05
R301 268 269 1.744 0.8 13.952 37
I269 269 0 1.31105e-05
R302 269 270 1.6 0.8 12.8 37
I270 270 0 1.32342e-05
R303 270 271 1.6 0.8 12.8 37
I271 271 0 1.24921e-05
R304 271 272 1.6 0.8 12.8 37
I272 272 0 1.24921e-05
R305 272 273 1.648 0.8 13.184 37
I273 273 0 1.32342e-05
R306 273 274 1.712 0.8 13.696 37
I274 274 0 1.26158e-05
R307 274 275 1.696 0.8 13.568 37
I275 275 0 1.28631e-05
R308 275 276 1.68 0.8 13.44 37
I276 276 0 1.26158e-05
R309 276 277 1.6 0.8 12.8 37
I277 277 0 1.26158e-05
R310 277 278 1.744 0.8 13.952 37
I278 278 0 1.23684e-05
R311 278 279 1.744 0.8 13.952 37
I279 279 0 1.34816e-05
R312 279 280 1.664 0.8 13.312 37
I280 280 0 1.29868e-05
R313 280 281 1.616 0.8 12.928 37
I281 281 0 1.23684e-05
R314 281 282 1.648 0.8 13.184 37
I282 282 0 1.32342e-05
R315 282 283 1.728 0.8 13.824 37
I283 283 0 1.33579e-05
R316 283 284 1.696 0.8 13.568 37
I284 284 0 1.23684e-05
R317 284 285 1.664 0.8 13.312 37
I285 285 0 1.31105e-05
R318 285 286 1.712 0.8 13.696 37
I286 286 0 1.31105e-05
R319 286 287 1.6 0.8 12.8 37
I287 287 0 1.34816e-05
R320 287 288 1.712 0.8 13.696 37
I288 288 0 1.29868e-05
R321 288 289 1.744 0.8 13.952 37
I289 289 0 1.32342e-05
R322 289 290 1.728 0.8 13.824 37
I290 290 0 1.29868e-05
R323 290 291 1.648 0.8 13.184 37
I291 291 0 1.27395e-05
R324 291 292 1.728 0.8 13.824 37
I292 292 0 1.27395e-05
R325 292 293 1.712 0.8 13.696 37
I293 293 0 1.34816e-05
R326 293 294 1.648 0.8 13.184 37
I294 294 0 1.32342e-05
R327 294 295 1.728 0.8 13.824 37
I295 295 0 1.32342e-05
R328 295 296 1.664 0.8 13.312 37
I296 296 0 1.24921e-05
R329 296 297 1.744 0.8 13.952 37
I297 297 0 1.23684e-05
R330 297 298 1.744 0.8 13.952 37
I298 298 0 1.33579e-05
R331 298 299 1.728 0.8 13.824 37
I299 299 0 1.29868e-05
R332 299 300 1.728 0.8 13.824 37
I300 300 0 1.23684e-05
R333 300 1001 0.5 10 50 37
*seg: 4
* inter-segment connection
R334 310 410 6.16 0.8 49.28 37
R335 320 420 6.16 0.8 49.28 37
R336 330 430 6.16 0.8 49.28 37
R337 340 440 6.16 0.8 49.28 37
R338 350 450 6.16 0.8 49.28 37
R339 360 460 6.16 0.8 49.28 37
R340 370 470 6.16 0.8 49.28 37
R341 380 480 6.16 0.8 49.28 37
R342 390 490 6.16 0.8 49.28 37
R343 400 500 6.16 0.8 49.28 37
R344 1001 301 0.4 20 80 37
I301 301 0 1.28631e-05
R345 301 302 1.648 0.8 13.184 37
I302 302 0 1.32342e-05
R346 302 303 1.616 0.8 12.928 37
I303 303 0 1.27395e-05
R347 303 304 1.728 0.8 13.824 37
I304 304 0 1.23684e-05
R348 304 305 1.744 0.8 13.952 37
I305 305 0 1.32342e-05
R349 305 306 1.744 0.8 13.952 37
I306 306 0 1.34816e-05
R350 306 307 1.648 0.8 13.184 37
I307 307 0 1.26158e-05
R351 307 308 1.664 0.8 13.312 37
I308 308 0 1.27395e-05
R352 308 309 1.712 0.8 13.696 37
I309 309 0 1.24921e-05
R353 309 310 1.632 0.8 13.056 37
I310 310 0 1.26158e-05
R354 310 311 1.6 0.8 12.8 37
I311 311 0 1.26158e-05
R355 311 312 1.616 0.8 12.928 37
I312 312 0 1.32342e-05
R356 312 313 1.68 0.8 13.44 37
I313 313 0 1.24921e-05
R357 313 314 1.712 0.8 13.696 37
I314 314 0 1.28631e-05
R358 314 315 1.616 0.8 12.928 37
I315 315 0 1.32342e-05
R359 315 316 1.616 0.8 12.928 37
I316 316 0 1.24921e-05
R360 316 317 1.616 0.8 12.928 37
I317 317 0 1.32342e-05
R361 317 318 1.6 0.8 12.8 37
I318 318 0 1.28631e-05
R362 318 319 1.6 0.8 12.8 37
I319 319 0 1.33579e-05
R363 319 320 1.68 0.8 13.44 37
I320 320 0 1.24921e-05
R364 320 321 1.696 0.8 13.568 37
I321 321 0 1.31105e-05
R365 321 322 1.632 0.8 13.056 37
I322 322 0 1.24921e-05
R366 322 323 1.744 0.8 13.952 37
I323 323 0 1.31105e-05
R367 323 324 1.664 0.8 13.312 37
I324 324 0 1.33579e-05
R368 324 325 1.6 0.8 12.8 37
I325 325 0 1.33579e-05
R369 325 326 1.616 0.8 12.928 37
I326 326 0 1.23684e-05
R370 326 327 1.632 0.8 13.056 37
I327 327 0 1.26158e-05
R371 327 328 1.744 0.8 13.952 37
I328 328 0 1.32342e-05
R372 328 329 1.68 0.8 13.44 37
I329 329 0 1.31105e-05
R373 329 330 1.664 0.8 13.312 37
I330 330 0 1.31105e-05
R374 330 331 1.648 0.8 13.184 37
I331 331 0 1.32342e-05
R375 331 332 1.744 0.8 13.952 37
I332 332 0 1.32342e-05
R376 332 333 1.664 0.8 13.312 37
I333 333 0 1.34816e-05
R377 333 334 1.616 0.8 12.928 37
I334 334 0 1.32342e-05
R378 334 335 1.6 0.8 12.8 37
I335 335 0 1.31105e-05
R379 335 336 1.6 0.8 12.8 37
I336 336 0 1.33579e-05
R380 336 337 1.68 0.8 13.44 37
I337 337 0 1.27395e-05
R381 337 338 1.744 0.8 13.952 37
I338 338 0 1.28631e-05
R382 338 339 1.616 0.8 12.928 37
I339 339 0 1.29868e-05
R383 339 340 1.664 0.8 13.312 37
I340 340 0 1.24921e-05
R384 340 341 1.68 0.8 13.44 37
I341 341 0 1.29868e-05
R385 341 342 1.664 0.8 13.312 37
I342 342 0 1.34816e-05
R386 342 343 1.728 0.8 13.824 37
I343 343 0 1.27395e-05
R387 343 344 1.728 0.8 13.824 37
I344 344 0 1.29868e-05
R388 344 345 1.632 0.8 13.056 37
I345 345 0 1.26158e-05
R389 345 346 1.632 0.8 13.056 37
I346 346 0 1.32342e-05
R390 346 347 1.6 0.8 12.8 37
I347 347 0 1.27395e-05
R391 347 348 1.664 0.8 13.312 37
I348 348 0 1.31105e-05
R392 348 349 1.648 0.8 13.184 37
I349 349 0 1.31105e-05
R393 349 350 1.648 0.8 13.184 37
I350 350 0 1.27395e-05
R394 350 351 1.664 0.8 13.312 37
I351 351 0 1.28631e-05
R395 351 352 1.648 0.8 13.184 37
I352 352 0 1.34816e-05
R396 352 353 1.712 0.8 13.696 37
I353 353 0 1.26158e-05
R397 353 354 1.68 0.8 13.44 37
I354 354 0 1.33579e-05
R398 354 355 1.744 0.8 13.952 37
I355 355 0 1.23684e-05
R399 355 356 1.632 0.8 13.056 37
I356 356 0 1.28631e-05
R400 356 357 1.712 0.8 13.696 37
I357 357 0 1.31105e-05
R401 357 358 1.68 0.8 13.44 37
I358 358 0 1.32342e-05
R402 358 359 1.616 0.8 12.928 37
I359 359 0 1.27395e-05
R403 359 360 1.648 0.8 13.184 37
I360 360 0 1.27395e-05
R404 360 361 1.728 0.8 13.824 37
I361 361 0 1.29868e-05
R405 361 362 1.616 0.8 12.928 37
I362 362 0 1.23684e-05
R406 362 363 1.728 0.8 13.824 37
I363 363 0 1.32342e-05
R407 363 364 1.696 0.8 13.568 37
I364 364 0 1.27395e-05
R408 364 365 1.68 0.8 13.44 37
I365 365 0 1.23684e-05
R409 365 366 1.728 0.8 13.824 37
I366 366 0 1.23684e-05
R410 366 367 1.664 0.8 13.312 37
I367 367 0 1.24921e-05
R411 367 368 1.616 0.8 12.928 37
I368 368 0 1.27395e-05
R412 368 369 1.68 0.8 13.44 37
I369 369 0 1.34816e-05
R413 369 370 1.648 0.8 13.184 37
I370 370 0 1.28631e-05
R414 370 371 1.616 0.8 12.928 37
I371 371 0 1.29868e-05
R415 371 372 1.6 0.8 12.8 37
I372 372 0 1.33579e-05
R416 372 373 1.648 0.8 13.184 37
I373 373 0 1.29868e-05
R417 373 374 1.696 0.8 13.568 37
I374 374 0 1.29868e-05
R418 374 375 1.744 0.8 13.952 37
I375 375 0 1.34816e-05
R419 375 376 1.6 0.8 12.8 37
I376 376 0 1.32342e-05
R420 376 377 1.696 0.8 13.568 37
I377 377 0 1.27395e-05
R421 377 378 1.712 0.8 13.696 37
I378 378 0 1.31105e-05
R422 378 379 1.616 0.8 12.928 37
I379 379 0 1.29868e-05
R423 379 380 1.6 0.8 12.8 37
I380 380 0 1.31105e-05
R424 380 381 1.68 0.8 13.44 37
I381 381 0 1.23684e-05
R425 381 382 1.728 0.8 13.824 37
I382 382 0 1.24921e-05
R426 382 383 1.632 0.8 13.056 37
I383 383 0 1.26158e-05
R427 383 384 1.696 0.8 13.568 37
I384 384 0 1.34816e-05
R428 384 385 1.616 0.8 12.928 37
I385 385 0 1.23684e-05
R429 385 386 1.664 0.8 13.312 37
I386 386 0 1.26158e-05
R430 386 387 1.712 0.8 13.696 37
I387 387 0 1.28631e-05
R431 387 388 1.6 0.8 12.8 37
I388 388 0 1.27395e-05
R432 388 389 1.632 0.8 13.056 37
I389 389 0 1.33579e-05
R433 389 390 1.6 0.8 12.8 37
I390 390 0 1.27395e-05
R434 390 391 1.712 0.8 13.696 37
I391 391 0 1.23684e-05
R435 391 392 1.6 0.8 12.8 37
I392 392 0 1.27395e-05
R436 392 393 1.664 0.8 13.312 37
I393 393 0 1.34816e-05
R437 393 394 1.632 0.8 13.056 37
I394 394 0 1.32342e-05
R438 394 395 1.664 0.8 13.312 37
I395 395 0 1.26158e-05
R439 395 396 1.68 0.8 13.44 37
I396 396 0 1.26158e-05
R440 396 397 1.664 0.8 13.312 37
I397 397 0 1.28631e-05
R441 397 398 1.648 0.8 13.184 37
I398 398 0 1.33579e-05
R442 398 399 1.696 0.8 13.568 37
I399 399 0 1.23684e-05
R443 399 400 1.728 0.8 13.824 37
I400 400 0 1.23684e-05
R444 400 1001 0.5 10 50 37
*seg: 5
* inter-segment connection
R445 410 510 6.16 0.8 49.28 37
R446 420 520 6.16 0.8 49.28 37
R447 430 530 6.16 0.8 49.28 37
R448 440 540 6.16 0.8 49.28 37
R449 450 550 6.16 0.8 49.28 37
R450 460 560 6.16 0.8 49.28 37
R451 470 570 6.16 0.8 49.28 37
R452 480 580 6.16 0.8 49.28 37
R453 490 590 6.16 0.8 49.28 37
R454 500 600 6.16 0.8 49.28 37
R455 1001 401 0.4 20 80 37
I401 401 0 1.34816e-05
R456 401 402 1.632 0.8 13.056 37
I402 402 0 1.26158e-05
R457 402 403 1.648 0.8 13.184 37
I403 403 0 1.24921e-05
R458 403 404 1.728 0.8 13.824 37
I404 404 0 1.27395e-05
R459 404 405 1.664 0.8 13.312 37
I405 405 0 1.26158e-05
R460 405 406 1.632 0.8 13.056 37
I406 406 0 1.28631e-05
R461 406 407 1.68 0.8 13.44 37
I407 407 0 1.24921e-05
R462 407 408 1.712 0.8 13.696 37
I408 408 0 1.29868e-05
R463 408 409 1.712 0.8 13.696 37
I409 409 0 1.24921e-05
R464 409 410 1.696 0.8 13.568 37
I410 410 0 1.34816e-05
R465 410 411 1.728 0.8 13.824 37
I411 411 0 1.24921e-05
R466 411 412 1.648 0.8 13.184 37
I412 412 0 1.27395e-05
R467 412 413 1.648 0.8 13.184 37
I413 413 0 1.32342e-05
R468 413 414 1.744 0.8 13.952 37
I414 414 0 1.33579e-05
R469 414 415 1.696 0.8 13.568 37
I415 415 0 1.32342e-05
R470 415 416 1.6 0.8 12.8 37
I416 416 0 1.28631e-05
R471 416 417 1.728 0.8 13.824 37
I417 417 0 1.28631e-05
R472 417 418 1.728 0.8 13.824 37
I418 418 0 1.24921e-05
R473 418 419 1.696 0.8 13.568 37
I419 419 0 1.33579e-05
R474 419 420 1.68 0.8 13.44 37
I420 420 0 1.26158e-05
R475 420 421 1.616 0.8 12.928 37
I421 421 0 1.34816e-05
R476 421 422 1.744 0.8 13.952 37
I422 422 0 1.31105e-05
R477 422 423 1.6 0.8 12.8 37
I423 423 0 1.31105e-05
R478 423 424 1.664 0.8 13.312 37
I424 424 0 1.34816e-05
R479 424 425 1.744 0.8 13.952 37
I425 425 0 1.23684e-05
R480 425 426 1.728 0.8 13.824 37
I426 426 0 1.34816e-05
R481 426 427 1.648 0.8 13.184 37
I427 427 0 1.24921e-05
R482 427 428 1.664 0.8 13.312 37
I428 428 0 1.33579e-05
R483 428 429 1.744 0.8 13.952 37
I429 429 0 1.31105e-05
R484 429 430 1.712 0.8 13.696 37
I430 430 0 1.32342e-05
R485 430 431 1.648 0.8 13.184 37
I431 431 0 1.32342e-05
R486 431 432 1.616 0.8 12.928 37
I432 432 0 1.26158e-05
R487 432 433 1.632 0.8 13.056 37
I433 433 0 1.24921e-05
R488 433 434 1.68 0.8 13.44 37
I434 434 0 1.23684e-05
R489 434 435 1.744 0.8 13.952 37
I435 435 0 1.23684e-05
R490 435 436 1.664 0.8 13.312 37
I436 436 0 1.23684e-05
R491 436 437 1.616 0.8 12.928 37
I437 437 0 1.27395e-05
R492 437 438 1.712 0.8 13.696 37
I438 438 0 1.28631e-05
R493 438 439 1.616 0.8 12.928 37
I439 439 0 1.24921e-05
R494 439 440 1.648 0.8 13.184 37
I440 440 0 1.23684e-05
R495 440 441 1.648 0.8 13.184 37
I441 441 0 1.26158e-05
R496 441 442 1.616 0.8 12.928 37
I442 442 0 1.32342e-05
R497 442 443 1.68 0.8 13.44 37
I443 443 0 1.31105e-05
R498 443 444 1.68 0.8 13.44 37
I444 444 0 1.28631e-05
R499 444 445 1.632 0.8 13.056 37
I445 445 0 1.26158e-05
R500 445 446 1.616 0.8 12.928 37
I446 446 0 1.32342e-05
R501 446 447 1.632 0.8 13.056 37
I447 447 0 1.28631e-05
R502 447 448 1.616 0.8 12.928 37
I448 448 0 1.31105e-05
R503 448 449 1.68 0.8 13.44 37
I449 449 0 1.32342e-05
R504 449 450 1.728 0.8 13.824 37
I450 450 0 1.29868e-05
R505 450 451 1.744 0.8 13.952 37
I451 451 0 1.26158e-05
R506 451 452 1.712 0.8 13.696 37
I452 452 0 1.27395e-05
R507 452 453 1.696 0.8 13.568 37
I453 453 0 1.28631e-05
R508 453 454 1.712 0.8 13.696 37
I454 454 0 1.34816e-05
R509 454 455 1.712 0.8 13.696 37
I455 455 0 1.26158e-05
R510 455 456 1.632 0.8 13.056 37
I456 456 0 1.24921e-05
R511 456 457 1.696 0.8 13.568 37
I457 457 0 1.27395e-05
R512 457 458 1.6 0.8 12.8 37
I458 458 0 1.26158e-05
R513 458 459 1.616 0.8 12.928 37
I459 459 0 1.29868e-05
R514 459 460 1.696 0.8 13.568 37
I460 460 0 1.29868e-05
R515 460 461 1.6 0.8 12.8 37
I461 461 0 1.23684e-05
R516 461 462 1.648 0.8 13.184 37
I462 462 0 1.28631e-05
R517 462 463 1.696 0.8 13.568 37
I463 463 0 1.31105e-05
R518 463 464 1.6 0.8 12.8 37
I464 464 0 1.26158e-05
R519 464 465 1.68 0.8 13.44 37
I465 465 0 1.33579e-05
R520 465 466 1.744 0.8 13.952 37
I466 466 0 1.29868e-05
R521 466 467 1.6 0.8 12.8 37
I467 467 0 1.31105e-05
R522 467 468 1.6 0.8 12.8 37
I468 468 0 1.33579e-05
R523 468 469 1.648 0.8 13.184 37
I469 469 0 1.32342e-05
R524 469 470 1.728 0.8 13.824 37
I470 470 0 1.26158e-05
R525 470 471 1.616 0.8 12.928 37
I471 471 0 1.23684e-05
R526 471 472 1.68 0.8 13.44 37
I472 472 0 1.33579e-05
R527 472 473 1.68 0.8 13.44 37
I473 473 0 1.29868e-05
R528 473 474 1.6 0.8 12.8 37
I474 474 0 1.32342e-05
R529 474 475 1.648 0.8 13.184 37
I475 475 0 1.33579e-05
R530 475 476 1.632 0.8 13.056 37
I476 476 0 1.27395e-05
R531 476 477 1.6 0.8 12.8 37
I477 477 0 1.32342e-05
R532 477 478 1.712 0.8 13.696 37
I478 478 0 1.32342e-05
R533 478 479 1.696 0.8 13.568 37
I479 479 0 1.34816e-05
R534 479 480 1.616 0.8 12.928 37
I480 480 0 1.24921e-05
R535 480 481 1.744 0.8 13.952 37
I481 481 0 1.23684e-05
R536 481 482 1.728 0.8 13.824 37
I482 482 0 1.34816e-05
R537 482 483 1.728 0.8 13.824 37
I483 483 0 1.33579e-05
R538 483 484 1.6 0.8 12.8 37
I484 484 0 1.27395e-05
R539 484 485 1.712 0.8 13.696 37
I485 485 0 1.23684e-05
R540 485 486 1.696 0.8 13.568 37
I486 486 0 1.34816e-05
R541 486 487 1.632 0.8 13.056 37
I487 487 0 1.24921e-05
R542 487 488 1.712 0.8 13.696 37
I488 488 0 1.32342e-05
R543 488 489 1.744 0.8 13.952 37
I489 489 0 1.32342e-05
R544 489 490 1.696 0.8 13.568 37
I490 490 0 1.26158e-05
R545 490 491 1.712 0.8 13.696 37
I491 491 0 1.24921e-05
R546 491 492 1.68 0.8 13.44 37
I492 492 0 1.33579e-05
R547 492 493 1.728 0.8 13.824 37
I493 493 0 1.28631e-05
R548 493 494 1.68 0.8 13.44 37
I494 494 0 1.31105e-05
R549 494 495 1.68 0.8 13.44 37
I495 495 0 1.31105e-05
R550 495 496 1.728 0.8 13.824 37
I496 496 0 1.28631e-05
R551 496 497 1.728 0.8 13.824 37
I497 497 0 1.33579e-05
R552 497 498 1.648 0.8 13.184 37
I498 498 0 1.33579e-05
R553 498 499 1.712 0.8 13.696 37
I499 499 0 1.29868e-05
R554 499 500 1.632 0.8 13.056 37
I500 500 0 1.23684e-05
R555 500 1001 0.5 10 50 37
*seg: 6
* inter-segment connection
R556 510 610 6.16 0.8 49.28 37
R557 520 620 6.16 0.8 49.28 37
R558 530 630 6.16 0.8 49.28 37
R559 540 640 6.16 0.8 49.28 37
R560 550 650 6.16 0.8 49.28 37
R561 560 660 6.16 0.8 49.28 37
R562 570 670 6.16 0.8 49.28 37
R563 580 680 6.16 0.8 49.28 37
R564 590 690 6.16 0.8 49.28 37
R565 600 700 6.16 0.8 49.28 37
R566 1001 501 0.4 20 80 37
I501 501 0 1.28631e-05
R567 501 502 1.68 0.8 13.44 37
I502 502 0 1.23684e-05
R568 502 503 1.68 0.8 13.44 37
I503 503 0 1.32342e-05
R569 503 504 1.648 0.8 13.184 37
I504 504 0 1.26158e-05
R570 504 505 1.712 0.8 13.696 37
I505 505 0 1.26158e-05
R571 505 506 1.616 0.8 12.928 37
I506 506 0 1.27395e-05
R572 506 507 1.664 0.8 13.312 37
I507 507 0 1.34816e-05
R573 507 508 1.664 0.8 13.312 37
I508 508 0 1.24921e-05
R574 508 509 1.744 0.8 13.952 37
I509 509 0 1.29868e-05
R575 509 510 1.712 0.8 13.696 37
I510 510 0 1.28631e-05
R576 510 511 1.616 0.8 12.928 37
I511 511 0 1.26158e-05
R577 511 512 1.632 0.8 13.056 37
I512 512 0 1.24921e-05
R578 512 513 1.696 0.8 13.568 37
I513 513 0 1.26158e-05
R579 513 514 1.6 0.8 12.8 37
I514 514 0 1.26158e-05
R580 514 515 1.632 0.8 13.056 37
I515 515 0 1.34816e-05
R581 515 516 1.712 0.8 13.696 37
I516 516 0 1.28631e-05
R582 516 517 1.648 0.8 13.184 37
I517 517 0 1.29868e-05
R583 517 518 1.696 0.8 13.568 37
I518 518 0 1.24921e-05
R584 518 519 1.664 0.8 13.312 37
I519 519 0 1.23684e-05
R585 519 520 1.648 0.8 13.184 37
I520 520 0 1.24921e-05
R586 520 521 1.632 0.8 13.056 37
I521 521 0 1.32342e-05
R587 521 522 1.712 0.8 13.696 37
I522 522 0 1.34816e-05
R588 522 523 1.728 0.8 13.824 37
I523 523 0 1.24921e-05
R589 523 524 1.6 0.8 12.8 37
I524 524 0 1.32342e-05
R590 524 525 1.696 0.8 13.568 37
I525 525 0 1.23684e-05
R591 525 526 1.616 0.8 12.928 37
I526 526 0 1.23684e-05
R592 526 527 1.632 0.8 13.056 37
I527 527 0 1.29868e-05
R593 527 528 1.616 0.8 12.928 37
I528 528 0 1.34816e-05
R594 528 529 1.712 0.8 13.696 37
I529 529 0 1.24921e-05
R595 529 530 1.648 0.8 13.184 37
I530 530 0 1.24921e-05
R596 530 531 1.632 0.8 13.056 37
I531 531 0 1.23684e-05
R597 531 532 1.696 0.8 13.568 37
I532 532 0 1.33579e-05
R598 532 533 1.712 0.8 13.696 37
I533 533 0 1.28631e-05
R599 533 534 1.744 0.8 13.952 37
I534 534 0 1.26158e-05
R600 534 535 1.664 0.8 13.312 37
I535 535 0 1.28631e-05
R601 535 536 1.68 0.8 13.44 37
I536 536 0 1.34816e-05
R602 536 537 1.616 0.8 12.928 37
I537 537 0 1.26158e-05
R603 537 538 1.728 0.8 13.824 37
I538 538 0 1.34816e-05
R604 538 539 1.696 0.8 13.568 37
I539 539 0 1.23684e-05
R605 539 540 1.696 0.8 13.568 37
I540 540 0 1.28631e-05
R606 540 541 1.6 0.8 12.8 37
I541 541 0 1.34816e-05
R607 541 542 1.664 0.8 13.312 37
I542 542 0 1.29868e-05
R608 542 543 1.664 0.8 13.312 37
I543 543 0 1.31105e-05
R609 543 544 1.696 0.8 13.568 37
I544 544 0 1.27395e-05
R610 544 545 1.744 0.8 13.952 37
I545 545 0 1.34816e-05
R611 545 546 1.68 0.8 13.44 37
I546 546 0 1.26158e-05
R612 546 547 1.616 0.8 12.928 37
I547 547 0 1.27395e-05
R613 547 548 1.6 0.8 12.8 37
I548 548 0 1.34816e-05
R614 548 549 1.744 0.8 13.952 37
I549 549 0 1.24921e-05
R615 549 550 1.648 0.8 13.184 37
I550 550 0 1.28631e-05
R616 550 551 1.68 0.8 13.44 37
I551 551 0 1.33579e-05
R617 551 552 1.68 0.8 13.44 37
I552 552 0 1.32342e-05
R618 552 553 1.648 0.8 13.184 37
I553 553 0 1.27395e-05
R619 553 554 1.728 0.8 13.824 37
I554 554 0 1.34816e-05
R620 554 555 1.68 0.8 13.44 37
I555 555 0 1.29868e-05
R621 555 556 1.648 0.8 13.184 37
I556 556 0 1.33579e-05
R622 556 557 1.696 0.8 13.568 37
I557 557 0 1.23684e-05
R623 557 558 1.648 0.8 13.184 37
I558 558 0 1.27395e-05
R624 558 559 1.696 0.8 13.568 37
I559 559 0 1.24921e-05
R625 559 560 1.728 0.8 13.824 37
I560 560 0 1.32342e-05
R626 560 561 1.6 0.8 12.8 37
I561 561 0 1.29868e-05
R627 561 562 1.616 0.8 12.928 37
I562 562 0 1.24921e-05
R628 562 563 1.6 0.8 12.8 37
I563 563 0 1.27395e-05
R629 563 564 1.6 0.8 12.8 37
I564 564 0 1.23684e-05
R630 564 565 1.664 0.8 13.312 37
I565 565 0 1.29868e-05
R631 565 566 1.664 0.8 13.312 37
I566 566 0 1.26158e-05
R632 566 567 1.664 0.8 13.312 37
I567 567 0 1.34816e-05
R633 567 568 1.744 0.8 13.952 37
I568 568 0 1.34816e-05
R634 568 569 1.664 0.8 13.312 37
I569 569 0 1.34816e-05
R635 569 570 1.728 0.8 13.824 37
I570 570 0 1.24921e-05
R636 570 571 1.696 0.8 13.568 37
I571 571 0 1.27395e-05
R637 571 572 1.744 0.8 13.952 37
I572 572 0 1.27395e-05
R638 572 573 1.648 0.8 13.184 37
I573 573 0 1.28631e-05
R639 573 574 1.696 0.8 13.568 37
I574 574 0 1.24921e-05
R640 574 575 1.68 0.8 13.44 37
I575 575 0 1.31105e-05
R641 575 576 1.616 0.8 12.928 37
I576 576 0 1.32342e-05
R642 576 577 1.632 0.8 13.056 37
I577 577 0 1.26158e-05
R643 577 578 1.744 0.8 13.952 37
I578 578 0 1.26158e-05
R644 578 579 1.728 0.8 13.824 37
I579 579 0 1.24921e-05
R645 579 580 1.632 0.8 13.056 37
I580 580 0 1.28631e-05
R646 580 581 1.712 0.8 13.696 37
I581 581 0 1.33579e-05
R647 581 582 1.696 0.8 13.568 37
I582 582 0 1.27395e-05
R648 582 583 1.712 0.8 13.696 37
I583 583 0 1.32342e-05
R649 583 584 1.632 0.8 13.056 37
I584 584 0 1.27395e-05
R650 584 585 1.712 0.8 13.696 37
I585 585 0 1.26158e-05
R651 585 586 1.68 0.8 13.44 37
I586 586 0 1.27395e-05
R652 586 587 1.712 0.8 13.696 37
I587 587 0 1.31105e-05
R653 587 588 1.728 0.8 13.824 37
I588 588 0 1.24921e-05
R654 588 589 1.648 0.8 13.184 37
I589 589 0 1.31105e-05
R655 589 590 1.664 0.8 13.312 37
I590 590 0 1.23684e-05
R656 590 591 1.648 0.8 13.184 37
I591 591 0 1.29868e-05
R657 591 592 1.728 0.8 13.824 37
I592 592 0 1.29868e-05
R658 592 593 1.6 0.8 12.8 37
I593 593 0 1.34816e-05
R659 593 594 1.744 0.8 13.952 37
I594 594 0 1.33579e-05
R660 594 595 1.6 0.8 12.8 37
I595 595 0 1.26158e-05
R661 595 596 1.664 0.8 13.312 37
I596 596 0 1.34816e-05
R662 596 597 1.6 0.8 12.8 37
I597 597 0 1.24921e-05
R663 597 598 1.632 0.8 13.056 37
I598 598 0 1.23684e-05
R664 598 599 1.6 0.8 12.8 37
I599 599 0 1.31105e-05
R665 599 600 1.648 0.8 13.184 37
I600 600 0 1.23684e-05
R666 600 1001 0.5 10 50 37
*seg: 7
* inter-segment connection
R667 610 710 6.16 0.8 49.28 37
R668 620 720 6.16 0.8 49.28 37
R669 630 730 6.16 0.8 49.28 37
R670 640 740 6.16 0.8 49.28 37
R671 650 750 6.16 0.8 49.28 37
R672 660 760 6.16 0.8 49.28 37
R673 670 770 6.16 0.8 49.28 37
R674 680 780 6.16 0.8 49.28 37
R675 690 790 6.16 0.8 49.28 37
R676 700 800 6.16 0.8 49.28 37
R677 1001 601 0.4 20 80 37
I601 601 0 1.34816e-05
R678 601 602 1.6 0.8 12.8 37
I602 602 0 1.33579e-05
R679 602 603 1.648 0.8 13.184 37
I603 603 0 1.33579e-05
R680 603 604 1.712 0.8 13.696 37
I604 604 0 1.27395e-05
R681 604 605 1.616 0.8 12.928 37
I605 605 0 1.23684e-05
R682 605 606 1.6 0.8 12.8 37
I606 606 0 1.29868e-05
R683 606 607 1.6 0.8 12.8 37
I607 607 0 1.27395e-05
R684 607 608 1.616 0.8 12.928 37
I608 608 0 1.33579e-05
R685 608 609 1.6 0.8 12.8 37
I609 609 0 1.24921e-05
R686 609 610 1.712 0.8 13.696 37
I610 610 0 1.34816e-05
R687 610 611 1.616 0.8 12.928 37
I611 611 0 1.23684e-05
R688 611 612 1.648 0.8 13.184 37
I612 612 0 1.29868e-05
R689 612 613 1.744 0.8 13.952 37
I613 613 0 1.28631e-05
R690 613 614 1.728 0.8 13.824 37
I614 614 0 1.28631e-05
R691 614 615 1.696 0.8 13.568 37
I615 615 0 1.34816e-05
R692 615 616 1.632 0.8 13.056 37
I616 616 0 1.34816e-05
R693 616 617 1.6 0.8 12.8 37
I617 617 0 1.27395e-05
R694 617 618 1.6 0.8 12.8 37
I618 618 0 1.27395e-05
R695 618 619 1.648 0.8 13.184 37
I619 619 0 1.32342e-05
R696 619 620 1.744 0.8 13.952 37
I620 620 0 1.28631e-05
R697 620 621 1.744 0.8 13.952 37
I621 621 0 1.34816e-05
R698 621 622 1.616 0.8 12.928 37
I622 622 0 1.34816e-05
R699 622 623 1.664 0.8 13.312 37
I623 623 0 1.26158e-05
R700 623 624 1.6 0.8 12.8 37
I624 624 0 1.31105e-05
R701 624 625 1.68 0.8 13.44 37
I625 625 0 1.34816e-05
R702 625 626 1.68 0.8 13.44 37
I626 626 0 1.31105e-05
R703 626 627 1.616 0.8 12.928 37
I627 627 0 1.24921e-05
R704 627 628 1.664 0.8 13.312 37
I628 628 0 1.27395e-05
R705 628 629 1.712 0.8 13.696 37
I629 629 0 1.26158e-05
R706 629 630 1.712 0.8 13.696 37
I630 630 0 1.27395e-05
R707 630 631 1.648 0.8 13.184 37
I631 631 0 1.34816e-05
R708 631 632 1.632 0.8 13.056 37
I632 632 0 1.28631e-05
R709 632 633 1.664 0.8 13.312 37
I633 633 0 1.28631e-05
R710 633 634 1.744 0.8 13.952 37
I634 634 0 1.34816e-05
R711 634 635 1.648 0.8 13.184 37
I635 635 0 1.33579e-05
R712 635 636 1.648 0.8 13.184 37
I636 636 0 1.26158e-05
R713 636 637 1.744 0.8 13.952 37
I637 637 0 1.29868e-05
R714 637 638 1.664 0.8 13.312 37
I638 638 0 1.27395e-05
R715 638 639 1.744 0.8 13.952 37
I639 639 0 1.28631e-05
R716 639 640 1.744 0.8 13.952 37
I640 640 0 1.29868e-05
R717 640 641 1.68 0.8 13.44 37
I641 641 0 1.32342e-05
R718 641 642 1.648 0.8 13.184 37
I642 642 0 1.34816e-05
R719 642 643 1.6 0.8 12.8 37
I643 643 0 1.32342e-05
R720 643 644 1.632 0.8 13.056 37
I644 644 0 1.32342e-05
R721 644 645 1.632 0.8 13.056 37
I645 645 0 1.34816e-05
R722 645 646 1.6 0.8 12.8 37
I646 646 0 1.29868e-05
R723 646 647 1.6 0.8 12.8 37
I647 647 0 1.28631e-05
R724 647 648 1.616 0.8 12.928 37
I648 648 0 1.32342e-05
R725 648 649 1.744 0.8 13.952 37
I649 649 0 1.27395e-05
R726 649 650 1.696 0.8 13.568 37
I650 650 0 1.26158e-05
R727 650 651 1.616 0.8 12.928 37
I651 651 0 1.26158e-05
R728 651 652 1.68 0.8 13.44 37
I652 652 0 1.27395e-05
R729 652 653 1.744 0.8 13.952 37
I653 653 0 1.24921e-05
R730 653 654 1.728 0.8 13.824 37
I654 654 0 1.33579e-05
R731 654 655 1.712 0.8 13.696 37
I655 655 0 1.23684e-05
R732 655 656 1.68 0.8 13.44 37
I656 656 0 1.26158e-05
R733 656 657 1.712 0.8 13.696 37
I657 657 0 1.34816e-05
R734 657 658 1.616 0.8 12.928 37
I658 658 0 1.34816e-05
R735 658 659 1.696 0.8 13.568 37
I659 659 0 1.27395e-05
R736 659 660 1.696 0.8 13.568 37
I660 660 0 1.33579e-05
R737 660 661 1.664 0.8 13.312 37
I661 661 0 1.31105e-05
R738 661 662 1.696 0.8 13.568 37
I662 662 0 1.32342e-05
R739 662 663 1.632 0.8 13.056 37
I663 663 0 1.32342e-05
R740 663 664 1.664 0.8 13.312 37
I664 664 0 1.24921e-05
R741 664 665 1.6 0.8 12.8 37
I665 665 0 1.23684e-05
R742 665 666 1.696 0.8 13.568 37
I666 666 0 1.28631e-05
R743 666 667 1.664 0.8 13.312 37
I667 667 0 1.27395e-05
R744 667 668 1.712 0.8 13.696 37
I668 668 0 1.27395e-05
R745 668 669 1.664 0.8 13.312 37
I669 669 0 1.32342e-05
R746 669 670 1.632 0.8 13.056 37
I670 670 0 1.24921e-05
R747 670 671 1.712 0.8 13.696 37
I671 671 0 1.34816e-05
R748 671 672 1.68 0.8 13.44 37
I672 672 0 1.31105e-05
R749 672 673 1.728 0.8 13.824 37
I673 673 0 1.34816e-05
R750 673 674 1.68 0.8 13.44 37
I674 674 0 1.29868e-05
R751 674 675 1.632 0.8 13.056 37
I675 675 0 1.24921e-05
R752 675 676 1.68 0.8 13.44 37
I676 676 0 1.34816e-05
R753 676 677 1.744 0.8 13.952 37
I677 677 0 1.24921e-05
R754 677 678 1.696 0.8 13.568 37
I678 678 0 1.26158e-05
R755 678 679 1.616 0.8 12.928 37
I679 679 0 1.23684e-05
R756 679 680 1.68 0.8 13.44 37
I680 680 0 1.27395e-05
R757 680 681 1.632 0.8 13.056 37
I681 681 0 1.24921e-05
R758 681 682 1.744 0.8 13.952 37
I682 682 0 1.32342e-05
R759 682 683 1.696 0.8 13.568 37
I683 683 0 1.33579e-05
R760 683 684 1.632 0.8 13.056 37
I684 684 0 1.23684e-05
R761 684 685 1.696 0.8 13.568 37
I685 685 0 1.28631e-05
R762 685 686 1.648 0.8 13.184 37
I686 686 0 1.27395e-05
R763 686 687 1.696 0.8 13.568 37
I687 687 0 1.34816e-05
R764 687 688 1.6 0.8 12.8 37
I688 688 0 1.28631e-05
R765 688 689 1.728 0.8 13.824 37
I689 689 0 1.29868e-05
R766 689 690 1.616 0.8 12.928 37
I690 690 0 1.26158e-05
R767 690 691 1.744 0.8 13.952 37
I691 691 0 1.32342e-05
R768 691 692 1.648 0.8 13.184 37
I692 692 0 1.33579e-05
R769 692 693 1.6 0.8 12.8 37
I693 693 0 1.34816e-05
R770 693 694 1.632 0.8 13.056 37
I694 694 0 1.27395e-05
R771 694 695 1.616 0.8 12.928 37
I695 695 0 1.33579e-05
R772 695 696 1.712 0.8 13.696 37
I696 696 0 1.28631e-05
R773 696 697 1.616 0.8 12.928 37
I697 697 0 1.31105e-05
R774 697 698 1.648 0.8 13.184 37
I698 698 0 1.33579e-05
R775 698 699 1.68 0.8 13.44 37
I699 699 0 1.29868e-05
R776 699 700 1.6 0.8 12.8 37
I700 700 0 1.23684e-05
R777 700 1001 0.5 10 50 37
*seg: 8
* inter-segment connection
R778 710 810 6.16 0.8 49.28 37
R779 720 820 6.16 0.8 49.28 37
R780 730 830 6.16 0.8 49.28 37
R781 740 840 6.16 0.8 49.28 37
R782 750 850 6.16 0.8 49.28 37
R783 760 860 6.16 0.8 49.28 37
R784 770 870 6.16 0.8 49.28 37
R785 780 880 6.16 0.8 49.28 37
R786 790 890 6.16 0.8 49.28 37
R787 800 900 6.16 0.8 49.28 37
R788 1001 701 0.4 20 80 37
I701 701 0 1.24921e-05
R789 701 702 1.632 0.8 13.056 37
I702 702 0 1.31105e-05
R790 702 703 1.664 0.8 13.312 37
I703 703 0 1.33579e-05
R791 703 704 1.68 0.8 13.44 37
I704 704 0 1.31105e-05
R792 704 705 1.632 0.8 13.056 37
I705 705 0 1.29868e-05
R793 705 706 1.632 0.8 13.056 37
I706 706 0 1.31105e-05
R794 706 707 1.744 0.8 13.952 37
I707 707 0 1.24921e-05
R795 707 708 1.648 0.8 13.184 37
I708 708 0 1.27395e-05
R796 708 709 1.616 0.8 12.928 37
I709 709 0 1.29868e-05
R797 709 710 1.632 0.8 13.056 37
I710 710 0 1.31105e-05
R798 710 711 1.744 0.8 13.952 37
I711 711 0 1.28631e-05
R799 711 712 1.664 0.8 13.312 37
I712 712 0 1.31105e-05
R800 712 713 1.6 0.8 12.8 37
I713 713 0 1.32342e-05
R801 713 714 1.664 0.8 13.312 37
I714 714 0 1.27395e-05
R802 714 715 1.712 0.8 13.696 37
I715 715 0 1.34816e-05
R803 715 716 1.6 0.8 12.8 37
I716 716 0 1.23684e-05
R804 716 717 1.632 0.8 13.056 37
I717 717 0 1.26158e-05
R805 717 718 1.696 0.8 13.568 37
I718 718 0 1.34816e-05
R806 718 719 1.6 0.8 12.8 37
I719 719 0 1.27395e-05
R807 719 720 1.68 0.8 13.44 37
I720 720 0 1.29868e-05
R808 720 721 1.728 0.8 13.824 37
I721 721 0 1.32342e-05
R809 721 722 1.616 0.8 12.928 37
I722 722 0 1.32342e-05
R810 722 723 1.6 0.8 12.8 37
I723 723 0 1.31105e-05
R811 723 724 1.6 0.8 12.8 37
I724 724 0 1.28631e-05
R812 724 725 1.616 0.8 12.928 37
I725 725 0 1.27395e-05
R813 725 726 1.6 0.8 12.8 37
I726 726 0 1.26158e-05
R814 726 727 1.744 0.8 13.952 37
I727 727 0 1.31105e-05
R815 727 728 1.6 0.8 12.8 37
I728 728 0 1.34816e-05
R816 728 729 1.648 0.8 13.184 37
I729 729 0 1.29868e-05
R817 729 730 1.664 0.8 13.312 37
I730 730 0 1.27395e-05
R818 730 731 1.696 0.8 13.568 37
I731 731 0 1.28631e-05
R819 731 732 1.648 0.8 13.184 37
I732 732 0 1.24921e-05
R820 732 733 1.744 0.8 13.952 37
I733 733 0 1.24921e-05
R821 733 734 1.6 0.8 12.8 37
I734 734 0 1.34816e-05
R822 734 735 1.664 0.8 13.312 37
I735 735 0 1.29868e-05
R823 735 736 1.696 0.8 13.568 37
I736 736 0 1.26158e-05
R824 736 737 1.68 0.8 13.44 37
I737 737 0 1.34816e-05
R825 737 738 1.616 0.8 12.928 37
I738 738 0 1.32342e-05
R826 738 739 1.712 0.8 13.696 37
I739 739 0 1.28631e-05
R827 739 740 1.616 0.8 12.928 37
I740 740 0 1.24921e-05
R828 740 741 1.744 0.8 13.952 37
I741 741 0 1.24921e-05
R829 741 742 1.648 0.8 13.184 37
I742 742 0 1.33579e-05
R830 742 743 1.712 0.8 13.696 37
I743 743 0 1.28631e-05
R831 743 744 1.744 0.8 13.952 37
I744 744 0 1.27395e-05
R832 744 745 1.616 0.8 12.928 37
I745 745 0 1.27395e-05
R833 745 746 1.728 0.8 13.824 37
I746 746 0 1.32342e-05
R834 746 747 1.744 0.8 13.952 37
I747 747 0 1.27395e-05
R835 747 748 1.728 0.8 13.824 37
I748 748 0 1.33579e-05
R836 748 749 1.664 0.8 13.312 37
I749 749 0 1.23684e-05
R837 749 750 1.6 0.8 12.8 37
I750 750 0 1.33579e-05
R838 750 751 1.696 0.8 13.568 37
I751 751 0 1.33579e-05
R839 751 752 1.632 0.8 13.056 37
I752 752 0 1.27395e-05
R840 752 753 1.728 0.8 13.824 37
I753 753 0 1.29868e-05
R841 753 754 1.6 0.8 12.8 37
I754 754 0 1.29868e-05
R842 754 755 1.744 0.8 13.952 37
I755 755 0 1.26158e-05
R843 755 756 1.696 0.8 13.568 37
I756 756 0 1.33579e-05
R844 756 757 1.68 0.8 13.44 37
I757 757 0 1.26158e-05
R845 757 758 1.728 0.8 13.824 37
I758 758 0 1.27395e-05
R846 758 759 1.696 0.8 13.568 37
I759 759 0 1.32342e-05
R847 759 760 1.728 0.8 13.824 37
I760 760 0 1.32342e-05
R848 760 761 1.632 0.8 13.056 37
I761 761 0 1.31105e-05
R849 761 762 1.696 0.8 13.568 37
I762 762 0 1.26158e-05
R850 762 763 1.744 0.8 13.952 37
I763 763 0 1.32342e-05
R851 763 764 1.6 0.8 12.8 37
I764 764 0 1.27395e-05
R852 764 765 1.712 0.8 13.696 37
I765 765 0 1.26158e-05
R853 765 766 1.648 0.8 13.184 37
I766 766 0 1.29868e-05
R854 766 767 1.616 0.8 12.928 37
I767 767 0 1.32342e-05
R855 767 768 1.728 0.8 13.824 37
I768 768 0 1.34816e-05
R856 768 769 1.664 0.8 13.312 37
I769 769 0 1.24921e-05
R857 769 770 1.696 0.8 13.568 37
I770 770 0 1.28631e-05
R858 770 771 1.648 0.8 13.184 37
I771 771 0 1.29868e-05
R859 771 772 1.664 0.8 13.312 37
I772 772 0 1.33579e-05
R860 772 773 1.712 0.8 13.696 37
I773 773 0 1.27395e-05
R861 773 774 1.648 0.8 13.184 37
I774 774 0 1.29868e-05
R862 774 775 1.6 0.8 12.8 37
I775 775 0 1.24921e-05
R863 775 776 1.664 0.8 13.312 37
I776 776 0 1.29868e-05
R864 776 777 1.712 0.8 13.696 37
I777 777 0 1.23684e-05
R865 777 778 1.712 0.8 13.696 37
I778 778 0 1.33579e-05
R866 778 779 1.744 0.8 13.952 37
I779 779 0 1.34816e-05
R867 779 780 1.648 0.8 13.184 37
I780 780 0 1.34816e-05
R868 780 781 1.664 0.8 13.312 37
I781 781 0 1.31105e-05
R869 781 782 1.664 0.8 13.312 37
I782 782 0 1.29868e-05
R870 782 783 1.68 0.8 13.44 37
I783 783 0 1.29868e-05
R871 783 784 1.696 0.8 13.568 37
I784 784 0 1.23684e-05
R872 784 785 1.696 0.8 13.568 37
I785 785 0 1.26158e-05
R873 785 786 1.696 0.8 13.568 37
I786 786 0 1.34816e-05
R874 786 787 1.744 0.8 13.952 37
I787 787 0 1.26158e-05
R875 787 788 1.744 0.8 13.952 37
I788 788 0 1.31105e-05
R876 788 789 1.68 0.8 13.44 37
I789 789 0 1.29868e-05
R877 789 790 1.648 0.8 13.184 37
I790 790 0 1.33579e-05
R878 790 791 1.696 0.8 13.568 37
I791 791 0 1.32342e-05
R879 791 792 1.648 0.8 13.184 37
I792 792 0 1.31105e-05
R880 792 793 1.6 0.8 12.8 37
I793 793 0 1.26158e-05
R881 793 794 1.696 0.8 13.568 37
I794 794 0 1.34816e-05
R882 794 795 1.648 0.8 13.184 37
I795 795 0 1.23684e-05
R883 795 796 1.728 0.8 13.824 37
I796 796 0 1.32342e-05
R884 796 797 1.696 0.8 13.568 37
I797 797 0 1.29868e-05
R885 797 798 1.632 0.8 13.056 37
I798 798 0 1.28631e-05
R886 798 799 1.6 0.8 12.8 37
I799 799 0 1.23684e-05
R887 799 800 1.696 0.8 13.568 37
I800 800 0 1.23684e-05
R888 800 1001 0.5 10 50 37
*seg: 9
* inter-segment connection
R889 810 910 6.16 0.8 49.28 37
R890 820 920 6.16 0.8 49.28 37
R891 830 930 6.16 0.8 49.28 37
R892 840 940 6.16 0.8 49.28 37
R893 850 950 6.16 0.8 49.28 37
R894 860 960 6.16 0.8 49.28 37
R895 870 970 6.16 0.8 49.28 37
R896 880 980 6.16 0.8 49.28 37
R897 890 990 6.16 0.8 49.28 37
R898 900 1000 6.16 0.8 49.28 37
R899 1001 801 0.4 20 80 37
I801 801 0 1.33579e-05
R900 801 802 1.68 0.8 13.44 37
I802 802 0 1.28631e-05
R901 802 803 1.744 0.8 13.952 37
I803 803 0 1.28631e-05
R902 803 804 1.696 0.8 13.568 37
I804 804 0 1.33579e-05
R903 804 805 1.648 0.8 13.184 37
I805 805 0 1.26158e-05
R904 805 806 1.648 0.8 13.184 37
I806 806 0 1.31105e-05
R905 806 807 1.632 0.8 13.056 37
I807 807 0 1.26158e-05
R906 807 808 1.664 0.8 13.312 37
I808 808 0 1.32342e-05
R907 808 809 1.6 0.8 12.8 37
I809 809 0 1.28631e-05
R908 809 810 1.744 0.8 13.952 37
I810 810 0 1.31105e-05
R909 810 811 1.68 0.8 13.44 37
I811 811 0 1.28631e-05
R910 811 812 1.696 0.8 13.568 37
I812 812 0 1.28631e-05
R911 812 813 1.632 0.8 13.056 37
I813 813 0 1.29868e-05
R912 813 814 1.616 0.8 12.928 37
I814 814 0 1.31105e-05
R913 814 815 1.616 0.8 12.928 37
I815 815 0 1.27395e-05
R914 815 816 1.712 0.8 13.696 37
I816 816 0 1.32342e-05
R915 816 817 1.616 0.8 12.928 37
I817 817 0 1.26158e-05
R916 817 818 1.616 0.8 12.928 37
I818 818 0 1.23684e-05
R917 818 819 1.728 0.8 13.824 37
I819 819 0 1.34816e-05
R918 819 820 1.6 0.8 12.8 37
I820 820 0 1.24921e-05
R919 820 821 1.648 0.8 13.184 37
I821 821 0 1.28631e-05
R920 821 822 1.728 0.8 13.824 37
I822 822 0 1.29868e-05
R921 822 823 1.728 0.8 13.824 37
I823 823 0 1.26158e-05
R922 823 824 1.632 0.8 13.056 37
I824 824 0 1.23684e-05
R923 824 825 1.696 0.8 13.568 37
I825 825 0 1.27395e-05
R924 825 826 1.696 0.8 13.568 37
I826 826 0 1.24921e-05
R925 826 827 1.6 0.8 12.8 37
I827 827 0 1.29868e-05
R926 827 828 1.712 0.8 13.696 37
I828 828 0 1.28631e-05
R927 828 829 1.632 0.8 13.056 37
I829 829 0 1.23684e-05
R928 829 830 1.6 0.8 12.8 37
I830 830 0 1.27395e-05
R929 830 831 1.648 0.8 13.184 37
I831 831 0 1.34816e-05
R930 831 832 1.6 0.8 12.8 37
I832 832 0 1.28631e-05
R931 832 833 1.648 0.8 13.184 37
I833 833 0 1.27395e-05
R932 833 834 1.664 0.8 13.312 37
I834 834 0 1.26158e-05
R933 834 835 1.664 0.8 13.312 37
I835 835 0 1.29868e-05
R934 835 836 1.648 0.8 13.184 37
I836 836 0 1.33579e-05
R935 836 837 1.616 0.8 12.928 37
I837 837 0 1.24921e-05
R936 837 838 1.648 0.8 13.184 37
I838 838 0 1.24921e-05
R937 838 839 1.68 0.8 13.44 37
I839 839 0 1.33579e-05
R938 839 840 1.616 0.8 12.928 37
I840 840 0 1.27395e-05
R939 840 841 1.648 0.8 13.184 37
I841 841 0 1.34816e-05
R940 841 842 1.712 0.8 13.696 37
I842 842 0 1.29868e-05
R941 842 843 1.664 0.8 13.312 37
I843 843 0 1.28631e-05
R942 843 844 1.744 0.8 13.952 37
I844 844 0 1.31105e-05
R943 844 845 1.712 0.8 13.696 37
I845 845 0 1.26158e-05
R944 845 846 1.616 0.8 12.928 37
I846 846 0 1.23684e-05
R945 846 847 1.616 0.8 12.928 37
I847 847 0 1.27395e-05
R946 847 848 1.712 0.8 13.696 37
I848 848 0 1.32342e-05
R947 848 849 1.696 0.8 13.568 37
I849 849 0 1.27395e-05
R948 849 850 1.744 0.8 13.952 37
I850 850 0 1.24921e-05
R949 850 851 1.6 0.8 12.8 37
I851 851 0 1.28631e-05
R950 851 852 1.616 0.8 12.928 37
I852 852 0 1.24921e-05
R951 852 853 1.728 0.8 13.824 37
I853 853 0 1.31105e-05
R952 853 854 1.664 0.8 13.312 37
I854 854 0 1.27395e-05
R953 854 855 1.664 0.8 13.312 37
I855 855 0 1.32342e-05
R954 855 856 1.712 0.8 13.696 37
I856 856 0 1.23684e-05
R955 856 857 1.712 0.8 13.696 37
I857 857 0 1.28631e-05
R956 857 858 1.68 0.8 13.44 37
I858 858 0 1.27395e-05
R957 858 859 1.6 0.8 12.8 37
I859 859 0 1.32342e-05
R958 859 860 1.632 0.8 13.056 37
I860 860 0 1.34816e-05
R959 860 861 1.744 0.8 13.952 37
I861 861 0 1.27395e-05
R960 861 862 1.6 0.8 12.8 37
I862 862 0 1.26158e-05
R961 862 863 1.712 0.8 13.696 37
I863 863 0 1.34816e-05
R962 863 864 1.744 0.8 13.952 37
I864 864 0 1.29868e-05
R963 864 865 1.632 0.8 13.056 37
I865 865 0 1.23684e-05
R964 865 866 1.728 0.8 13.824 37
I866 866 0 1.27395e-05
R965 866 867 1.68 0.8 13.44 37
I867 867 0 1.34816e-05
R966 867 868 1.696 0.8 13.568 37
I868 868 0 1.29868e-05
R967 868 869 1.696 0.8 13.568 37
I869 869 0 1.27395e-05
R968 869 870 1.6 0.8 12.8 37
I870 870 0 1.26158e-05
R969 870 871 1.6 0.8 12.8 37
I871 871 0 1.32342e-05
R970 871 872 1.664 0.8 13.312 37
I872 872 0 1.32342e-05
R971 872 873 1.648 0.8 13.184 37
I873 873 0 1.23684e-05
R972 873 874 1.616 0.8 12.928 37
I874 874 0 1.31105e-05
R973 874 875 1.712 0.8 13.696 37
I875 875 0 1.29868e-05
R974 875 876 1.712 0.8 13.696 37
I876 876 0 1.33579e-05
R975 876 877 1.728 0.8 13.824 37
I877 877 0 1.34816e-05
R976 877 878 1.6 0.8 12.8 37
I878 878 0 1.32342e-05
R977 878 879 1.728 0.8 13.824 37
I879 879 0 1.23684e-05
R978 879 880 1.648 0.8 13.184 37
I880 880 0 1.24921e-05
R979 880 881 1.6 0.8 12.8 37
I881 881 0 1.27395e-05
R980 881 882 1.696 0.8 13.568 37
I882 882 0 1.32342e-05
R981 882 883 1.648 0.8 13.184 37
I883 883 0 1.26158e-05
R982 883 884 1.632 0.8 13.056 37
I884 884 0 1.24921e-05
R983 884 885 1.68 0.8 13.44 37
I885 885 0 1.27395e-05
R984 885 886 1.648 0.8 13.184 37
I886 886 0 1.33579e-05
R985 886 887 1.632 0.8 13.056 37
I887 887 0 1.33579e-05
R986 887 888 1.68 0.8 13.44 37
I888 888 0 1.33579e-05
R987 888 889 1.6 0.8 12.8 37
I889 889 0 1.33579e-05
R988 889 890 1.696 0.8 13.568 37
I890 890 0 1.34816e-05
R989 890 891 1.648 0.8 13.184 37
I891 891 0 1.27395e-05
R990 891 892 1.712 0.8 13.696 37
I892 892 0 1.28631e-05
R991 892 893 1.648 0.8 13.184 37
I893 893 0 1.32342e-05
R992 893 894 1.616 0.8 12.928 37
I894 894 0 1.27395e-05
R993 894 895 1.744 0.8 13.952 37
I895 895 0 1.31105e-05
R994 895 896 1.664 0.8 13.312 37
I896 896 0 1.26158e-05
R995 896 897 1.6 0.8 12.8 37
I897 897 0 1.26158e-05
R996 897 898 1.744 0.8 13.952 37
I898 898 0 1.29868e-05
R997 898 899 1.712 0.8 13.696 37
I899 899 0 1.28631e-05
R998 899 900 1.696 0.8 13.568 37
I900 900 0 1.23684e-05
R999 900 1001 0.5 10 50 37
*seg: 10
R1000 1001 901 0.4 20 80 37
I901 901 0 1.28631e-05
R1001 901 902 1.744 0.8 13.952 37
I902 902 0 1.24921e-05
R1002 902 903 1.632 0.8 13.056 37
I903 903 0 1.27395e-05
R1003 903 904 1.616 0.8 12.928 37
I904 904 0 1.33579e-05
R1004 904 905 1.616 0.8 12.928 37
I905 905 0 1.27395e-05
R1005 905 906 1.728 0.8 13.824 37
I906 906 0 1.34816e-05
R1006 906 907 1.632 0.8 13.056 37
I907 907 0 1.28631e-05
R1007 907 908 1.68 0.8 13.44 37
I908 908 0 1.24921e-05
R1008 908 909 1.6 0.8 12.8 37
I909 909 0 1.23684e-05
R1009 909 910 1.616 0.8 12.928 37
I910 910 0 1.27395e-05
R1010 910 911 1.648 0.8 13.184 37
I911 911 0 1.23684e-05
R1011 911 912 1.6 0.8 12.8 37
I912 912 0 1.23684e-05
R1012 912 913 1.632 0.8 13.056 37
I913 913 0 1.26158e-05
R1013 913 914 1.632 0.8 13.056 37
I914 914 0 1.28631e-05
R1014 914 915 1.712 0.8 13.696 37
I915 915 0 1.34816e-05
R1015 915 916 1.728 0.8 13.824 37
I916 916 0 1.29868e-05
R1016 916 917 1.664 0.8 13.312 37
I917 917 0 1.32342e-05
R1017 917 918 1.728 0.8 13.824 37
I918 918 0 1.31105e-05
R1018 918 919 1.6 0.8 12.8 37
I919 919 0 1.23684e-05
R1019 919 920 1.696 0.8 13.568 37
I920 920 0 1.28631e-05
R1020 920 921 1.648 0.8 13.184 37
I921 921 0 1.32342e-05
R1021 921 922 1.68 0.8 13.44 37
I922 922 0 1.33579e-05
R1022 922 923 1.616 0.8 12.928 37
I923 923 0 1.23684e-05
R1023 923 924 1.744 0.8 13.952 37
I924 924 0 1.27395e-05
R1024 924 925 1.6 0.8 12.8 37
I925 925 0 1.26158e-05
R1025 925 926 1.696 0.8 13.568 37
I926 926 0 1.28631e-05
R1026 926 927 1.648 0.8 13.184 37
I927 927 0 1.33579e-05
R1027 927 928 1.696 0.8 13.568 37
I928 928 0 1.32342e-05
R1028 928 929 1.6 0.8 12.8 37
I929 929 0 1.33579e-05
R1029 929 930 1.616 0.8 12.928 37
I930 930 0 1.34816e-05
R1030 930 931 1.728 0.8 13.824 37
I931 931 0 1.24921e-05
R1031 931 932 1.696 0.8 13.568 37
I932 932 0 1.28631e-05
R1032 932 933 1.728 0.8 13.824 37
I933 933 0 1.29868e-05
R1033 933 934 1.6 0.8 12.8 37
I934 934 0 1.24921e-05
R1034 934 935 1.68 0.8 13.44 37
I935 935 0 1.34816e-05
R1035 935 936 1.712 0.8 13.696 37
I936 936 0 1.23684e-05
R1036 936 937 1.696 0.8 13.568 37
I937 937 0 1.26158e-05
R1037 937 938 1.728 0.8 13.824 37
I938 938 0 1.34816e-05
R1038 938 939 1.68 0.8 13.44 37
I939 939 0 1.23684e-05
R1039 939 940 1.632 0.8 13.056 37
I940 940 0 1.32342e-05
R1040 940 941 1.632 0.8 13.056 37
I941 941 0 1.33579e-05
R1041 941 942 1.616 0.8 12.928 37
I942 942 0 1.32342e-05
R1042 942 943 1.712 0.8 13.696 37
I943 943 0 1.34816e-05
R1043 943 944 1.712 0.8 13.696 37
I944 944 0 1.34816e-05
R1044 944 945 1.728 0.8 13.824 37
I945 945 0 1.33579e-05
R1045 945 946 1.744 0.8 13.952 37
I946 946 0 1.33579e-05
R1046 946 947 1.6 0.8 12.8 37
I947 947 0 1.29868e-05
R1047 947 948 1.632 0.8 13.056 37
I948 948 0 1.23684e-05
R1048 948 949 1.632 0.8 13.056 37
I949 949 0 1.28631e-05
R1049 949 950 1.648 0.8 13.184 37
I950 950 0 1.32342e-05
R1050 950 951 1.648 0.8 13.184 37
I951 951 0 1.23684e-05
R1051 951 952 1.6 0.8 12.8 37
I952 952 0 1.24921e-05
R1052 952 953 1.68 0.8 13.44 37
I953 953 0 1.33579e-05
R1053 953 954 1.6 0.8 12.8 37
I954 954 0 1.23684e-05
R1054 954 955 1.6 0.8 12.8 37
I955 955 0 1.28631e-05
R1055 955 956 1.712 0.8 13.696 37
I956 956 0 1.29868e-05
R1056 956 957 1.648 0.8 13.184 37
I957 957 0 1.24921e-05
R1057 957 958 1.664 0.8 13.312 37
I958 958 0 1.26158e-05
R1058 958 959 1.6 0.8 12.8 37
I959 959 0 1.24921e-05
R1059 959 960 1.648 0.8 13.184 37
I960 960 0 1.23684e-05
R1060 960 961 1.6 0.8 12.8 37
I961 961 0 1.28631e-05
R1061 961 962 1.728 0.8 13.824 37
I962 962 0 1.26158e-05
R1062 962 963 1.632 0.8 13.056 37
I963 963 0 1.23684e-05
R1063 963 964 1.632 0.8 13.056 37
I964 964 0 1.28631e-05
R1064 964 965 1.68 0.8 13.44 37
I965 965 0 1.33579e-05
R1065 965 966 1.664 0.8 13.312 37
I966 966 0 1.23684e-05
R1066 966 967 1.728 0.8 13.824 37
I967 967 0 1.28631e-05
R1067 967 968 1.632 0.8 13.056 37
I968 968 0 1.29868e-05
R1068 968 969 1.664 0.8 13.312 37
I969 969 0 1.26158e-05
R1069 969 970 1.712 0.8 13.696 37
I970 970 0 1.29868e-05
R1070 970 971 1.712 0.8 13.696 37
I971 971 0 1.29868e-05
R1071 971 972 1.632 0.8 13.056 37
I972 972 0 1.26158e-05
R1072 972 973 1.728 0.8 13.824 37
I973 973 0 1.31105e-05
R1073 973 974 1.696 0.8 13.568 37
I974 974 0 1.23684e-05
R1074 974 975 1.6 0.8 12.8 37
I975 975 0 1.34816e-05
R1075 975 976 1.616 0.8 12.928 37
I976 976 0 1.26158e-05
R1076 976 977 1.696 0.8 13.568 37
I977 977 0 1.34816e-05
R1077 977 978 1.664 0.8 13.312 37
I978 978 0 1.33579e-05
R1078 978 979 1.632 0.8 13.056 37
I979 979 0 1.33579e-05
R1079 979 980 1.632 0.8 13.056 37
I980 980 0 1.32342e-05
R1080 980 981 1.728 0.8 13.824 37
I981 981 0 1.31105e-05
R1081 981 982 1.712 0.8 13.696 37
I982 982 0 1.32342e-05
R1082 982 983 1.6 0.8 12.8 37
I983 983 0 1.34816e-05
R1083 983 984 1.664 0.8 13.312 37
I984 984 0 1.29868e-05
R1084 984 985 1.664 0.8 13.312 37
I985 985 0 1.26158e-05
R1085 985 986 1.632 0.8 13.056 37
I986 986 0 1.27395e-05
R1086 986 987 1.744 0.8 13.952 37
I987 987 0 1.31105e-05
R1087 987 988 1.68 0.8 13.44 37
I988 988 0 1.32342e-05
R1088 988 989 1.664 0.8 13.312 37
I989 989 0 1.27395e-05
R1089 989 990 1.744 0.8 13.952 37
I990 990 0 1.28631e-05
R1090 990 991 1.664 0.8 13.312 37
I991 991 0 1.23684e-05
R1091 991 992 1.696 0.8 13.568 37
I992 992 0 1.23684e-05
R1092 992 993 1.632 0.8 13.056 37
I993 993 0 1.26158e-05
R1093 993 994 1.728 0.8 13.824 37
I994 994 0 1.28631e-05
R1094 994 995 1.648 0.8 13.184 37
I995 995 0 1.24921e-05
R1095 995 996 1.616 0.8 12.928 37
I996 996 0 1.24921e-05
R1096 996 997 1.744 0.8 13.952 37
I997 997 0 1.23684e-05
R1097 997 998 1.6 0.8 12.8 37
I998 998 0 1.23684e-05
R1098 998 999 1.632 0.8 13.056 37
I999 999 0 1.29868e-05
R1099 999 1000 1.712 0.8 13.696 37
I1000 1000 0 1.23684e-05
R1100 1000 1001 0.5 10 50 37
V1 1001 0 5

.op
.end
