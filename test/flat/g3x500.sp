num_node 1500
matrix_size 1500

* 3 x 500 ground network
*seg: 1
R1 0 1 0.4 20 80 37
R2 250 750 6.16 0.8 49.28 37
I1 0 1 1.33579e-02
R3 1 2 1.728 0.8 13.824 37
I2 0 2 1.27395e-02
R4 2 3 1.68 0.8 13.44 37
I3 0 3 1.24921e-02
R5 3 4 1.712 0.8 13.696 37
I4 0 4 1.23684e-02
R6 4 5 1.744 0.8 13.952 37
I5 0 5 1.26158e-02
R7 5 6 1.696 0.8 13.568 37
I6 0 6 1.34816e-02
R8 6 7 1.712 0.8 13.696 37
I7 0 7 1.28631e-02
R9 7 8 1.6 0.8 12.8 37
I8 0 8 1.29868e-02
R10 8 9 1.648 0.8 13.184 37
I9 0 9 1.34816e-02
R11 9 10 1.648 0.8 13.184 37
I10 0 10 1.32342e-02
R12 10 11 1.696 0.8 13.568 37
I11 0 11 1.31105e-02
R13 11 12 1.728 0.8 13.824 37
I12 0 12 1.29868e-02
R14 12 13 1.616 0.8 12.928 37
I13 0 13 1.32342e-02
R15 13 14 1.664 0.8 13.312 37
I14 0 14 1.24921e-02
R16 14 15 1.68 0.8 13.44 37
I15 0 15 1.26158e-02
R17 15 16 1.696 0.8 13.568 37
I16 0 16 1.28631e-02
R18 16 17 1.68 0.8 13.44 37
I17 0 17 1.28631e-02
R19 17 18 1.632 0.8 13.056 37
I18 0 18 1.24921e-02
R20 18 19 1.712 0.8 13.696 37
I19 0 19 1.28631e-02
R21 19 20 1.648 0.8 13.184 37
I20 0 20 1.24921e-02
R22 20 21 1.696 0.8 13.568 37
I21 0 21 1.33579e-02
R23 21 22 1.728 0.8 13.824 37
I22 0 22 1.29868e-02
R24 22 23 1.648 0.8 13.184 37
I23 0 23 1.32342e-02
R25 23 24 1.696 0.8 13.568 37
I24 0 24 1.29868e-02
R26 24 25 1.648 0.8 13.184 37
I25 0 25 1.26158e-02
R27 25 26 1.664 0.8 13.312 37
I26 0 26 1.27395e-02
R28 26 27 1.6 0.8 12.8 37
I27 0 27 1.28631e-02
R29 27 28 1.648 0.8 13.184 37
I28 0 28 1.26158e-02
R30 28 29 1.728 0.8 13.824 37
I29 0 29 1.26158e-02
R31 29 30 1.712 0.8 13.696 37
I30 0 30 1.32342e-02
R32 30 31 1.68 0.8 13.44 37
I31 0 31 1.34816e-02
R33 31 32 1.648 0.8 13.184 37
I32 0 32 1.24921e-02
R34 32 33 1.664 0.8 13.312 37
I33 0 33 1.23684e-02
R35 33 34 1.744 0.8 13.952 37
I34 0 34 1.33579e-02
R36 34 35 1.712 0.8 13.696 37
I35 0 35 1.34816e-02
R37 35 36 1.696 0.8 13.568 37
I36 0 36 1.31105e-02
R38 36 37 1.6 0.8 12.8 37
I37 0 37 1.33579e-02
R39 37 38 1.696 0.8 13.568 37
I38 0 38 1.28631e-02
R40 38 39 1.632 0.8 13.056 37
I39 0 39 1.31105e-02
R41 39 40 1.68 0.8 13.44 37
I40 0 40 1.24921e-02
R42 40 41 1.664 0.8 13.312 37
I41 0 41 1.27395e-02
R43 41 42 1.632 0.8 13.056 37
I42 0 42 1.27395e-02
R44 42 43 1.696 0.8 13.568 37
I43 0 43 1.23684e-02
R45 43 44 1.744 0.8 13.952 37
I44 0 44 1.24921e-02
R46 44 45 1.616 0.8 12.928 37
I45 0 45 1.31105e-02
R47 45 46 1.616 0.8 12.928 37
I46 0 46 1.23684e-02
R48 46 47 1.68 0.8 13.44 37
I47 0 47 1.34816e-02
R49 47 48 1.664 0.8 13.312 37
I48 0 48 1.29868e-02
R50 48 49 1.648 0.8 13.184 37
I49 0 49 1.28631e-02
R51 49 50 1.744 0.8 13.952 37
I50 0 50 1.33579e-02
R52 50 51 1.616 0.8 12.928 37
I51 0 51 1.26158e-02
R53 51 52 1.616 0.8 12.928 37
I52 0 52 1.28631e-02
R54 52 53 1.712 0.8 13.696 37
I53 0 53 1.26158e-02
R55 53 54 1.68 0.8 13.44 37
I54 0 54 1.31105e-02
R56 54 55 1.648 0.8 13.184 37
I55 0 55 1.31105e-02
R57 55 56 1.664 0.8 13.312 37
I56 0 56 1.24921e-02
R58 56 57 1.728 0.8 13.824 37
I57 0 57 1.27395e-02
R59 57 58 1.664 0.8 13.312 37
I58 0 58 1.27395e-02
R60 58 59 1.6 0.8 12.8 37
I59 0 59 1.33579e-02
R61 59 60 1.6 0.8 12.8 37
I60 0 60 1.23684e-02
R62 60 61 1.744 0.8 13.952 37
I61 0 61 1.31105e-02
R63 61 62 1.632 0.8 13.056 37
I62 0 62 1.31105e-02
R64 62 63 1.712 0.8 13.696 37
I63 0 63 1.27395e-02
R65 63 64 1.6 0.8 12.8 37
I64 0 64 1.24921e-02
R66 64 65 1.744 0.8 13.952 37
I65 0 65 1.31105e-02
R67 65 66 1.68 0.8 13.44 37
I66 0 66 1.29868e-02
R68 66 67 1.632 0.8 13.056 37
I67 0 67 1.23684e-02
R69 67 68 1.6 0.8 12.8 37
I68 0 68 1.26158e-02
R70 68 69 1.68 0.8 13.44 37
I69 0 69 1.23684e-02
R71 69 70 1.6 0.8 12.8 37
I70 0 70 1.34816e-02
R72 70 71 1.664 0.8 13.312 37
I71 0 71 1.29868e-02
R73 71 72 1.68 0.8 13.44 37
I72 0 72 1.29868e-02
R74 72 73 1.68 0.8 13.44 37
I73 0 73 1.28631e-02
R75 73 74 1.616 0.8 12.928 37
I74 0 74 1.31105e-02
R76 74 75 1.712 0.8 13.696 37
I75 0 75 1.27395e-02
R77 75 76 1.712 0.8 13.696 37
I76 0 76 1.34816e-02
R78 76 77 1.712 0.8 13.696 37
I77 0 77 1.27395e-02
R79 77 78 1.744 0.8 13.952 37
I78 0 78 1.29868e-02
R80 78 79 1.696 0.8 13.568 37
I79 0 79 1.27395e-02
R81 79 80 1.616 0.8 12.928 37
I80 0 80 1.27395e-02
R82 80 81 1.712 0.8 13.696 37
I81 0 81 1.34816e-02
R83 81 82 1.712 0.8 13.696 37
I82 0 82 1.27395e-02
R84 82 83 1.728 0.8 13.824 37
I83 0 83 1.31105e-02
R85 83 84 1.616 0.8 12.928 37
I84 0 84 1.31105e-02
R86 84 85 1.696 0.8 13.568 37
I85 0 85 1.31105e-02
R87 85 86 1.728 0.8 13.824 37
I86 0 86 1.33579e-02
R88 86 87 1.696 0.8 13.568 37
I87 0 87 1.27395e-02
R89 87 88 1.712 0.8 13.696 37
I88 0 88 1.24921e-02
R90 88 89 1.712 0.8 13.696 37
I89 0 89 1.26158e-02
R91 89 90 1.728 0.8 13.824 37
I90 0 90 1.24921e-02
R92 90 91 1.648 0.8 13.184 37
I91 0 91 1.26158e-02
R93 91 92 1.664 0.8 13.312 37
I92 0 92 1.33579e-02
R94 92 93 1.68 0.8 13.44 37
I93 0 93 1.27395e-02
R95 93 94 1.744 0.8 13.952 37
I94 0 94 1.24921e-02
R96 94 95 1.696 0.8 13.568 37
I95 0 95 1.29868e-02
R97 95 96 1.728 0.8 13.824 37
I96 0 96 1.27395e-02
R98 96 97 1.68 0.8 13.44 37
I97 0 97 1.28631e-02
R99 97 98 1.744 0.8 13.952 37
I98 0 98 1.27395e-02
R100 98 99 1.616 0.8 12.928 37
I99 0 99 1.24921e-02
R101 99 100 1.696 0.8 13.568 37
I100 0 100 1.29868e-02
R102 100 101 1.696 0.8 13.568 37
I101 0 101 1.27395e-02
R103 101 102 1.6 0.8 12.8 37
I102 0 102 1.23684e-02
R104 102 103 1.744 0.8 13.952 37
I103 0 103 1.34816e-02
R105 103 104 1.6 0.8 12.8 37
I104 0 104 1.32342e-02
R106 104 105 1.728 0.8 13.824 37
I105 0 105 1.29868e-02
R107 105 106 1.712 0.8 13.696 37
I106 0 106 1.26158e-02
R108 106 107 1.664 0.8 13.312 37
I107 0 107 1.24921e-02
R109 107 108 1.632 0.8 13.056 37
I108 0 108 1.26158e-02
R110 108 109 1.664 0.8 13.312 37
I109 0 109 1.28631e-02
R111 109 110 1.68 0.8 13.44 37
I110 0 110 1.32342e-02
R112 110 111 1.696 0.8 13.568 37
I111 0 111 1.33579e-02
R113 111 112 1.68 0.8 13.44 37
I112 0 112 1.31105e-02
R114 112 113 1.696 0.8 13.568 37
I113 0 113 1.26158e-02
R115 113 114 1.616 0.8 12.928 37
I114 0 114 1.33579e-02
R116 114 115 1.648 0.8 13.184 37
I115 0 115 1.24921e-02
R117 115 116 1.648 0.8 13.184 37
I116 0 116 1.26158e-02
R118 116 117 1.696 0.8 13.568 37
I117 0 117 1.24921e-02
R119 117 118 1.664 0.8 13.312 37
I118 0 118 1.33579e-02
R120 118 119 1.664 0.8 13.312 37
I119 0 119 1.34816e-02
R121 119 120 1.664 0.8 13.312 37
I120 0 120 1.24921e-02
R122 120 121 1.744 0.8 13.952 37
I121 0 121 1.29868e-02
R123 121 122 1.68 0.8 13.44 37
I122 0 122 1.28631e-02
R124 122 123 1.6 0.8 12.8 37
I123 0 123 1.26158e-02
R125 123 124 1.68 0.8 13.44 37
I124 0 124 1.34816e-02
R126 124 125 1.632 0.8 13.056 37
I125 0 125 1.23684e-02
R127 125 126 1.6 0.8 12.8 37
I126 0 126 1.29868e-02
R128 126 127 1.728 0.8 13.824 37
I127 0 127 1.24921e-02
R129 127 128 1.744 0.8 13.952 37
I128 0 128 1.24921e-02
R130 128 129 1.632 0.8 13.056 37
I129 0 129 1.23684e-02
R131 129 130 1.696 0.8 13.568 37
I130 0 130 1.24921e-02
R132 130 131 1.6 0.8 12.8 37
I131 0 131 1.24921e-02
R133 131 132 1.712 0.8 13.696 37
I132 0 132 1.34816e-02
R134 132 133 1.6 0.8 12.8 37
I133 0 133 1.31105e-02
R135 133 134 1.648 0.8 13.184 37
I134 0 134 1.33579e-02
R136 134 135 1.648 0.8 13.184 37
I135 0 135 1.24921e-02
R137 135 136 1.616 0.8 12.928 37
I136 0 136 1.34816e-02
R138 136 137 1.696 0.8 13.568 37
I137 0 137 1.28631e-02
R139 137 138 1.744 0.8 13.952 37
I138 0 138 1.26158e-02
R140 138 139 1.712 0.8 13.696 37
I139 0 139 1.33579e-02
R141 139 140 1.632 0.8 13.056 37
I140 0 140 1.29868e-02
R142 140 141 1.6 0.8 12.8 37
I141 0 141 1.34816e-02
R143 141 142 1.68 0.8 13.44 37
I142 0 142 1.34816e-02
R144 142 143 1.616 0.8 12.928 37
I143 0 143 1.33579e-02
R145 143 144 1.632 0.8 13.056 37
I144 0 144 1.27395e-02
R146 144 145 1.68 0.8 13.44 37
I145 0 145 1.34816e-02
R147 145 146 1.632 0.8 13.056 37
I146 0 146 1.28631e-02
R148 146 147 1.632 0.8 13.056 37
I147 0 147 1.34816e-02
R149 147 148 1.648 0.8 13.184 37
I148 0 148 1.32342e-02
R150 148 149 1.632 0.8 13.056 37
I149 0 149 1.24921e-02
R151 149 150 1.68 0.8 13.44 37
I150 0 150 1.28631e-02
R152 150 151 1.744 0.8 13.952 37
I151 0 151 1.23684e-02
R153 151 152 1.744 0.8 13.952 37
I152 0 152 1.34816e-02
R154 152 153 1.664 0.8 13.312 37
I153 0 153 1.26158e-02
R155 153 154 1.664 0.8 13.312 37
I154 0 154 1.23684e-02
R156 154 155 1.744 0.8 13.952 37
I155 0 155 1.29868e-02
R157 155 156 1.632 0.8 13.056 37
I156 0 156 1.29868e-02
R158 156 157 1.696 0.8 13.568 37
I157 0 157 1.27395e-02
R159 157 158 1.744 0.8 13.952 37
I158 0 158 1.33579e-02
R160 158 159 1.712 0.8 13.696 37
I159 0 159 1.34816e-02
R161 159 160 1.712 0.8 13.696 37
I160 0 160 1.28631e-02
R162 160 161 1.712 0.8 13.696 37
I161 0 161 1.23684e-02
R163 161 162 1.632 0.8 13.056 37
I162 0 162 1.34816e-02
R164 162 163 1.744 0.8 13.952 37
I163 0 163 1.34816e-02
R165 163 164 1.648 0.8 13.184 37
I164 0 164 1.31105e-02
R166 164 165 1.632 0.8 13.056 37
I165 0 165 1.34816e-02
R167 165 166 1.648 0.8 13.184 37
I166 0 166 1.34816e-02
R168 166 167 1.696 0.8 13.568 37
I167 0 167 1.32342e-02
R169 167 168 1.616 0.8 12.928 37
I168 0 168 1.24921e-02
R170 168 169 1.6 0.8 12.8 37
I169 0 169 1.27395e-02
R171 169 170 1.68 0.8 13.44 37
I170 0 170 1.34816e-02
R172 170 171 1.6 0.8 12.8 37
I171 0 171 1.32342e-02
R173 171 172 1.664 0.8 13.312 37
I172 0 172 1.28631e-02
R174 172 173 1.648 0.8 13.184 37
I173 0 173 1.26158e-02
R175 173 174 1.744 0.8 13.952 37
I174 0 174 1.31105e-02
R176 174 175 1.648 0.8 13.184 37
I175 0 175 1.32342e-02
R177 175 176 1.68 0.8 13.44 37
I176 0 176 1.27395e-02
R178 176 177 1.664 0.8 13.312 37
I177 0 177 1.26158e-02
R179 177 178 1.632 0.8 13.056 37
I178 0 178 1.29868e-02
R180 178 179 1.632 0.8 13.056 37
I179 0 179 1.28631e-02
R181 179 180 1.6 0.8 12.8 37
I180 0 180 1.29868e-02
R182 180 181 1.696 0.8 13.568 37
I181 0 181 1.33579e-02
R183 181 182 1.68 0.8 13.44 37
I182 0 182 1.33579e-02
R184 182 183 1.6 0.8 12.8 37
I183 0 183 1.31105e-02
R185 183 184 1.68 0.8 13.44 37
I184 0 184 1.31105e-02
R186 184 185 1.648 0.8 13.184 37
I185 0 185 1.24921e-02
R187 185 186 1.616 0.8 12.928 37
I186 0 186 1.33579e-02
R188 186 187 1.744 0.8 13.952 37
I187 0 187 1.32342e-02
R189 187 188 1.616 0.8 12.928 37
I188 0 188 1.23684e-02
R190 188 189 1.664 0.8 13.312 37
I189 0 189 1.23684e-02
R191 189 190 1.648 0.8 13.184 37
I190 0 190 1.33579e-02
R192 190 191 1.728 0.8 13.824 37
I191 0 191 1.28631e-02
R193 191 192 1.68 0.8 13.44 37
I192 0 192 1.29868e-02
R194 192 193 1.632 0.8 13.056 37
I193 0 193 1.33579e-02
R195 193 194 1.744 0.8 13.952 37
I194 0 194 1.29868e-02
R196 194 195 1.632 0.8 13.056 37
I195 0 195 1.33579e-02
R197 195 196 1.664 0.8 13.312 37
I196 0 196 1.33579e-02
R198 196 197 1.632 0.8 13.056 37
I197 0 197 1.28631e-02
R199 197 198 1.616 0.8 12.928 37
I198 0 198 1.28631e-02
R200 198 199 1.744 0.8 13.952 37
I199 0 199 1.24921e-02
R201 199 200 1.632 0.8 13.056 37
I200 0 200 1.27395e-02
R202 200 201 1.728 0.8 13.824 37
I201 0 201 1.33579e-02
R203 201 202 1.648 0.8 13.184 37
I202 0 202 1.32342e-02
R204 202 203 1.632 0.8 13.056 37
I203 0 203 1.29868e-02
R205 203 204 1.744 0.8 13.952 37
I204 0 204 1.29868e-02
R206 204 205 1.68 0.8 13.44 37
I205 0 205 1.29868e-02
R207 205 206 1.728 0.8 13.824 37
I206 0 206 1.27395e-02
R208 206 207 1.712 0.8 13.696 37
I207 0 207 1.33579e-02
R209 207 208 1.632 0.8 13.056 37
I208 0 208 1.33579e-02
R210 208 209 1.68 0.8 13.44 37
I209 0 209 1.28631e-02
R211 209 210 1.6 0.8 12.8 37
I210 0 210 1.24921e-02
R212 210 211 1.68 0.8 13.44 37
I211 0 211 1.24921e-02
R213 211 212 1.616 0.8 12.928 37
I212 0 212 1.33579e-02
R214 212 213 1.664 0.8 13.312 37
I213 0 213 1.32342e-02
R215 213 214 1.68 0.8 13.44 37
I214 0 214 1.34816e-02
R216 214 215 1.68 0.8 13.44 37
I215 0 215 1.23684e-02
R217 215 216 1.712 0.8 13.696 37
I216 0 216 1.34816e-02
R218 216 217 1.712 0.8 13.696 37
I217 0 217 1.34816e-02
R219 217 218 1.744 0.8 13.952 37
I218 0 218 1.24921e-02
R220 218 219 1.712 0.8 13.696 37
I219 0 219 1.32342e-02
R221 219 220 1.744 0.8 13.952 37
I220 0 220 1.31105e-02
R222 220 221 1.712 0.8 13.696 37
I221 0 221 1.29868e-02
R223 221 222 1.616 0.8 12.928 37
I222 0 222 1.32342e-02
R224 222 223 1.744 0.8 13.952 37
I223 0 223 1.29868e-02
R225 223 224 1.68 0.8 13.44 37
I224 0 224 1.31105e-02
R226 224 225 1.648 0.8 13.184 37
I225 0 225 1.31105e-02
R227 225 226 1.6 0.8 12.8 37
I226 0 226 1.33579e-02
R228 226 227 1.6 0.8 12.8 37
I227 0 227 1.34816e-02
R229 227 228 1.728 0.8 13.824 37
I228 0 228 1.26158e-02
R230 228 229 1.744 0.8 13.952 37
I229 0 229 1.34816e-02
R231 229 230 1.696 0.8 13.568 37
I230 0 230 1.33579e-02
R232 230 231 1.616 0.8 12.928 37
I231 0 231 1.24921e-02
R233 231 232 1.696 0.8 13.568 37
I232 0 232 1.33579e-02
R234 232 233 1.712 0.8 13.696 37
I233 0 233 1.32342e-02
R235 233 234 1.6 0.8 12.8 37
I234 0 234 1.34816e-02
R236 234 235 1.696 0.8 13.568 37
I235 0 235 1.31105e-02
R237 235 236 1.68 0.8 13.44 37
I236 0 236 1.24921e-02
R238 236 237 1.696 0.8 13.568 37
I237 0 237 1.27395e-02
R239 237 238 1.744 0.8 13.952 37
I238 0 238 1.24921e-02
R240 238 239 1.632 0.8 13.056 37
I239 0 239 1.31105e-02
R241 239 240 1.712 0.8 13.696 37
I240 0 240 1.31105e-02
R242 240 241 1.632 0.8 13.056 37
I241 0 241 1.23684e-02
R243 241 242 1.664 0.8 13.312 37
I242 0 242 1.27395e-02
R244 242 243 1.744 0.8 13.952 37
I243 0 243 1.34816e-02
R245 243 244 1.632 0.8 13.056 37
I244 0 244 1.26158e-02
R246 244 245 1.712 0.8 13.696 37
I245 0 245 1.33579e-02
R247 245 246 1.632 0.8 13.056 37
I246 0 246 1.26158e-02
R248 246 247 1.632 0.8 13.056 37
I247 0 247 1.29868e-02
R249 247 248 1.744 0.8 13.952 37
I248 0 248 1.31105e-02
R250 248 249 1.664 0.8 13.312 37
I249 0 249 1.23684e-02
R251 249 250 1.68 0.8 13.44 37
I250 0 250 1.34816e-02
R252 250 251 1.68 0.8 13.44 37
I251 0 251 1.27395e-02
R253 251 252 1.616 0.8 12.928 37
I252 0 252 1.28631e-02
R254 252 253 1.744 0.8 13.952 37
I253 0 253 1.23684e-02
R255 253 254 1.616 0.8 12.928 37
I254 0 254 1.28631e-02
R256 254 255 1.68 0.8 13.44 37
I255 0 255 1.28631e-02
R257 255 256 1.6 0.8 12.8 37
I256 0 256 1.34816e-02
R258 256 257 1.616 0.8 12.928 37
I257 0 257 1.27395e-02
R259 257 258 1.616 0.8 12.928 37
I258 0 258 1.34816e-02
R260 258 259 1.6 0.8 12.8 37
I259 0 259 1.28631e-02
R261 259 260 1.712 0.8 13.696 37
I260 0 260 1.27395e-02
R262 260 261 1.712 0.8 13.696 37
I261 0 261 1.33579e-02
R263 261 262 1.6 0.8 12.8 37
I262 0 262 1.29868e-02
R264 262 263 1.6 0.8 12.8 37
I263 0 263 1.34816e-02
R265 263 264 1.696 0.8 13.568 37
I264 0 264 1.31105e-02
R266 264 265 1.712 0.8 13.696 37
I265 0 265 1.26158e-02
R267 265 266 1.648 0.8 13.184 37
I266 0 266 1.32342e-02
R268 266 267 1.632 0.8 13.056 37
I267 0 267 1.31105e-02
R269 267 268 1.632 0.8 13.056 37
I268 0 268 1.34816e-02
R270 268 269 1.664 0.8 13.312 37
I269 0 269 1.26158e-02
R271 269 270 1.664 0.8 13.312 37
I270 0 270 1.29868e-02
R272 270 271 1.728 0.8 13.824 37
I271 0 271 1.28631e-02
R273 271 272 1.712 0.8 13.696 37
I272 0 272 1.31105e-02
R274 272 273 1.632 0.8 13.056 37
I273 0 273 1.28631e-02
R275 273 274 1.696 0.8 13.568 37
I274 0 274 1.26158e-02
R276 274 275 1.68 0.8 13.44 37
I275 0 275 1.33579e-02
R277 275 276 1.632 0.8 13.056 37
I276 0 276 1.23684e-02
R278 276 277 1.616 0.8 12.928 37
I277 0 277 1.34816e-02
R279 277 278 1.712 0.8 13.696 37
I278 0 278 1.28631e-02
R280 278 279 1.664 0.8 13.312 37
I279 0 279 1.29868e-02
R281 279 280 1.712 0.8 13.696 37
I280 0 280 1.29868e-02
R282 280 281 1.6 0.8 12.8 37
I281 0 281 1.33579e-02
R283 281 282 1.68 0.8 13.44 37
I282 0 282 1.23684e-02
R284 282 283 1.616 0.8 12.928 37
I283 0 283 1.34816e-02
R285 283 284 1.712 0.8 13.696 37
I284 0 284 1.32342e-02
R286 284 285 1.6 0.8 12.8 37
I285 0 285 1.32342e-02
R287 285 286 1.712 0.8 13.696 37
I286 0 286 1.31105e-02
R288 286 287 1.648 0.8 13.184 37
I287 0 287 1.27395e-02
R289 287 288 1.712 0.8 13.696 37
I288 0 288 1.32342e-02
R290 288 289 1.68 0.8 13.44 37
I289 0 289 1.24921e-02
R291 289 290 1.68 0.8 13.44 37
I290 0 290 1.31105e-02
R292 290 291 1.712 0.8 13.696 37
I291 0 291 1.24921e-02
R293 291 292 1.616 0.8 12.928 37
I292 0 292 1.23684e-02
R294 292 293 1.696 0.8 13.568 37
I293 0 293 1.34816e-02
R295 293 294 1.68 0.8 13.44 37
I294 0 294 1.32342e-02
R296 294 295 1.728 0.8 13.824 37
I295 0 295 1.27395e-02
R297 295 296 1.616 0.8 12.928 37
I296 0 296 1.31105e-02
R298 296 297 1.664 0.8 13.312 37
I297 0 297 1.33579e-02
R299 297 298 1.632 0.8 13.056 37
I298 0 298 1.32342e-02
R300 298 299 1.664 0.8 13.312 37
I299 0 299 1.31105e-02
R301 299 300 1.68 0.8 13.44 37
I300 0 300 1.29868e-02
R302 300 301 1.632 0.8 13.056 37
I301 0 301 1.31105e-02
R303 301 302 1.68 0.8 13.44 37
I302 0 302 1.29868e-02
R304 302 303 1.632 0.8 13.056 37
I303 0 303 1.33579e-02
R305 303 304 1.68 0.8 13.44 37
I304 0 304 1.32342e-02
R306 304 305 1.632 0.8 13.056 37
I305 0 305 1.23684e-02
R307 305 306 1.712 0.8 13.696 37
I306 0 306 1.26158e-02
R308 306 307 1.632 0.8 13.056 37
I307 0 307 1.27395e-02
R309 307 308 1.728 0.8 13.824 37
I308 0 308 1.29868e-02
R310 308 309 1.6 0.8 12.8 37
I309 0 309 1.33579e-02
R311 309 310 1.696 0.8 13.568 37
I310 0 310 1.26158e-02
R312 310 311 1.632 0.8 13.056 37
I311 0 311 1.28631e-02
R313 311 312 1.712 0.8 13.696 37
I312 0 312 1.29868e-02
R314 312 313 1.744 0.8 13.952 37
I313 0 313 1.28631e-02
R315 313 314 1.648 0.8 13.184 37
I314 0 314 1.34816e-02
R316 314 315 1.68 0.8 13.44 37
I315 0 315 1.29868e-02
R317 315 316 1.712 0.8 13.696 37
I316 0 316 1.24921e-02
R318 316 317 1.648 0.8 13.184 37
I317 0 317 1.32342e-02
R319 317 318 1.616 0.8 12.928 37
I318 0 318 1.32342e-02
R320 318 319 1.712 0.8 13.696 37
I319 0 319 1.26158e-02
R321 319 320 1.664 0.8 13.312 37
I320 0 320 1.24921e-02
R322 320 321 1.712 0.8 13.696 37
I321 0 321 1.27395e-02
R323 321 322 1.712 0.8 13.696 37
I322 0 322 1.32342e-02
R324 322 323 1.648 0.8 13.184 37
I323 0 323 1.24921e-02
R325 323 324 1.728 0.8 13.824 37
I324 0 324 1.34816e-02
R326 324 325 1.728 0.8 13.824 37
I325 0 325 1.31105e-02
R327 325 326 1.632 0.8 13.056 37
I326 0 326 1.23684e-02
R328 326 327 1.632 0.8 13.056 37
I327 0 327 1.33579e-02
R329 327 328 1.68 0.8 13.44 37
I328 0 328 1.26158e-02
R330 328 329 1.696 0.8 13.568 37
I329 0 329 1.34816e-02
R331 329 330 1.664 0.8 13.312 37
I330 0 330 1.31105e-02
R332 330 331 1.744 0.8 13.952 37
I331 0 331 1.27395e-02
R333 331 332 1.712 0.8 13.696 37
I332 0 332 1.23684e-02
R334 332 333 1.728 0.8 13.824 37
I333 0 333 1.33579e-02
R335 333 334 1.712 0.8 13.696 37
I334 0 334 1.29868e-02
R336 334 335 1.632 0.8 13.056 37
I335 0 335 1.23684e-02
R337 335 336 1.648 0.8 13.184 37
I336 0 336 1.27395e-02
R338 336 337 1.616 0.8 12.928 37
I337 0 337 1.24921e-02
R339 337 338 1.632 0.8 13.056 37
I338 0 338 1.28631e-02
R340 338 339 1.68 0.8 13.44 37
I339 0 339 1.31105e-02
R341 339 340 1.728 0.8 13.824 37
I340 0 340 1.24921e-02
R342 340 341 1.632 0.8 13.056 37
I341 0 341 1.24921e-02
R343 341 342 1.744 0.8 13.952 37
I342 0 342 1.34816e-02
R344 342 343 1.632 0.8 13.056 37
I343 0 343 1.34816e-02
R345 343 344 1.728 0.8 13.824 37
I344 0 344 1.27395e-02
R346 344 345 1.712 0.8 13.696 37
I345 0 345 1.24921e-02
R347 345 346 1.664 0.8 13.312 37
I346 0 346 1.24921e-02
R348 346 347 1.664 0.8 13.312 37
I347 0 347 1.32342e-02
R349 347 348 1.68 0.8 13.44 37
I348 0 348 1.27395e-02
R350 348 349 1.616 0.8 12.928 37
I349 0 349 1.24921e-02
R351 349 350 1.664 0.8 13.312 37
I350 0 350 1.28631e-02
R352 350 351 1.648 0.8 13.184 37
I351 0 351 1.29868e-02
R353 351 352 1.744 0.8 13.952 37
I352 0 352 1.26158e-02
R354 352 353 1.616 0.8 12.928 37
I353 0 353 1.34816e-02
R355 353 354 1.616 0.8 12.928 37
I354 0 354 1.27395e-02
R356 354 355 1.664 0.8 13.312 37
I355 0 355 1.33579e-02
R357 355 356 1.616 0.8 12.928 37
I356 0 356 1.31105e-02
R358 356 357 1.648 0.8 13.184 37
I357 0 357 1.28631e-02
R359 357 358 1.6 0.8 12.8 37
I358 0 358 1.29868e-02
R360 358 359 1.696 0.8 13.568 37
I359 0 359 1.33579e-02
R361 359 360 1.6 0.8 12.8 37
I360 0 360 1.26158e-02
R362 360 361 1.648 0.8 13.184 37
I361 0 361 1.28631e-02
R363 361 362 1.712 0.8 13.696 37
I362 0 362 1.27395e-02
R364 362 363 1.648 0.8 13.184 37
I363 0 363 1.27395e-02
R365 363 364 1.696 0.8 13.568 37
I364 0 364 1.28631e-02
R366 364 365 1.616 0.8 12.928 37
I365 0 365 1.24921e-02
R367 365 366 1.648 0.8 13.184 37
I366 0 366 1.28631e-02
R368 366 367 1.728 0.8 13.824 37
I367 0 367 1.32342e-02
R369 367 368 1.728 0.8 13.824 37
I368 0 368 1.33579e-02
R370 368 369 1.616 0.8 12.928 37
I369 0 369 1.24921e-02
R371 369 370 1.744 0.8 13.952 37
I370 0 370 1.34816e-02
R372 370 371 1.728 0.8 13.824 37
I371 0 371 1.29868e-02
R373 371 372 1.632 0.8 13.056 37
I372 0 372 1.28631e-02
R374 372 373 1.744 0.8 13.952 37
I373 0 373 1.23684e-02
R375 373 374 1.664 0.8 13.312 37
I374 0 374 1.28631e-02
R376 374 375 1.744 0.8 13.952 37
I375 0 375 1.23684e-02
R377 375 376 1.744 0.8 13.952 37
I376 0 376 1.34816e-02
R378 376 377 1.6 0.8 12.8 37
I377 0 377 1.24921e-02
R379 377 378 1.664 0.8 13.312 37
I378 0 378 1.26158e-02
R380 378 379 1.712 0.8 13.696 37
I379 0 379 1.24921e-02
R381 379 380 1.728 0.8 13.824 37
I380 0 380 1.26158e-02
R382 380 381 1.728 0.8 13.824 37
I381 0 381 1.27395e-02
R383 381 382 1.744 0.8 13.952 37
I382 0 382 1.34816e-02
R384 382 383 1.744 0.8 13.952 37
I383 0 383 1.26158e-02
R385 383 384 1.744 0.8 13.952 37
I384 0 384 1.32342e-02
R386 384 385 1.6 0.8 12.8 37
I385 0 385 1.34816e-02
R387 385 386 1.648 0.8 13.184 37
I386 0 386 1.29868e-02
R388 386 387 1.712 0.8 13.696 37
I387 0 387 1.34816e-02
R389 387 388 1.68 0.8 13.44 37
I388 0 388 1.33579e-02
R390 388 389 1.648 0.8 13.184 37
I389 0 389 1.33579e-02
R391 389 390 1.632 0.8 13.056 37
I390 0 390 1.32342e-02
R392 390 391 1.648 0.8 13.184 37
I391 0 391 1.33579e-02
R393 391 392 1.712 0.8 13.696 37
I392 0 392 1.33579e-02
R394 392 393 1.616 0.8 12.928 37
I393 0 393 1.28631e-02
R395 393 394 1.744 0.8 13.952 37
I394 0 394 1.29868e-02
R396 394 395 1.648 0.8 13.184 37
I395 0 395 1.33579e-02
R397 395 396 1.6 0.8 12.8 37
I396 0 396 1.34816e-02
R398 396 397 1.632 0.8 13.056 37
I397 0 397 1.27395e-02
R399 397 398 1.744 0.8 13.952 37
I398 0 398 1.34816e-02
R400 398 399 1.68 0.8 13.44 37
I399 0 399 1.34816e-02
R401 399 400 1.664 0.8 13.312 37
I400 0 400 1.28631e-02
R402 400 401 1.664 0.8 13.312 37
I401 0 401 1.27395e-02
R403 401 402 1.616 0.8 12.928 37
I402 0 402 1.34816e-02
R404 402 403 1.712 0.8 13.696 37
I403 0 403 1.32342e-02
R405 403 404 1.632 0.8 13.056 37
I404 0 404 1.29868e-02
R406 404 405 1.744 0.8 13.952 37
I405 0 405 1.23684e-02
R407 405 406 1.6 0.8 12.8 37
I406 0 406 1.24921e-02
R408 406 407 1.648 0.8 13.184 37
I407 0 407 1.28631e-02
R409 407 408 1.632 0.8 13.056 37
I408 0 408 1.24921e-02
R410 408 409 1.632 0.8 13.056 37
I409 0 409 1.33579e-02
R411 409 410 1.616 0.8 12.928 37
I410 0 410 1.33579e-02
R412 410 411 1.664 0.8 13.312 37
I411 0 411 1.31105e-02
R413 411 412 1.616 0.8 12.928 37
I412 0 412 1.28631e-02
R414 412 413 1.664 0.8 13.312 37
I413 0 413 1.29868e-02
R415 413 414 1.712 0.8 13.696 37
I414 0 414 1.23684e-02
R416 414 415 1.728 0.8 13.824 37
I415 0 415 1.31105e-02
R417 415 416 1.696 0.8 13.568 37
I416 0 416 1.24921e-02
R418 416 417 1.616 0.8 12.928 37
I417 0 417 1.29868e-02
R419 417 418 1.632 0.8 13.056 37
I418 0 418 1.32342e-02
R420 418 419 1.6 0.8 12.8 37
I419 0 419 1.34816e-02
R421 419 420 1.728 0.8 13.824 37
I420 0 420 1.33579e-02
R422 420 421 1.744 0.8 13.952 37
I421 0 421 1.33579e-02
R423 421 422 1.712 0.8 13.696 37
I422 0 422 1.23684e-02
R424 422 423 1.728 0.8 13.824 37
I423 0 423 1.31105e-02
R425 423 424 1.744 0.8 13.952 37
I424 0 424 1.23684e-02
R426 424 425 1.616 0.8 12.928 37
I425 0 425 1.29868e-02
R427 425 426 1.712 0.8 13.696 37
I426 0 426 1.26158e-02
R428 426 427 1.696 0.8 13.568 37
I427 0 427 1.29868e-02
R429 427 428 1.68 0.8 13.44 37
I428 0 428 1.26158e-02
R430 428 429 1.616 0.8 12.928 37
I429 0 429 1.32342e-02
R431 429 430 1.6 0.8 12.8 37
I430 0 430 1.33579e-02
R432 430 431 1.696 0.8 13.568 37
I431 0 431 1.27395e-02
R433 431 432 1.616 0.8 12.928 37
I432 0 432 1.23684e-02
R434 432 433 1.616 0.8 12.928 37
I433 0 433 1.23684e-02
R435 433 434 1.6 0.8 12.8 37
I434 0 434 1.31105e-02
R436 434 435 1.728 0.8 13.824 37
I435 0 435 1.34816e-02
R437 435 436 1.744 0.8 13.952 37
I436 0 436 1.34816e-02
R438 436 437 1.712 0.8 13.696 37
I437 0 437 1.24921e-02
R439 437 438 1.664 0.8 13.312 37
I438 0 438 1.32342e-02
R440 438 439 1.6 0.8 12.8 37
I439 0 439 1.33579e-02
R441 439 440 1.632 0.8 13.056 37
I440 0 440 1.31105e-02
R442 440 441 1.632 0.8 13.056 37
I441 0 441 1.24921e-02
R443 441 442 1.68 0.8 13.44 37
I442 0 442 1.27395e-02
R444 442 443 1.664 0.8 13.312 37
I443 0 443 1.23684e-02
R445 443 444 1.664 0.8 13.312 37
I444 0 444 1.34816e-02
R446 444 445 1.632 0.8 13.056 37
I445 0 445 1.31105e-02
R447 445 446 1.664 0.8 13.312 37
I446 0 446 1.23684e-02
R448 446 447 1.712 0.8 13.696 37
I447 0 447 1.32342e-02
R449 447 448 1.664 0.8 13.312 37
I448 0 448 1.24921e-02
R450 448 449 1.696 0.8 13.568 37
I449 0 449 1.34816e-02
R451 449 450 1.712 0.8 13.696 37
I450 0 450 1.27395e-02
R452 450 451 1.6 0.8 12.8 37
I451 0 451 1.31105e-02
R453 451 452 1.664 0.8 13.312 37
I452 0 452 1.33579e-02
R454 452 453 1.648 0.8 13.184 37
I453 0 453 1.27395e-02
R455 453 454 1.728 0.8 13.824 37
I454 0 454 1.29868e-02
R456 454 455 1.744 0.8 13.952 37
I455 0 455 1.28631e-02
R457 455 456 1.728 0.8 13.824 37
I456 0 456 1.23684e-02
R458 456 457 1.68 0.8 13.44 37
I457 0 457 1.27395e-02
R459 457 458 1.6 0.8 12.8 37
I458 0 458 1.26158e-02
R460 458 459 1.728 0.8 13.824 37
I459 0 459 1.32342e-02
R461 459 460 1.712 0.8 13.696 37
I460 0 460 1.31105e-02
R462 460 461 1.728 0.8 13.824 37
I461 0 461 1.32342e-02
R463 461 462 1.632 0.8 13.056 37
I462 0 462 1.34816e-02
R464 462 463 1.68 0.8 13.44 37
I463 0 463 1.24921e-02
R465 463 464 1.6 0.8 12.8 37
I464 0 464 1.32342e-02
R466 464 465 1.696 0.8 13.568 37
I465 0 465 1.33579e-02
R467 465 466 1.728 0.8 13.824 37
I466 0 466 1.26158e-02
R468 466 467 1.632 0.8 13.056 37
I467 0 467 1.26158e-02
R469 467 468 1.6 0.8 12.8 37
I468 0 468 1.23684e-02
R470 468 469 1.696 0.8 13.568 37
I469 0 469 1.33579e-02
R471 469 470 1.728 0.8 13.824 37
I470 0 470 1.23684e-02
R472 470 471 1.696 0.8 13.568 37
I471 0 471 1.27395e-02
R473 471 472 1.664 0.8 13.312 37
I472 0 472 1.27395e-02
R474 472 473 1.616 0.8 12.928 37
I473 0 473 1.32342e-02
R475 473 474 1.696 0.8 13.568 37
I474 0 474 1.26158e-02
R476 474 475 1.664 0.8 13.312 37
I475 0 475 1.31105e-02
R477 475 476 1.728 0.8 13.824 37
I476 0 476 1.27395e-02
R478 476 477 1.648 0.8 13.184 37
I477 0 477 1.26158e-02
R479 477 478 1.6 0.8 12.8 37
I478 0 478 1.26158e-02
R480 478 479 1.664 0.8 13.312 37
I479 0 479 1.32342e-02
R481 479 480 1.616 0.8 12.928 37
I480 0 480 1.29868e-02
R482 480 481 1.648 0.8 13.184 37
I481 0 481 1.24921e-02
R483 481 482 1.728 0.8 13.824 37
I482 0 482 1.33579e-02
R484 482 483 1.728 0.8 13.824 37
I483 0 483 1.28631e-02
R485 483 484 1.696 0.8 13.568 37
I484 0 484 1.23684e-02
R486 484 485 1.648 0.8 13.184 37
I485 0 485 1.32342e-02
R487 485 486 1.632 0.8 13.056 37
I486 0 486 1.34816e-02
R488 486 487 1.696 0.8 13.568 37
I487 0 487 1.34816e-02
R489 487 488 1.696 0.8 13.568 37
I488 0 488 1.29868e-02
R490 488 489 1.744 0.8 13.952 37
I489 0 489 1.27395e-02
R491 489 490 1.664 0.8 13.312 37
I490 0 490 1.34816e-02
R492 490 491 1.68 0.8 13.44 37
I491 0 491 1.33579e-02
R493 491 492 1.696 0.8 13.568 37
I492 0 492 1.34816e-02
R494 492 493 1.648 0.8 13.184 37
I493 0 493 1.32342e-02
R495 493 494 1.712 0.8 13.696 37
I494 0 494 1.32342e-02
R496 494 495 1.664 0.8 13.312 37
I495 0 495 1.23684e-02
R497 495 496 1.728 0.8 13.824 37
I496 0 496 1.26158e-02
R498 496 497 1.728 0.8 13.824 37
I497 0 497 1.24921e-02
R499 497 498 1.648 0.8 13.184 37
I498 0 498 1.23684e-02
R500 498 499 1.6 0.8 12.8 37
I499 0 499 1.31105e-02
R501 499 500 1.68 0.8 13.44 37
I500 0 500 1.23684e-02
R502 500 0 0.5 10 50 37
*seg: 2
R503 0 501 0.4 20 80 37
R504 750 1250 6.16 0.8 49.28 37
I501 0 501 1.27395e-02
R505 501 502 1.664 0.8 13.312 37
I502 0 502 1.29868e-02
R506 502 503 1.68 0.8 13.44 37
I503 0 503 1.26158e-02
R507 503 504 1.744 0.8 13.952 37
I504 0 504 1.26158e-02
R508 504 505 1.664 0.8 13.312 37
I505 0 505 1.23684e-02
R509 505 506 1.712 0.8 13.696 37
I506 0 506 1.31105e-02
R510 506 507 1.696 0.8 13.568 37
I507 0 507 1.26158e-02
R511 507 508 1.744 0.8 13.952 37
I508 0 508 1.29868e-02
R512 508 509 1.696 0.8 13.568 37
I509 0 509 1.27395e-02
R513 509 510 1.68 0.8 13.44 37
I510 0 510 1.33579e-02
R514 510 511 1.696 0.8 13.568 37
I511 0 511 1.27395e-02
R515 511 512 1.6 0.8 12.8 37
I512 0 512 1.32342e-02
R516 512 513 1.616 0.8 12.928 37
I513 0 513 1.23684e-02
R517 513 514 1.616 0.8 12.928 37
I514 0 514 1.28631e-02
R518 514 515 1.68 0.8 13.44 37
I515 0 515 1.29868e-02
R519 515 516 1.696 0.8 13.568 37
I516 0 516 1.33579e-02
R520 516 517 1.744 0.8 13.952 37
I517 0 517 1.24921e-02
R521 517 518 1.664 0.8 13.312 37
I518 0 518 1.31105e-02
R522 518 519 1.744 0.8 13.952 37
I519 0 519 1.28631e-02
R523 519 520 1.696 0.8 13.568 37
I520 0 520 1.31105e-02
R524 520 521 1.632 0.8 13.056 37
I521 0 521 1.27395e-02
R525 521 522 1.664 0.8 13.312 37
I522 0 522 1.34816e-02
R526 522 523 1.616 0.8 12.928 37
I523 0 523 1.31105e-02
R527 523 524 1.664 0.8 13.312 37
I524 0 524 1.31105e-02
R528 524 525 1.6 0.8 12.8 37
I525 0 525 1.27395e-02
R529 525 526 1.68 0.8 13.44 37
I526 0 526 1.24921e-02
R530 526 527 1.632 0.8 13.056 37
I527 0 527 1.26158e-02
R531 527 528 1.6 0.8 12.8 37
I528 0 528 1.24921e-02
R532 528 529 1.616 0.8 12.928 37
I529 0 529 1.32342e-02
R533 529 530 1.6 0.8 12.8 37
I530 0 530 1.23684e-02
R534 530 531 1.648 0.8 13.184 37
I531 0 531 1.32342e-02
R535 531 532 1.664 0.8 13.312 37
I532 0 532 1.29868e-02
R536 532 533 1.712 0.8 13.696 37
I533 0 533 1.23684e-02
R537 533 534 1.744 0.8 13.952 37
I534 0 534 1.27395e-02
R538 534 535 1.728 0.8 13.824 37
I535 0 535 1.26158e-02
R539 535 536 1.712 0.8 13.696 37
I536 0 536 1.31105e-02
R540 536 537 1.632 0.8 13.056 37
I537 0 537 1.29868e-02
R541 537 538 1.696 0.8 13.568 37
I538 0 538 1.32342e-02
R542 538 539 1.664 0.8 13.312 37
I539 0 539 1.33579e-02
R543 539 540 1.728 0.8 13.824 37
I540 0 540 1.27395e-02
R544 540 541 1.728 0.8 13.824 37
I541 0 541 1.33579e-02
R545 541 542 1.616 0.8 12.928 37
I542 0 542 1.29868e-02
R546 542 543 1.696 0.8 13.568 37
I543 0 543 1.34816e-02
R547 543 544 1.696 0.8 13.568 37
I544 0 544 1.23684e-02
R548 544 545 1.696 0.8 13.568 37
I545 0 545 1.28631e-02
R549 545 546 1.744 0.8 13.952 37
I546 0 546 1.33579e-02
R550 546 547 1.68 0.8 13.44 37
I547 0 547 1.26158e-02
R551 547 548 1.728 0.8 13.824 37
I548 0 548 1.29868e-02
R552 548 549 1.616 0.8 12.928 37
I549 0 549 1.24921e-02
R553 549 550 1.648 0.8 13.184 37
I550 0 550 1.29868e-02
R554 550 551 1.744 0.8 13.952 37
I551 0 551 1.28631e-02
R555 551 552 1.632 0.8 13.056 37
I552 0 552 1.23684e-02
R556 552 553 1.616 0.8 12.928 37
I553 0 553 1.33579e-02
R557 553 554 1.616 0.8 12.928 37
I554 0 554 1.31105e-02
R558 554 555 1.664 0.8 13.312 37
I555 0 555 1.31105e-02
R559 555 556 1.632 0.8 13.056 37
I556 0 556 1.23684e-02
R560 556 557 1.6 0.8 12.8 37
I557 0 557 1.29868e-02
R561 557 558 1.68 0.8 13.44 37
I558 0 558 1.29868e-02
R562 558 559 1.6 0.8 12.8 37
I559 0 559 1.32342e-02
R563 559 560 1.728 0.8 13.824 37
I560 0 560 1.24921e-02
R564 560 561 1.68 0.8 13.44 37
I561 0 561 1.33579e-02
R565 561 562 1.696 0.8 13.568 37
I562 0 562 1.23684e-02
R566 562 563 1.632 0.8 13.056 37
I563 0 563 1.34816e-02
R567 563 564 1.6 0.8 12.8 37
I564 0 564 1.24921e-02
R568 564 565 1.728 0.8 13.824 37
I565 0 565 1.32342e-02
R569 565 566 1.728 0.8 13.824 37
I566 0 566 1.29868e-02
R570 566 567 1.648 0.8 13.184 37
I567 0 567 1.27395e-02
R571 567 568 1.712 0.8 13.696 37
I568 0 568 1.23684e-02
R572 568 569 1.728 0.8 13.824 37
I569 0 569 1.32342e-02
R573 569 570 1.648 0.8 13.184 37
I570 0 570 1.26158e-02
R574 570 571 1.632 0.8 13.056 37
I571 0 571 1.31105e-02
R575 571 572 1.6 0.8 12.8 37
I572 0 572 1.33579e-02
R576 572 573 1.664 0.8 13.312 37
I573 0 573 1.27395e-02
R577 573 574 1.648 0.8 13.184 37
I574 0 574 1.32342e-02
R578 574 575 1.744 0.8 13.952 37
I575 0 575 1.26158e-02
R579 575 576 1.664 0.8 13.312 37
I576 0 576 1.31105e-02
R580 576 577 1.712 0.8 13.696 37
I577 0 577 1.24921e-02
R581 577 578 1.712 0.8 13.696 37
I578 0 578 1.28631e-02
R582 578 579 1.6 0.8 12.8 37
I579 0 579 1.34816e-02
R583 579 580 1.712 0.8 13.696 37
I580 0 580 1.27395e-02
R584 580 581 1.696 0.8 13.568 37
I581 0 581 1.24921e-02
R585 581 582 1.696 0.8 13.568 37
I582 0 582 1.24921e-02
R586 582 583 1.616 0.8 12.928 37
I583 0 583 1.23684e-02
R587 583 584 1.6 0.8 12.8 37
I584 0 584 1.32342e-02
R588 584 585 1.68 0.8 13.44 37
I585 0 585 1.27395e-02
R589 585 586 1.6 0.8 12.8 37
I586 0 586 1.34816e-02
R590 586 587 1.632 0.8 13.056 37
I587 0 587 1.24921e-02
R591 587 588 1.68 0.8 13.44 37
I588 0 588 1.24921e-02
R592 588 589 1.744 0.8 13.952 37
I589 0 589 1.23684e-02
R593 589 590 1.616 0.8 12.928 37
I590 0 590 1.27395e-02
R594 590 591 1.712 0.8 13.696 37
I591 0 591 1.27395e-02
R595 591 592 1.632 0.8 13.056 37
I592 0 592 1.34816e-02
R596 592 593 1.664 0.8 13.312 37
I593 0 593 1.33579e-02
R597 593 594 1.664 0.8 13.312 37
I594 0 594 1.29868e-02
R598 594 595 1.744 0.8 13.952 37
I595 0 595 1.29868e-02
R599 595 596 1.616 0.8 12.928 37
I596 0 596 1.34816e-02
R600 596 597 1.6 0.8 12.8 37
I597 0 597 1.28631e-02
R601 597 598 1.616 0.8 12.928 37
I598 0 598 1.33579e-02
R602 598 599 1.632 0.8 13.056 37
I599 0 599 1.29868e-02
R603 599 600 1.648 0.8 13.184 37
I600 0 600 1.31105e-02
R604 600 601 1.616 0.8 12.928 37
I601 0 601 1.31105e-02
R605 601 602 1.648 0.8 13.184 37
I602 0 602 1.27395e-02
R606 602 603 1.712 0.8 13.696 37
I603 0 603 1.26158e-02
R607 603 604 1.712 0.8 13.696 37
I604 0 604 1.31105e-02
R608 604 605 1.712 0.8 13.696 37
I605 0 605 1.23684e-02
R609 605 606 1.712 0.8 13.696 37
I606 0 606 1.26158e-02
R610 606 607 1.664 0.8 13.312 37
I607 0 607 1.23684e-02
R611 607 608 1.632 0.8 13.056 37
I608 0 608 1.32342e-02
R612 608 609 1.744 0.8 13.952 37
I609 0 609 1.26158e-02
R613 609 610 1.632 0.8 13.056 37
I610 0 610 1.28631e-02
R614 610 611 1.68 0.8 13.44 37
I611 0 611 1.24921e-02
R615 611 612 1.648 0.8 13.184 37
I612 0 612 1.31105e-02
R616 612 613 1.712 0.8 13.696 37
I613 0 613 1.26158e-02
R617 613 614 1.6 0.8 12.8 37
I614 0 614 1.31105e-02
R618 614 615 1.632 0.8 13.056 37
I615 0 615 1.23684e-02
R619 615 616 1.696 0.8 13.568 37
I616 0 616 1.27395e-02
R620 616 617 1.696 0.8 13.568 37
I617 0 617 1.34816e-02
R621 617 618 1.696 0.8 13.568 37
I618 0 618 1.29868e-02
R622 618 619 1.68 0.8 13.44 37
I619 0 619 1.34816e-02
R623 619 620 1.744 0.8 13.952 37
I620 0 620 1.24921e-02
R624 620 621 1.648 0.8 13.184 37
I621 0 621 1.28631e-02
R625 621 622 1.664 0.8 13.312 37
I622 0 622 1.33579e-02
R626 622 623 1.712 0.8 13.696 37
I623 0 623 1.31105e-02
R627 623 624 1.696 0.8 13.568 37
I624 0 624 1.31105e-02
R628 624 625 1.728 0.8 13.824 37
I625 0 625 1.29868e-02
R629 625 626 1.6 0.8 12.8 37
I626 0 626 1.24921e-02
R630 626 627 1.6 0.8 12.8 37
I627 0 627 1.23684e-02
R631 627 628 1.696 0.8 13.568 37
I628 0 628 1.23684e-02
R632 628 629 1.696 0.8 13.568 37
I629 0 629 1.24921e-02
R633 629 630 1.712 0.8 13.696 37
I630 0 630 1.34816e-02
R634 630 631 1.744 0.8 13.952 37
I631 0 631 1.28631e-02
R635 631 632 1.712 0.8 13.696 37
I632 0 632 1.31105e-02
R636 632 633 1.6 0.8 12.8 37
I633 0 633 1.29868e-02
R637 633 634 1.632 0.8 13.056 37
I634 0 634 1.24921e-02
R638 634 635 1.648 0.8 13.184 37
I635 0 635 1.34816e-02
R639 635 636 1.6 0.8 12.8 37
I636 0 636 1.31105e-02
R640 636 637 1.616 0.8 12.928 37
I637 0 637 1.27395e-02
R641 637 638 1.6 0.8 12.8 37
I638 0 638 1.29868e-02
R642 638 639 1.68 0.8 13.44 37
I639 0 639 1.28631e-02
R643 639 640 1.68 0.8 13.44 37
I640 0 640 1.31105e-02
R644 640 641 1.696 0.8 13.568 37
I641 0 641 1.23684e-02
R645 641 642 1.728 0.8 13.824 37
I642 0 642 1.23684e-02
R646 642 643 1.648 0.8 13.184 37
I643 0 643 1.27395e-02
R647 643 644 1.648 0.8 13.184 37
I644 0 644 1.23684e-02
R648 644 645 1.664 0.8 13.312 37
I645 0 645 1.31105e-02
R649 645 646 1.744 0.8 13.952 37
I646 0 646 1.23684e-02
R650 646 647 1.664 0.8 13.312 37
I647 0 647 1.28631e-02
R651 647 648 1.616 0.8 12.928 37
I648 0 648 1.26158e-02
R652 648 649 1.648 0.8 13.184 37
I649 0 649 1.23684e-02
R653 649 650 1.696 0.8 13.568 37
I650 0 650 1.29868e-02
R654 650 651 1.616 0.8 12.928 37
I651 0 651 1.29868e-02
R655 651 652 1.616 0.8 12.928 37
I652 0 652 1.28631e-02
R656 652 653 1.68 0.8 13.44 37
I653 0 653 1.34816e-02
R657 653 654 1.68 0.8 13.44 37
I654 0 654 1.31105e-02
R658 654 655 1.696 0.8 13.568 37
I655 0 655 1.31105e-02
R659 655 656 1.616 0.8 12.928 37
I656 0 656 1.23684e-02
R660 656 657 1.68 0.8 13.44 37
I657 0 657 1.23684e-02
R661 657 658 1.744 0.8 13.952 37
I658 0 658 1.32342e-02
R662 658 659 1.616 0.8 12.928 37
I659 0 659 1.28631e-02
R663 659 660 1.712 0.8 13.696 37
I660 0 660 1.26158e-02
R664 660 661 1.616 0.8 12.928 37
I661 0 661 1.31105e-02
R665 661 662 1.68 0.8 13.44 37
I662 0 662 1.32342e-02
R666 662 663 1.68 0.8 13.44 37
I663 0 663 1.27395e-02
R667 663 664 1.632 0.8 13.056 37
I664 0 664 1.29868e-02
R668 664 665 1.68 0.8 13.44 37
I665 0 665 1.32342e-02
R669 665 666 1.696 0.8 13.568 37
I666 0 666 1.24921e-02
R670 666 667 1.6 0.8 12.8 37
I667 0 667 1.29868e-02
R671 667 668 1.744 0.8 13.952 37
I668 0 668 1.24921e-02
R672 668 669 1.6 0.8 12.8 37
I669 0 669 1.27395e-02
R673 669 670 1.712 0.8 13.696 37
I670 0 670 1.29868e-02
R674 670 671 1.632 0.8 13.056 37
I671 0 671 1.24921e-02
R675 671 672 1.744 0.8 13.952 37
I672 0 672 1.26158e-02
R676 672 673 1.632 0.8 13.056 37
I673 0 673 1.29868e-02
R677 673 674 1.744 0.8 13.952 37
I674 0 674 1.23684e-02
R678 674 675 1.616 0.8 12.928 37
I675 0 675 1.24921e-02
R679 675 676 1.696 0.8 13.568 37
I676 0 676 1.23684e-02
R680 676 677 1.664 0.8 13.312 37
I677 0 677 1.27395e-02
R681 677 678 1.648 0.8 13.184 37
I678 0 678 1.31105e-02
R682 678 679 1.744 0.8 13.952 37
I679 0 679 1.31105e-02
R683 679 680 1.632 0.8 13.056 37
I680 0 680 1.34816e-02
R684 680 681 1.744 0.8 13.952 37
I681 0 681 1.34816e-02
R685 681 682 1.632 0.8 13.056 37
I682 0 682 1.33579e-02
R686 682 683 1.68 0.8 13.44 37
I683 0 683 1.33579e-02
R687 683 684 1.696 0.8 13.568 37
I684 0 684 1.29868e-02
R688 684 685 1.616 0.8 12.928 37
I685 0 685 1.28631e-02
R689 685 686 1.664 0.8 13.312 37
I686 0 686 1.34816e-02
R690 686 687 1.696 0.8 13.568 37
I687 0 687 1.31105e-02
R691 687 688 1.664 0.8 13.312 37
I688 0 688 1.33579e-02
R692 688 689 1.6 0.8 12.8 37
I689 0 689 1.33579e-02
R693 689 690 1.6 0.8 12.8 37
I690 0 690 1.23684e-02
R694 690 691 1.744 0.8 13.952 37
I691 0 691 1.32342e-02
R695 691 692 1.648 0.8 13.184 37
I692 0 692 1.29868e-02
R696 692 693 1.664 0.8 13.312 37
I693 0 693 1.33579e-02
R697 693 694 1.616 0.8 12.928 37
I694 0 694 1.23684e-02
R698 694 695 1.712 0.8 13.696 37
I695 0 695 1.32342e-02
R699 695 696 1.712 0.8 13.696 37
I696 0 696 1.28631e-02
R700 696 697 1.648 0.8 13.184 37
I697 0 697 1.23684e-02
R701 697 698 1.6 0.8 12.8 37
I698 0 698 1.24921e-02
R702 698 699 1.696 0.8 13.568 37
I699 0 699 1.24921e-02
R703 699 700 1.648 0.8 13.184 37
I700 0 700 1.29868e-02
R704 700 701 1.632 0.8 13.056 37
I701 0 701 1.28631e-02
R705 701 702 1.632 0.8 13.056 37
I702 0 702 1.33579e-02
R706 702 703 1.648 0.8 13.184 37
I703 0 703 1.32342e-02
R707 703 704 1.6 0.8 12.8 37
I704 0 704 1.34816e-02
R708 704 705 1.696 0.8 13.568 37
I705 0 705 1.27395e-02
R709 705 706 1.6 0.8 12.8 37
I706 0 706 1.23684e-02
R710 706 707 1.728 0.8 13.824 37
I707 0 707 1.29868e-02
R711 707 708 1.712 0.8 13.696 37
I708 0 708 1.27395e-02
R712 708 709 1.6 0.8 12.8 37
I709 0 709 1.33579e-02
R713 709 710 1.648 0.8 13.184 37
I710 0 710 1.24921e-02
R714 710 711 1.696 0.8 13.568 37
I711 0 711 1.26158e-02
R715 711 712 1.648 0.8 13.184 37
I712 0 712 1.34816e-02
R716 712 713 1.6 0.8 12.8 37
I713 0 713 1.27395e-02
R717 713 714 1.6 0.8 12.8 37
I714 0 714 1.29868e-02
R718 714 715 1.696 0.8 13.568 37
I715 0 715 1.31105e-02
R719 715 716 1.664 0.8 13.312 37
I716 0 716 1.34816e-02
R720 716 717 1.616 0.8 12.928 37
I717 0 717 1.23684e-02
R721 717 718 1.744 0.8 13.952 37
I718 0 718 1.28631e-02
R722 718 719 1.68 0.8 13.44 37
I719 0 719 1.32342e-02
R723 719 720 1.68 0.8 13.44 37
I720 0 720 1.27395e-02
R724 720 721 1.616 0.8 12.928 37
I721 0 721 1.29868e-02
R725 721 722 1.6 0.8 12.8 37
I722 0 722 1.26158e-02
R726 722 723 1.744 0.8 13.952 37
I723 0 723 1.27395e-02
R727 723 724 1.664 0.8 13.312 37
I724 0 724 1.26158e-02
R728 724 725 1.744 0.8 13.952 37
I725 0 725 1.29868e-02
R729 725 726 1.712 0.8 13.696 37
I726 0 726 1.29868e-02
R730 726 727 1.712 0.8 13.696 37
I727 0 727 1.33579e-02
R731 727 728 1.728 0.8 13.824 37
I728 0 728 1.32342e-02
R732 728 729 1.744 0.8 13.952 37
I729 0 729 1.23684e-02
R733 729 730 1.712 0.8 13.696 37
I730 0 730 1.24921e-02
R734 730 731 1.648 0.8 13.184 37
I731 0 731 1.33579e-02
R735 731 732 1.6 0.8 12.8 37
I732 0 732 1.32342e-02
R736 732 733 1.712 0.8 13.696 37
I733 0 733 1.29868e-02
R737 733 734 1.68 0.8 13.44 37
I734 0 734 1.26158e-02
R738 734 735 1.744 0.8 13.952 37
I735 0 735 1.27395e-02
R739 735 736 1.664 0.8 13.312 37
I736 0 736 1.32342e-02
R740 736 737 1.696 0.8 13.568 37
I737 0 737 1.24921e-02
R741 737 738 1.664 0.8 13.312 37
I738 0 738 1.31105e-02
R742 738 739 1.68 0.8 13.44 37
I739 0 739 1.26158e-02
R743 739 740 1.68 0.8 13.44 37
I740 0 740 1.28631e-02
R744 740 741 1.632 0.8 13.056 37
I741 0 741 1.33579e-02
R745 741 742 1.6 0.8 12.8 37
I742 0 742 1.24921e-02
R746 742 743 1.728 0.8 13.824 37
I743 0 743 1.28631e-02
R747 743 744 1.728 0.8 13.824 37
I744 0 744 1.23684e-02
R748 744 745 1.632 0.8 13.056 37
I745 0 745 1.23684e-02
R749 745 746 1.728 0.8 13.824 37
I746 0 746 1.31105e-02
R750 746 747 1.664 0.8 13.312 37
I747 0 747 1.33579e-02
R751 747 748 1.712 0.8 13.696 37
I748 0 748 1.23684e-02
R752 748 749 1.6 0.8 12.8 37
I749 0 749 1.32342e-02
R753 749 750 1.632 0.8 13.056 37
I750 0 750 1.28631e-02
R754 750 751 1.696 0.8 13.568 37
I751 0 751 1.27395e-02
R755 751 752 1.728 0.8 13.824 37
I752 0 752 1.24921e-02
R756 752 753 1.6 0.8 12.8 37
I753 0 753 1.32342e-02
R757 753 754 1.68 0.8 13.44 37
I754 0 754 1.34816e-02
R758 754 755 1.648 0.8 13.184 37
I755 0 755 1.27395e-02
R759 755 756 1.6 0.8 12.8 37
I756 0 756 1.33579e-02
R760 756 757 1.6 0.8 12.8 37
I757 0 757 1.32342e-02
R761 757 758 1.6 0.8 12.8 37
I758 0 758 1.27395e-02
R762 758 759 1.728 0.8 13.824 37
I759 0 759 1.33579e-02
R763 759 760 1.664 0.8 13.312 37
I760 0 760 1.31105e-02
R764 760 761 1.712 0.8 13.696 37
I761 0 761 1.28631e-02
R765 761 762 1.712 0.8 13.696 37
I762 0 762 1.29868e-02
R766 762 763 1.616 0.8 12.928 37
I763 0 763 1.33579e-02
R767 763 764 1.6 0.8 12.8 37
I764 0 764 1.23684e-02
R768 764 765 1.648 0.8 13.184 37
I765 0 765 1.31105e-02
R769 765 766 1.744 0.8 13.952 37
I766 0 766 1.26158e-02
R770 766 767 1.68 0.8 13.44 37
I767 0 767 1.34816e-02
R771 767 768 1.68 0.8 13.44 37
I768 0 768 1.32342e-02
R772 768 769 1.616 0.8 12.928 37
I769 0 769 1.28631e-02
R773 769 770 1.68 0.8 13.44 37
I770 0 770 1.27395e-02
R774 770 771 1.744 0.8 13.952 37
I771 0 771 1.27395e-02
R775 771 772 1.744 0.8 13.952 37
I772 0 772 1.24921e-02
R776 772 773 1.728 0.8 13.824 37
I773 0 773 1.32342e-02
R777 773 774 1.68 0.8 13.44 37
I774 0 774 1.23684e-02
R778 774 775 1.68 0.8 13.44 37
I775 0 775 1.29868e-02
R779 775 776 1.664 0.8 13.312 37
I776 0 776 1.27395e-02
R780 776 777 1.632 0.8 13.056 37
I777 0 777 1.28631e-02
R781 777 778 1.648 0.8 13.184 37
I778 0 778 1.24921e-02
R782 778 779 1.648 0.8 13.184 37
I779 0 779 1.26158e-02
R783 779 780 1.664 0.8 13.312 37
I780 0 780 1.31105e-02
R784 780 781 1.648 0.8 13.184 37
I781 0 781 1.32342e-02
R785 781 782 1.728 0.8 13.824 37
I782 0 782 1.27395e-02
R786 782 783 1.68 0.8 13.44 37
I783 0 783 1.28631e-02
R787 783 784 1.696 0.8 13.568 37
I784 0 784 1.26158e-02
R788 784 785 1.696 0.8 13.568 37
I785 0 785 1.28631e-02
R789 785 786 1.616 0.8 12.928 37
I786 0 786 1.23684e-02
R790 786 787 1.6 0.8 12.8 37
I787 0 787 1.33579e-02
R791 787 788 1.664 0.8 13.312 37
I788 0 788 1.32342e-02
R792 788 789 1.712 0.8 13.696 37
I789 0 789 1.27395e-02
R793 789 790 1.6 0.8 12.8 37
I790 0 790 1.33579e-02
R794 790 791 1.664 0.8 13.312 37
I791 0 791 1.28631e-02
R795 791 792 1.6 0.8 12.8 37
I792 0 792 1.28631e-02
R796 792 793 1.616 0.8 12.928 37
I793 0 793 1.29868e-02
R797 793 794 1.664 0.8 13.312 37
I794 0 794 1.27395e-02
R798 794 795 1.616 0.8 12.928 37
I795 0 795 1.24921e-02
R799 795 796 1.744 0.8 13.952 37
I796 0 796 1.33579e-02
R800 796 797 1.68 0.8 13.44 37
I797 0 797 1.24921e-02
R801 797 798 1.712 0.8 13.696 37
I798 0 798 1.29868e-02
R802 798 799 1.632 0.8 13.056 37
I799 0 799 1.32342e-02
R803 799 800 1.648 0.8 13.184 37
I800 0 800 1.26158e-02
R804 800 801 1.728 0.8 13.824 37
I801 0 801 1.28631e-02
R805 801 802 1.744 0.8 13.952 37
I802 0 802 1.34816e-02
R806 802 803 1.632 0.8 13.056 37
I803 0 803 1.23684e-02
R807 803 804 1.696 0.8 13.568 37
I804 0 804 1.31105e-02
R808 804 805 1.616 0.8 12.928 37
I805 0 805 1.32342e-02
R809 805 806 1.616 0.8 12.928 37
I806 0 806 1.27395e-02
R810 806 807 1.712 0.8 13.696 37
I807 0 807 1.34816e-02
R811 807 808 1.648 0.8 13.184 37
I808 0 808 1.33579e-02
R812 808 809 1.712 0.8 13.696 37
I809 0 809 1.27395e-02
R813 809 810 1.696 0.8 13.568 37
I810 0 810 1.34816e-02
R814 810 811 1.664 0.8 13.312 37
I811 0 811 1.28631e-02
R815 811 812 1.632 0.8 13.056 37
I812 0 812 1.28631e-02
R816 812 813 1.664 0.8 13.312 37
I813 0 813 1.29868e-02
R817 813 814 1.664 0.8 13.312 37
I814 0 814 1.31105e-02
R818 814 815 1.664 0.8 13.312 37
I815 0 815 1.29868e-02
R819 815 816 1.696 0.8 13.568 37
I816 0 816 1.29868e-02
R820 816 817 1.632 0.8 13.056 37
I817 0 817 1.27395e-02
R821 817 818 1.712 0.8 13.696 37
I818 0 818 1.31105e-02
R822 818 819 1.664 0.8 13.312 37
I819 0 819 1.26158e-02
R823 819 820 1.616 0.8 12.928 37
I820 0 820 1.23684e-02
R824 820 821 1.68 0.8 13.44 37
I821 0 821 1.23684e-02
R825 821 822 1.632 0.8 13.056 37
I822 0 822 1.28631e-02
R826 822 823 1.744 0.8 13.952 37
I823 0 823 1.24921e-02
R827 823 824 1.68 0.8 13.44 37
I824 0 824 1.28631e-02
R828 824 825 1.712 0.8 13.696 37
I825 0 825 1.34816e-02
R829 825 826 1.648 0.8 13.184 37
I826 0 826 1.24921e-02
R830 826 827 1.648 0.8 13.184 37
I827 0 827 1.28631e-02
R831 827 828 1.616 0.8 12.928 37
I828 0 828 1.24921e-02
R832 828 829 1.648 0.8 13.184 37
I829 0 829 1.33579e-02
R833 829 830 1.744 0.8 13.952 37
I830 0 830 1.34816e-02
R834 830 831 1.632 0.8 13.056 37
I831 0 831 1.34816e-02
R835 831 832 1.744 0.8 13.952 37
I832 0 832 1.28631e-02
R836 832 833 1.712 0.8 13.696 37
I833 0 833 1.26158e-02
R837 833 834 1.728 0.8 13.824 37
I834 0 834 1.23684e-02
R838 834 835 1.728 0.8 13.824 37
I835 0 835 1.32342e-02
R839 835 836 1.632 0.8 13.056 37
I836 0 836 1.23684e-02
R840 836 837 1.696 0.8 13.568 37
I837 0 837 1.33579e-02
R841 837 838 1.712 0.8 13.696 37
I838 0 838 1.32342e-02
R842 838 839 1.744 0.8 13.952 37
I839 0 839 1.34816e-02
R843 839 840 1.6 0.8 12.8 37
I840 0 840 1.29868e-02
R844 840 841 1.68 0.8 13.44 37
I841 0 841 1.33579e-02
R845 841 842 1.648 0.8 13.184 37
I842 0 842 1.26158e-02
R846 842 843 1.664 0.8 13.312 37
I843 0 843 1.29868e-02
R847 843 844 1.712 0.8 13.696 37
I844 0 844 1.32342e-02
R848 844 845 1.648 0.8 13.184 37
I845 0 845 1.31105e-02
R849 845 846 1.696 0.8 13.568 37
I846 0 846 1.34816e-02
R850 846 847 1.632 0.8 13.056 37
I847 0 847 1.32342e-02
R851 847 848 1.696 0.8 13.568 37
I848 0 848 1.23684e-02
R852 848 849 1.696 0.8 13.568 37
I849 0 849 1.34816e-02
R853 849 850 1.744 0.8 13.952 37
I850 0 850 1.27395e-02
R854 850 851 1.68 0.8 13.44 37
I851 0 851 1.26158e-02
R855 851 852 1.712 0.8 13.696 37
I852 0 852 1.27395e-02
R856 852 853 1.68 0.8 13.44 37
I853 0 853 1.23684e-02
R857 853 854 1.616 0.8 12.928 37
I854 0 854 1.27395e-02
R858 854 855 1.648 0.8 13.184 37
I855 0 855 1.32342e-02
R859 855 856 1.664 0.8 13.312 37
I856 0 856 1.33579e-02
R860 856 857 1.664 0.8 13.312 37
I857 0 857 1.28631e-02
R861 857 858 1.728 0.8 13.824 37
I858 0 858 1.33579e-02
R862 858 859 1.696 0.8 13.568 37
I859 0 859 1.26158e-02
R863 859 860 1.6 0.8 12.8 37
I860 0 860 1.29868e-02
R864 860 861 1.696 0.8 13.568 37
I861 0 861 1.34816e-02
R865 861 862 1.648 0.8 13.184 37
I862 0 862 1.23684e-02
R866 862 863 1.744 0.8 13.952 37
I863 0 863 1.29868e-02
R867 863 864 1.648 0.8 13.184 37
I864 0 864 1.23684e-02
R868 864 865 1.664 0.8 13.312 37
I865 0 865 1.23684e-02
R869 865 866 1.6 0.8 12.8 37
I866 0 866 1.27395e-02
R870 866 867 1.632 0.8 13.056 37
I867 0 867 1.32342e-02
R871 867 868 1.712 0.8 13.696 37
I868 0 868 1.32342e-02
R872 868 869 1.616 0.8 12.928 37
I869 0 869 1.24921e-02
R873 869 870 1.696 0.8 13.568 37
I870 0 870 1.33579e-02
R874 870 871 1.696 0.8 13.568 37
I871 0 871 1.26158e-02
R875 871 872 1.6 0.8 12.8 37
I872 0 872 1.28631e-02
R876 872 873 1.632 0.8 13.056 37
I873 0 873 1.23684e-02
R877 873 874 1.616 0.8 12.928 37
I874 0 874 1.32342e-02
R878 874 875 1.616 0.8 12.928 37
I875 0 875 1.33579e-02
R879 875 876 1.68 0.8 13.44 37
I876 0 876 1.29868e-02
R880 876 877 1.744 0.8 13.952 37
I877 0 877 1.33579e-02
R881 877 878 1.68 0.8 13.44 37
I878 0 878 1.28631e-02
R882 878 879 1.728 0.8 13.824 37
I879 0 879 1.28631e-02
R883 879 880 1.648 0.8 13.184 37
I880 0 880 1.29868e-02
R884 880 881 1.744 0.8 13.952 37
I881 0 881 1.29868e-02
R885 881 882 1.6 0.8 12.8 37
I882 0 882 1.27395e-02
R886 882 883 1.648 0.8 13.184 37
I883 0 883 1.27395e-02
R887 883 884 1.696 0.8 13.568 37
I884 0 884 1.33579e-02
R888 884 885 1.744 0.8 13.952 37
I885 0 885 1.31105e-02
R889 885 886 1.6 0.8 12.8 37
I886 0 886 1.31105e-02
R890 886 887 1.696 0.8 13.568 37
I887 0 887 1.28631e-02
R891 887 888 1.696 0.8 13.568 37
I888 0 888 1.33579e-02
R892 888 889 1.648 0.8 13.184 37
I889 0 889 1.32342e-02
R893 889 890 1.696 0.8 13.568 37
I890 0 890 1.23684e-02
R894 890 891 1.616 0.8 12.928 37
I891 0 891 1.27395e-02
R895 891 892 1.744 0.8 13.952 37
I892 0 892 1.32342e-02
R896 892 893 1.744 0.8 13.952 37
I893 0 893 1.28631e-02
R897 893 894 1.664 0.8 13.312 37
I894 0 894 1.32342e-02
R898 894 895 1.664 0.8 13.312 37
I895 0 895 1.32342e-02
R899 895 896 1.696 0.8 13.568 37
I896 0 896 1.23684e-02
R900 896 897 1.728 0.8 13.824 37
I897 0 897 1.26158e-02
R901 897 898 1.68 0.8 13.44 37
I898 0 898 1.27395e-02
R902 898 899 1.712 0.8 13.696 37
I899 0 899 1.32342e-02
R903 899 900 1.728 0.8 13.824 37
I900 0 900 1.23684e-02
R904 900 901 1.728 0.8 13.824 37
I901 0 901 1.32342e-02
R905 901 902 1.696 0.8 13.568 37
I902 0 902 1.26158e-02
R906 902 903 1.664 0.8 13.312 37
I903 0 903 1.31105e-02
R907 903 904 1.728 0.8 13.824 37
I904 0 904 1.34816e-02
R908 904 905 1.648 0.8 13.184 37
I905 0 905 1.24921e-02
R909 905 906 1.6 0.8 12.8 37
I906 0 906 1.32342e-02
R910 906 907 1.648 0.8 13.184 37
I907 0 907 1.31105e-02
R911 907 908 1.616 0.8 12.928 37
I908 0 908 1.31105e-02
R912 908 909 1.648 0.8 13.184 37
I909 0 909 1.27395e-02
R913 909 910 1.728 0.8 13.824 37
I910 0 910 1.29868e-02
R914 910 911 1.664 0.8 13.312 37
I911 0 911 1.31105e-02
R915 911 912 1.744 0.8 13.952 37
I912 0 912 1.23684e-02
R916 912 913 1.68 0.8 13.44 37
I913 0 913 1.32342e-02
R917 913 914 1.648 0.8 13.184 37
I914 0 914 1.24921e-02
R918 914 915 1.696 0.8 13.568 37
I915 0 915 1.32342e-02
R919 915 916 1.664 0.8 13.312 37
I916 0 916 1.32342e-02
R920 916 917 1.6 0.8 12.8 37
I917 0 917 1.31105e-02
R921 917 918 1.6 0.8 12.8 37
I918 0 918 1.23684e-02
R922 918 919 1.696 0.8 13.568 37
I919 0 919 1.29868e-02
R923 919 920 1.68 0.8 13.44 37
I920 0 920 1.34816e-02
R924 920 921 1.696 0.8 13.568 37
I921 0 921 1.34816e-02
R925 921 922 1.664 0.8 13.312 37
I922 0 922 1.29868e-02
R926 922 923 1.6 0.8 12.8 37
I923 0 923 1.32342e-02
R927 923 924 1.664 0.8 13.312 37
I924 0 924 1.26158e-02
R928 924 925 1.632 0.8 13.056 37
I925 0 925 1.23684e-02
R929 925 926 1.616 0.8 12.928 37
I926 0 926 1.28631e-02
R930 926 927 1.616 0.8 12.928 37
I927 0 927 1.26158e-02
R931 927 928 1.744 0.8 13.952 37
I928 0 928 1.33579e-02
R932 928 929 1.744 0.8 13.952 37
I929 0 929 1.32342e-02
R933 929 930 1.6 0.8 12.8 37
I930 0 930 1.31105e-02
R934 930 931 1.744 0.8 13.952 37
I931 0 931 1.34816e-02
R935 931 932 1.648 0.8 13.184 37
I932 0 932 1.33579e-02
R936 932 933 1.632 0.8 13.056 37
I933 0 933 1.34816e-02
R937 933 934 1.632 0.8 13.056 37
I934 0 934 1.26158e-02
R938 934 935 1.616 0.8 12.928 37
I935 0 935 1.34816e-02
R939 935 936 1.712 0.8 13.696 37
I936 0 936 1.31105e-02
R940 936 937 1.744 0.8 13.952 37
I937 0 937 1.33579e-02
R941 937 938 1.728 0.8 13.824 37
I938 0 938 1.33579e-02
R942 938 939 1.712 0.8 13.696 37
I939 0 939 1.28631e-02
R943 939 940 1.664 0.8 13.312 37
I940 0 940 1.34816e-02
R944 940 941 1.744 0.8 13.952 37
I941 0 941 1.33579e-02
R945 941 942 1.744 0.8 13.952 37
I942 0 942 1.33579e-02
R946 942 943 1.728 0.8 13.824 37
I943 0 943 1.31105e-02
R947 943 944 1.728 0.8 13.824 37
I944 0 944 1.24921e-02
R948 944 945 1.632 0.8 13.056 37
I945 0 945 1.34816e-02
R949 945 946 1.6 0.8 12.8 37
I946 0 946 1.33579e-02
R950 946 947 1.728 0.8 13.824 37
I947 0 947 1.33579e-02
R951 947 948 1.712 0.8 13.696 37
I948 0 948 1.31105e-02
R952 948 949 1.632 0.8 13.056 37
I949 0 949 1.26158e-02
R953 949 950 1.728 0.8 13.824 37
I950 0 950 1.31105e-02
R954 950 951 1.6 0.8 12.8 37
I951 0 951 1.34816e-02
R955 951 952 1.664 0.8 13.312 37
I952 0 952 1.29868e-02
R956 952 953 1.696 0.8 13.568 37
I953 0 953 1.31105e-02
R957 953 954 1.696 0.8 13.568 37
I954 0 954 1.23684e-02
R958 954 955 1.648 0.8 13.184 37
I955 0 955 1.33579e-02
R959 955 956 1.696 0.8 13.568 37
I956 0 956 1.26158e-02
R960 956 957 1.712 0.8 13.696 37
I957 0 957 1.32342e-02
R961 957 958 1.632 0.8 13.056 37
I958 0 958 1.34816e-02
R962 958 959 1.712 0.8 13.696 37
I959 0 959 1.23684e-02
R963 959 960 1.664 0.8 13.312 37
I960 0 960 1.34816e-02
R964 960 961 1.648 0.8 13.184 37
I961 0 961 1.23684e-02
R965 961 962 1.744 0.8 13.952 37
I962 0 962 1.32342e-02
R966 962 963 1.632 0.8 13.056 37
I963 0 963 1.34816e-02
R967 963 964 1.744 0.8 13.952 37
I964 0 964 1.32342e-02
R968 964 965 1.632 0.8 13.056 37
I965 0 965 1.34816e-02
R969 965 966 1.664 0.8 13.312 37
I966 0 966 1.29868e-02
R970 966 967 1.6 0.8 12.8 37
I967 0 967 1.27395e-02
R971 967 968 1.696 0.8 13.568 37
I968 0 968 1.31105e-02
R972 968 969 1.664 0.8 13.312 37
I969 0 969 1.32342e-02
R973 969 970 1.744 0.8 13.952 37
I970 0 970 1.31105e-02
R974 970 971 1.632 0.8 13.056 37
I971 0 971 1.24921e-02
R975 971 972 1.616 0.8 12.928 37
I972 0 972 1.29868e-02
R976 972 973 1.648 0.8 13.184 37
I973 0 973 1.31105e-02
R977 973 974 1.696 0.8 13.568 37
I974 0 974 1.32342e-02
R978 974 975 1.744 0.8 13.952 37
I975 0 975 1.31105e-02
R979 975 976 1.616 0.8 12.928 37
I976 0 976 1.26158e-02
R980 976 977 1.744 0.8 13.952 37
I977 0 977 1.31105e-02
R981 977 978 1.744 0.8 13.952 37
I978 0 978 1.26158e-02
R982 978 979 1.696 0.8 13.568 37
I979 0 979 1.26158e-02
R983 979 980 1.744 0.8 13.952 37
I980 0 980 1.34816e-02
R984 980 981 1.712 0.8 13.696 37
I981 0 981 1.28631e-02
R985 981 982 1.648 0.8 13.184 37
I982 0 982 1.33579e-02
R986 982 983 1.6 0.8 12.8 37
I983 0 983 1.33579e-02
R987 983 984 1.648 0.8 13.184 37
I984 0 984 1.27395e-02
R988 984 985 1.6 0.8 12.8 37
I985 0 985 1.33579e-02
R989 985 986 1.728 0.8 13.824 37
I986 0 986 1.28631e-02
R990 986 987 1.6 0.8 12.8 37
I987 0 987 1.24921e-02
R991 987 988 1.648 0.8 13.184 37
I988 0 988 1.23684e-02
R992 988 989 1.632 0.8 13.056 37
I989 0 989 1.31105e-02
R993 989 990 1.616 0.8 12.928 37
I990 0 990 1.31105e-02
R994 990 991 1.744 0.8 13.952 37
I991 0 991 1.27395e-02
R995 991 992 1.616 0.8 12.928 37
I992 0 992 1.26158e-02
R996 992 993 1.696 0.8 13.568 37
I993 0 993 1.24921e-02
R997 993 994 1.696 0.8 13.568 37
I994 0 994 1.32342e-02
R998 994 995 1.744 0.8 13.952 37
I995 0 995 1.31105e-02
R999 995 996 1.648 0.8 13.184 37
I996 0 996 1.24921e-02
R1000 996 997 1.728 0.8 13.824 37
I997 0 997 1.29868e-02
R1001 997 998 1.6 0.8 12.8 37
I998 0 998 1.32342e-02
R1002 998 999 1.728 0.8 13.824 37
I999 0 999 1.24921e-02
R1003 999 1000 1.632 0.8 13.056 37
I1000 0 1000 1.23684e-02
R1004 1000 0 0.5 10 50 37
*seg: 3
R1005 0 1001 0.4 20 80 37
I1001 0 1001 1.24921e-02
R1006 1001 1002 1.728 0.8 13.824 37
I1002 0 1002 1.28631e-02
R1007 1002 1003 1.744 0.8 13.952 37
I1003 0 1003 1.32342e-02
R1008 1003 1004 1.648 0.8 13.184 37
I1004 0 1004 1.31105e-02
R1009 1004 1005 1.648 0.8 13.184 37
I1005 0 1005 1.28631e-02
R1010 1005 1006 1.664 0.8 13.312 37
I1006 0 1006 1.29868e-02
R1011 1006 1007 1.616 0.8 12.928 37
I1007 0 1007 1.29868e-02
R1012 1007 1008 1.728 0.8 13.824 37
I1008 0 1008 1.34816e-02
R1013 1008 1009 1.68 0.8 13.44 37
I1009 0 1009 1.31105e-02
R1014 1009 1010 1.616 0.8 12.928 37
I1010 0 1010 1.26158e-02
R1015 1010 1011 1.6 0.8 12.8 37
I1011 0 1011 1.24921e-02
R1016 1011 1012 1.6 0.8 12.8 37
I1012 0 1012 1.28631e-02
R1017 1012 1013 1.712 0.8 13.696 37
I1013 0 1013 1.32342e-02
R1018 1013 1014 1.68 0.8 13.44 37
I1014 0 1014 1.26158e-02
R1019 1014 1015 1.712 0.8 13.696 37
I1015 0 1015 1.31105e-02
R1020 1015 1016 1.744 0.8 13.952 37
I1016 0 1016 1.24921e-02
R1021 1016 1017 1.696 0.8 13.568 37
I1017 0 1017 1.26158e-02
R1022 1017 1018 1.6 0.8 12.8 37
I1018 0 1018 1.26158e-02
R1023 1018 1019 1.648 0.8 13.184 37
I1019 0 1019 1.27395e-02
R1024 1019 1020 1.6 0.8 12.8 37
I1020 0 1020 1.24921e-02
R1025 1020 1021 1.648 0.8 13.184 37
I1021 0 1021 1.29868e-02
R1026 1021 1022 1.664 0.8 13.312 37
I1022 0 1022 1.27395e-02
R1027 1022 1023 1.616 0.8 12.928 37
I1023 0 1023 1.34816e-02
R1028 1023 1024 1.744 0.8 13.952 37
I1024 0 1024 1.33579e-02
R1029 1024 1025 1.632 0.8 13.056 37
I1025 0 1025 1.27395e-02
R1030 1025 1026 1.664 0.8 13.312 37
I1026 0 1026 1.26158e-02
R1031 1026 1027 1.664 0.8 13.312 37
I1027 0 1027 1.31105e-02
R1032 1027 1028 1.664 0.8 13.312 37
I1028 0 1028 1.27395e-02
R1033 1028 1029 1.68 0.8 13.44 37
I1029 0 1029 1.32342e-02
R1034 1029 1030 1.6 0.8 12.8 37
I1030 0 1030 1.26158e-02
R1035 1030 1031 1.68 0.8 13.44 37
I1031 0 1031 1.31105e-02
R1036 1031 1032 1.648 0.8 13.184 37
I1032 0 1032 1.33579e-02
R1037 1032 1033 1.712 0.8 13.696 37
I1033 0 1033 1.23684e-02
R1038 1033 1034 1.632 0.8 13.056 37
I1034 0 1034 1.27395e-02
R1039 1034 1035 1.728 0.8 13.824 37
I1035 0 1035 1.23684e-02
R1040 1035 1036 1.648 0.8 13.184 37
I1036 0 1036 1.29868e-02
R1041 1036 1037 1.648 0.8 13.184 37
I1037 0 1037 1.28631e-02
R1042 1037 1038 1.616 0.8 12.928 37
I1038 0 1038 1.34816e-02
R1043 1038 1039 1.744 0.8 13.952 37
I1039 0 1039 1.23684e-02
R1044 1039 1040 1.68 0.8 13.44 37
I1040 0 1040 1.31105e-02
R1045 1040 1041 1.632 0.8 13.056 37
I1041 0 1041 1.34816e-02
R1046 1041 1042 1.664 0.8 13.312 37
I1042 0 1042 1.33579e-02
R1047 1042 1043 1.696 0.8 13.568 37
I1043 0 1043 1.31105e-02
R1048 1043 1044 1.6 0.8 12.8 37
I1044 0 1044 1.27395e-02
R1049 1044 1045 1.648 0.8 13.184 37
I1045 0 1045 1.28631e-02
R1050 1045 1046 1.664 0.8 13.312 37
I1046 0 1046 1.31105e-02
R1051 1046 1047 1.696 0.8 13.568 37
I1047 0 1047 1.34816e-02
R1052 1047 1048 1.616 0.8 12.928 37
I1048 0 1048 1.26158e-02
R1053 1048 1049 1.664 0.8 13.312 37
I1049 0 1049 1.26158e-02
R1054 1049 1050 1.632 0.8 13.056 37
I1050 0 1050 1.32342e-02
R1055 1050 1051 1.6 0.8 12.8 37
I1051 0 1051 1.29868e-02
R1056 1051 1052 1.696 0.8 13.568 37
I1052 0 1052 1.27395e-02
R1057 1052 1053 1.696 0.8 13.568 37
I1053 0 1053 1.27395e-02
R1058 1053 1054 1.728 0.8 13.824 37
I1054 0 1054 1.33579e-02
R1059 1054 1055 1.648 0.8 13.184 37
I1055 0 1055 1.33579e-02
R1060 1055 1056 1.744 0.8 13.952 37
I1056 0 1056 1.31105e-02
R1061 1056 1057 1.664 0.8 13.312 37
I1057 0 1057 1.33579e-02
R1062 1057 1058 1.68 0.8 13.44 37
I1058 0 1058 1.29868e-02
R1063 1058 1059 1.6 0.8 12.8 37
I1059 0 1059 1.31105e-02
R1064 1059 1060 1.6 0.8 12.8 37
I1060 0 1060 1.31105e-02
R1065 1060 1061 1.616 0.8 12.928 37
I1061 0 1061 1.23684e-02
R1066 1061 1062 1.712 0.8 13.696 37
I1062 0 1062 1.32342e-02
R1067 1062 1063 1.6 0.8 12.8 37
I1063 0 1063 1.24921e-02
R1068 1063 1064 1.616 0.8 12.928 37
I1064 0 1064 1.31105e-02
R1069 1064 1065 1.616 0.8 12.928 37
I1065 0 1065 1.27395e-02
R1070 1065 1066 1.744 0.8 13.952 37
I1066 0 1066 1.26158e-02
R1071 1066 1067 1.744 0.8 13.952 37
I1067 0 1067 1.33579e-02
R1072 1067 1068 1.68 0.8 13.44 37
I1068 0 1068 1.32342e-02
R1073 1068 1069 1.664 0.8 13.312 37
I1069 0 1069 1.33579e-02
R1074 1069 1070 1.696 0.8 13.568 37
I1070 0 1070 1.27395e-02
R1075 1070 1071 1.68 0.8 13.44 37
I1071 0 1071 1.23684e-02
R1076 1071 1072 1.6 0.8 12.8 37
I1072 0 1072 1.27395e-02
R1077 1072 1073 1.664 0.8 13.312 37
I1073 0 1073 1.28631e-02
R1078 1073 1074 1.664 0.8 13.312 37
I1074 0 1074 1.29868e-02
R1079 1074 1075 1.632 0.8 13.056 37
I1075 0 1075 1.28631e-02
R1080 1075 1076 1.744 0.8 13.952 37
I1076 0 1076 1.32342e-02
R1081 1076 1077 1.712 0.8 13.696 37
I1077 0 1077 1.28631e-02
R1082 1077 1078 1.6 0.8 12.8 37
I1078 0 1078 1.24921e-02
R1083 1078 1079 1.712 0.8 13.696 37
I1079 0 1079 1.29868e-02
R1084 1079 1080 1.6 0.8 12.8 37
I1080 0 1080 1.27395e-02
R1085 1080 1081 1.728 0.8 13.824 37
I1081 0 1081 1.32342e-02
R1086 1081 1082 1.632 0.8 13.056 37
I1082 0 1082 1.34816e-02
R1087 1082 1083 1.68 0.8 13.44 37
I1083 0 1083 1.32342e-02
R1088 1083 1084 1.696 0.8 13.568 37
I1084 0 1084 1.29868e-02
R1089 1084 1085 1.632 0.8 13.056 37
I1085 0 1085 1.26158e-02
R1090 1085 1086 1.744 0.8 13.952 37
I1086 0 1086 1.29868e-02
R1091 1086 1087 1.616 0.8 12.928 37
I1087 0 1087 1.28631e-02
R1092 1087 1088 1.728 0.8 13.824 37
I1088 0 1088 1.34816e-02
R1093 1088 1089 1.632 0.8 13.056 37
I1089 0 1089 1.28631e-02
R1094 1089 1090 1.696 0.8 13.568 37
I1090 0 1090 1.28631e-02
R1095 1090 1091 1.664 0.8 13.312 37
I1091 0 1091 1.34816e-02
R1096 1091 1092 1.696 0.8 13.568 37
I1092 0 1092 1.29868e-02
R1097 1092 1093 1.728 0.8 13.824 37
I1093 0 1093 1.23684e-02
R1098 1093 1094 1.728 0.8 13.824 37
I1094 0 1094 1.33579e-02
R1099 1094 1095 1.648 0.8 13.184 37
I1095 0 1095 1.29868e-02
R1100 1095 1096 1.648 0.8 13.184 37
I1096 0 1096 1.23684e-02
R1101 1096 1097 1.616 0.8 12.928 37
I1097 0 1097 1.26158e-02
R1102 1097 1098 1.648 0.8 13.184 37
I1098 0 1098 1.29868e-02
R1103 1098 1099 1.696 0.8 13.568 37
I1099 0 1099 1.33579e-02
R1104 1099 1100 1.6 0.8 12.8 37
I1100 0 1100 1.23684e-02
R1105 1100 1101 1.664 0.8 13.312 37
I1101 0 1101 1.24921e-02
R1106 1101 1102 1.6 0.8 12.8 37
I1102 0 1102 1.23684e-02
R1107 1102 1103 1.68 0.8 13.44 37
I1103 0 1103 1.31105e-02
R1108 1103 1104 1.632 0.8 13.056 37
I1104 0 1104 1.33579e-02
R1109 1104 1105 1.664 0.8 13.312 37
I1105 0 1105 1.28631e-02
R1110 1105 1106 1.712 0.8 13.696 37
I1106 0 1106 1.29868e-02
R1111 1106 1107 1.616 0.8 12.928 37
I1107 0 1107 1.29868e-02
R1112 1107 1108 1.6 0.8 12.8 37
I1108 0 1108 1.34816e-02
R1113 1108 1109 1.728 0.8 13.824 37
I1109 0 1109 1.23684e-02
R1114 1109 1110 1.632 0.8 13.056 37
I1110 0 1110 1.24921e-02
R1115 1110 1111 1.632 0.8 13.056 37
I1111 0 1111 1.34816e-02
R1116 1111 1112 1.696 0.8 13.568 37
I1112 0 1112 1.24921e-02
R1117 1112 1113 1.632 0.8 13.056 37
I1113 0 1113 1.31105e-02
R1118 1113 1114 1.744 0.8 13.952 37
I1114 0 1114 1.23684e-02
R1119 1114 1115 1.6 0.8 12.8 37
I1115 0 1115 1.31105e-02
R1120 1115 1116 1.744 0.8 13.952 37
I1116 0 1116 1.27395e-02
R1121 1116 1117 1.712 0.8 13.696 37
I1117 0 1117 1.23684e-02
R1122 1117 1118 1.744 0.8 13.952 37
I1118 0 1118 1.33579e-02
R1123 1118 1119 1.712 0.8 13.696 37
I1119 0 1119 1.23684e-02
R1124 1119 1120 1.632 0.8 13.056 37
I1120 0 1120 1.26158e-02
R1125 1120 1121 1.664 0.8 13.312 37
I1121 0 1121 1.33579e-02
R1126 1121 1122 1.728 0.8 13.824 37
I1122 0 1122 1.34816e-02
R1127 1122 1123 1.696 0.8 13.568 37
I1123 0 1123 1.28631e-02
R1128 1123 1124 1.6 0.8 12.8 37
I1124 0 1124 1.34816e-02
R1129 1124 1125 1.728 0.8 13.824 37
I1125 0 1125 1.32342e-02
R1130 1125 1126 1.744 0.8 13.952 37
I1126 0 1126 1.24921e-02
R1131 1126 1127 1.712 0.8 13.696 37
I1127 0 1127 1.33579e-02
R1132 1127 1128 1.632 0.8 13.056 37
I1128 0 1128 1.27395e-02
R1133 1128 1129 1.728 0.8 13.824 37
I1129 0 1129 1.28631e-02
R1134 1129 1130 1.632 0.8 13.056 37
I1130 0 1130 1.24921e-02
R1135 1130 1131 1.632 0.8 13.056 37
I1131 0 1131 1.26158e-02
R1136 1131 1132 1.664 0.8 13.312 37
I1132 0 1132 1.26158e-02
R1137 1132 1133 1.744 0.8 13.952 37
I1133 0 1133 1.32342e-02
R1138 1133 1134 1.616 0.8 12.928 37
I1134 0 1134 1.33579e-02
R1139 1134 1135 1.632 0.8 13.056 37
I1135 0 1135 1.34816e-02
R1140 1135 1136 1.6 0.8 12.8 37
I1136 0 1136 1.32342e-02
R1141 1136 1137 1.744 0.8 13.952 37
I1137 0 1137 1.29868e-02
R1142 1137 1138 1.712 0.8 13.696 37
I1138 0 1138 1.26158e-02
R1143 1138 1139 1.68 0.8 13.44 37
I1139 0 1139 1.29868e-02
R1144 1139 1140 1.648 0.8 13.184 37
I1140 0 1140 1.33579e-02
R1145 1140 1141 1.712 0.8 13.696 37
I1141 0 1141 1.29868e-02
R1146 1141 1142 1.696 0.8 13.568 37
I1142 0 1142 1.23684e-02
R1147 1142 1143 1.696 0.8 13.568 37
I1143 0 1143 1.27395e-02
R1148 1143 1144 1.744 0.8 13.952 37
I1144 0 1144 1.34816e-02
R1149 1144 1145 1.68 0.8 13.44 37
I1145 0 1145 1.31105e-02
R1150 1145 1146 1.664 0.8 13.312 37
I1146 0 1146 1.29868e-02
R1151 1146 1147 1.632 0.8 13.056 37
I1147 0 1147 1.26158e-02
R1152 1147 1148 1.6 0.8 12.8 37
I1148 0 1148 1.33579e-02
R1153 1148 1149 1.664 0.8 13.312 37
I1149 0 1149 1.26158e-02
R1154 1149 1150 1.728 0.8 13.824 37
I1150 0 1150 1.32342e-02
R1155 1150 1151 1.632 0.8 13.056 37
I1151 0 1151 1.31105e-02
R1156 1151 1152 1.648 0.8 13.184 37
I1152 0 1152 1.24921e-02
R1157 1152 1153 1.648 0.8 13.184 37
I1153 0 1153 1.28631e-02
R1158 1153 1154 1.712 0.8 13.696 37
I1154 0 1154 1.27395e-02
R1159 1154 1155 1.648 0.8 13.184 37
I1155 0 1155 1.31105e-02
R1160 1155 1156 1.6 0.8 12.8 37
I1156 0 1156 1.34816e-02
R1161 1156 1157 1.648 0.8 13.184 37
I1157 0 1157 1.23684e-02
R1162 1157 1158 1.632 0.8 13.056 37
I1158 0 1158 1.24921e-02
R1163 1158 1159 1.696 0.8 13.568 37
I1159 0 1159 1.34816e-02
R1164 1159 1160 1.728 0.8 13.824 37
I1160 0 1160 1.32342e-02
R1165 1160 1161 1.664 0.8 13.312 37
I1161 0 1161 1.26158e-02
R1166 1161 1162 1.616 0.8 12.928 37
I1162 0 1162 1.26158e-02
R1167 1162 1163 1.616 0.8 12.928 37
I1163 0 1163 1.23684e-02
R1168 1163 1164 1.712 0.8 13.696 37
I1164 0 1164 1.23684e-02
R1169 1164 1165 1.696 0.8 13.568 37
I1165 0 1165 1.26158e-02
R1170 1165 1166 1.744 0.8 13.952 37
I1166 0 1166 1.24921e-02
R1171 1166 1167 1.648 0.8 13.184 37
I1167 0 1167 1.27395e-02
R1172 1167 1168 1.664 0.8 13.312 37
I1168 0 1168 1.33579e-02
R1173 1168 1169 1.744 0.8 13.952 37
I1169 0 1169 1.34816e-02
R1174 1169 1170 1.6 0.8 12.8 37
I1170 0 1170 1.33579e-02
R1175 1170 1171 1.632 0.8 13.056 37
I1171 0 1171 1.32342e-02
R1176 1171 1172 1.744 0.8 13.952 37
I1172 0 1172 1.26158e-02
R1177 1172 1173 1.696 0.8 13.568 37
I1173 0 1173 1.29868e-02
R1178 1173 1174 1.632 0.8 13.056 37
I1174 0 1174 1.24921e-02
R1179 1174 1175 1.632 0.8 13.056 37
I1175 0 1175 1.27395e-02
R1180 1175 1176 1.712 0.8 13.696 37
I1176 0 1176 1.32342e-02
R1181 1176 1177 1.664 0.8 13.312 37
I1177 0 1177 1.34816e-02
R1182 1177 1178 1.664 0.8 13.312 37
I1178 0 1178 1.29868e-02
R1183 1178 1179 1.728 0.8 13.824 37
I1179 0 1179 1.23684e-02
R1184 1179 1180 1.68 0.8 13.44 37
I1180 0 1180 1.33579e-02
R1185 1180 1181 1.744 0.8 13.952 37
I1181 0 1181 1.32342e-02
R1186 1181 1182 1.68 0.8 13.44 37
I1182 0 1182 1.29868e-02
R1187 1182 1183 1.616 0.8 12.928 37
I1183 0 1183 1.33579e-02
R1188 1183 1184 1.616 0.8 12.928 37
I1184 0 1184 1.23684e-02
R1189 1184 1185 1.728 0.8 13.824 37
I1185 0 1185 1.26158e-02
R1190 1185 1186 1.648 0.8 13.184 37
I1186 0 1186 1.31105e-02
R1191 1186 1187 1.728 0.8 13.824 37
I1187 0 1187 1.24921e-02
R1192 1187 1188 1.712 0.8 13.696 37
I1188 0 1188 1.24921e-02
R1193 1188 1189 1.648 0.8 13.184 37
I1189 0 1189 1.29868e-02
R1194 1189 1190 1.664 0.8 13.312 37
I1190 0 1190 1.28631e-02
R1195 1190 1191 1.696 0.8 13.568 37
I1191 0 1191 1.26158e-02
R1196 1191 1192 1.616 0.8 12.928 37
I1192 0 1192 1.33579e-02
R1197 1192 1193 1.68 0.8 13.44 37
I1193 0 1193 1.32342e-02
R1198 1193 1194 1.616 0.8 12.928 37
I1194 0 1194 1.29868e-02
R1199 1194 1195 1.68 0.8 13.44 37
I1195 0 1195 1.24921e-02
R1200 1195 1196 1.664 0.8 13.312 37
I1196 0 1196 1.27395e-02
R1201 1196 1197 1.728 0.8 13.824 37
I1197 0 1197 1.32342e-02
R1202 1197 1198 1.648 0.8 13.184 37
I1198 0 1198 1.31105e-02
R1203 1198 1199 1.6 0.8 12.8 37
I1199 0 1199 1.27395e-02
R1204 1199 1200 1.68 0.8 13.44 37
I1200 0 1200 1.34816e-02
R1205 1200 1201 1.728 0.8 13.824 37
I1201 0 1201 1.27395e-02
R1206 1201 1202 1.648 0.8 13.184 37
I1202 0 1202 1.26158e-02
R1207 1202 1203 1.744 0.8 13.952 37
I1203 0 1203 1.28631e-02
R1208 1203 1204 1.6 0.8 12.8 37
I1204 0 1204 1.29868e-02
R1209 1204 1205 1.648 0.8 13.184 37
I1205 0 1205 1.33579e-02
R1210 1205 1206 1.68 0.8 13.44 37
I1206 0 1206 1.34816e-02
R1211 1206 1207 1.696 0.8 13.568 37
I1207 0 1207 1.34816e-02
R1212 1207 1208 1.68 0.8 13.44 37
I1208 0 1208 1.34816e-02
R1213 1208 1209 1.744 0.8 13.952 37
I1209 0 1209 1.32342e-02
R1214 1209 1210 1.648 0.8 13.184 37
I1210 0 1210 1.33579e-02
R1215 1210 1211 1.632 0.8 13.056 37
I1211 0 1211 1.33579e-02
R1216 1211 1212 1.6 0.8 12.8 37
I1212 0 1212 1.33579e-02
R1217 1212 1213 1.616 0.8 12.928 37
I1213 0 1213 1.27395e-02
R1218 1213 1214 1.696 0.8 13.568 37
I1214 0 1214 1.31105e-02
R1219 1214 1215 1.632 0.8 13.056 37
I1215 0 1215 1.27395e-02
R1220 1215 1216 1.6 0.8 12.8 37
I1216 0 1216 1.27395e-02
R1221 1216 1217 1.616 0.8 12.928 37
I1217 0 1217 1.31105e-02
R1222 1217 1218 1.616 0.8 12.928 37
I1218 0 1218 1.28631e-02
R1223 1218 1219 1.712 0.8 13.696 37
I1219 0 1219 1.28631e-02
R1224 1219 1220 1.6 0.8 12.8 37
I1220 0 1220 1.32342e-02
R1225 1220 1221 1.728 0.8 13.824 37
I1221 0 1221 1.23684e-02
R1226 1221 1222 1.616 0.8 12.928 37
I1222 0 1222 1.32342e-02
R1227 1222 1223 1.648 0.8 13.184 37
I1223 0 1223 1.29868e-02
R1228 1223 1224 1.696 0.8 13.568 37
I1224 0 1224 1.32342e-02
R1229 1224 1225 1.632 0.8 13.056 37
I1225 0 1225 1.32342e-02
R1230 1225 1226 1.664 0.8 13.312 37
I1226 0 1226 1.31105e-02
R1231 1226 1227 1.712 0.8 13.696 37
I1227 0 1227 1.29868e-02
R1232 1227 1228 1.696 0.8 13.568 37
I1228 0 1228 1.34816e-02
R1233 1228 1229 1.712 0.8 13.696 37
I1229 0 1229 1.27395e-02
R1234 1229 1230 1.6 0.8 12.8 37
I1230 0 1230 1.28631e-02
R1235 1230 1231 1.648 0.8 13.184 37
I1231 0 1231 1.32342e-02
R1236 1231 1232 1.616 0.8 12.928 37
I1232 0 1232 1.31105e-02
R1237 1232 1233 1.744 0.8 13.952 37
I1233 0 1233 1.34816e-02
R1238 1233 1234 1.632 0.8 13.056 37
I1234 0 1234 1.29868e-02
R1239 1234 1235 1.664 0.8 13.312 37
I1235 0 1235 1.23684e-02
R1240 1235 1236 1.6 0.8 12.8 37
I1236 0 1236 1.32342e-02
R1241 1236 1237 1.712 0.8 13.696 37
I1237 0 1237 1.29868e-02
R1242 1237 1238 1.632 0.8 13.056 37
I1238 0 1238 1.33579e-02
R1243 1238 1239 1.728 0.8 13.824 37
I1239 0 1239 1.29868e-02
R1244 1239 1240 1.744 0.8 13.952 37
I1240 0 1240 1.28631e-02
R1245 1240 1241 1.632 0.8 13.056 37
I1241 0 1241 1.27395e-02
R1246 1241 1242 1.712 0.8 13.696 37
I1242 0 1242 1.23684e-02
R1247 1242 1243 1.6 0.8 12.8 37
I1243 0 1243 1.28631e-02
R1248 1243 1244 1.728 0.8 13.824 37
I1244 0 1244 1.32342e-02
R1249 1244 1245 1.632 0.8 13.056 37
I1245 0 1245 1.27395e-02
R1250 1245 1246 1.728 0.8 13.824 37
I1246 0 1246 1.24921e-02
R1251 1246 1247 1.648 0.8 13.184 37
I1247 0 1247 1.32342e-02
R1252 1247 1248 1.632 0.8 13.056 37
I1248 0 1248 1.31105e-02
R1253 1248 1249 1.664 0.8 13.312 37
I1249 0 1249 1.31105e-02
R1254 1249 1250 1.68 0.8 13.44 37
I1250 0 1250 1.31105e-02
R1255 1250 1251 1.6 0.8 12.8 37
I1251 0 1251 1.28631e-02
R1256 1251 1252 1.712 0.8 13.696 37
I1252 0 1252 1.28631e-02
R1257 1252 1253 1.632 0.8 13.056 37
I1253 0 1253 1.27395e-02
R1258 1253 1254 1.68 0.8 13.44 37
I1254 0 1254 1.34816e-02
R1259 1254 1255 1.648 0.8 13.184 37
I1255 0 1255 1.34816e-02
R1260 1255 1256 1.744 0.8 13.952 37
I1256 0 1256 1.26158e-02
R1261 1256 1257 1.68 0.8 13.44 37
I1257 0 1257 1.28631e-02
R1262 1257 1258 1.632 0.8 13.056 37
I1258 0 1258 1.27395e-02
R1263 1258 1259 1.728 0.8 13.824 37
I1259 0 1259 1.27395e-02
R1264 1259 1260 1.712 0.8 13.696 37
I1260 0 1260 1.27395e-02
R1265 1260 1261 1.648 0.8 13.184 37
I1261 0 1261 1.23684e-02
R1266 1261 1262 1.6 0.8 12.8 37
I1262 0 1262 1.29868e-02
R1267 1262 1263 1.616 0.8 12.928 37
I1263 0 1263 1.24921e-02
R1268 1263 1264 1.696 0.8 13.568 37
I1264 0 1264 1.31105e-02
R1269 1264 1265 1.712 0.8 13.696 37
I1265 0 1265 1.34816e-02
R1270 1265 1266 1.616 0.8 12.928 37
I1266 0 1266 1.28631e-02
R1271 1266 1267 1.6 0.8 12.8 37
I1267 0 1267 1.27395e-02
R1272 1267 1268 1.68 0.8 13.44 37
I1268 0 1268 1.24921e-02
R1273 1268 1269 1.616 0.8 12.928 37
I1269 0 1269 1.24921e-02
R1274 1269 1270 1.68 0.8 13.44 37
I1270 0 1270 1.24921e-02
R1275 1270 1271 1.648 0.8 13.184 37
I1271 0 1271 1.29868e-02
R1276 1271 1272 1.744 0.8 13.952 37
I1272 0 1272 1.27395e-02
R1277 1272 1273 1.648 0.8 13.184 37
I1273 0 1273 1.23684e-02
R1278 1273 1274 1.68 0.8 13.44 37
I1274 0 1274 1.23684e-02
R1279 1274 1275 1.712 0.8 13.696 37
I1275 0 1275 1.29868e-02
R1280 1275 1276 1.68 0.8 13.44 37
I1276 0 1276 1.29868e-02
R1281 1276 1277 1.728 0.8 13.824 37
I1277 0 1277 1.23684e-02
R1282 1277 1278 1.696 0.8 13.568 37
I1278 0 1278 1.29868e-02
R1283 1278 1279 1.616 0.8 12.928 37
I1279 0 1279 1.34816e-02
R1284 1279 1280 1.728 0.8 13.824 37
I1280 0 1280 1.27395e-02
R1285 1280 1281 1.696 0.8 13.568 37
I1281 0 1281 1.26158e-02
R1286 1281 1282 1.664 0.8 13.312 37
I1282 0 1282 1.27395e-02
R1287 1282 1283 1.728 0.8 13.824 37
I1283 0 1283 1.29868e-02
R1288 1283 1284 1.6 0.8 12.8 37
I1284 0 1284 1.28631e-02
R1289 1284 1285 1.696 0.8 13.568 37
I1285 0 1285 1.23684e-02
R1290 1285 1286 1.664 0.8 13.312 37
I1286 0 1286 1.26158e-02
R1291 1286 1287 1.632 0.8 13.056 37
I1287 0 1287 1.29868e-02
R1292 1287 1288 1.648 0.8 13.184 37
I1288 0 1288 1.27395e-02
R1293 1288 1289 1.648 0.8 13.184 37
I1289 0 1289 1.33579e-02
R1294 1289 1290 1.664 0.8 13.312 37
I1290 0 1290 1.32342e-02
R1295 1290 1291 1.68 0.8 13.44 37
I1291 0 1291 1.28631e-02
R1296 1291 1292 1.728 0.8 13.824 37
I1292 0 1292 1.34816e-02
R1297 1292 1293 1.744 0.8 13.952 37
I1293 0 1293 1.28631e-02
R1298 1293 1294 1.648 0.8 13.184 37
I1294 0 1294 1.24921e-02
R1299 1294 1295 1.664 0.8 13.312 37
I1295 0 1295 1.32342e-02
R1300 1295 1296 1.648 0.8 13.184 37
I1296 0 1296 1.33579e-02
R1301 1296 1297 1.632 0.8 13.056 37
I1297 0 1297 1.24921e-02
R1302 1297 1298 1.68 0.8 13.44 37
I1298 0 1298 1.27395e-02
R1303 1298 1299 1.6 0.8 12.8 37
I1299 0 1299 1.33579e-02
R1304 1299 1300 1.648 0.8 13.184 37
I1300 0 1300 1.31105e-02
R1305 1300 1301 1.68 0.8 13.44 37
I1301 0 1301 1.31105e-02
R1306 1301 1302 1.68 0.8 13.44 37
I1302 0 1302 1.26158e-02
R1307 1302 1303 1.664 0.8 13.312 37
I1303 0 1303 1.26158e-02
R1308 1303 1304 1.6 0.8 12.8 37
I1304 0 1304 1.33579e-02
R1309 1304 1305 1.712 0.8 13.696 37
I1305 0 1305 1.23684e-02
R1310 1305 1306 1.744 0.8 13.952 37
I1306 0 1306 1.32342e-02
R1311 1306 1307 1.728 0.8 13.824 37
I1307 0 1307 1.23684e-02
R1312 1307 1308 1.744 0.8 13.952 37
I1308 0 1308 1.23684e-02
R1313 1308 1309 1.68 0.8 13.44 37
I1309 0 1309 1.31105e-02
R1314 1309 1310 1.728 0.8 13.824 37
I1310 0 1310 1.33579e-02
R1315 1310 1311 1.648 0.8 13.184 37
I1311 0 1311 1.26158e-02
R1316 1311 1312 1.664 0.8 13.312 37
I1312 0 1312 1.24921e-02
R1317 1312 1313 1.712 0.8 13.696 37
I1313 0 1313 1.34816e-02
R1318 1313 1314 1.712 0.8 13.696 37
I1314 0 1314 1.34816e-02
R1319 1314 1315 1.728 0.8 13.824 37
I1315 0 1315 1.32342e-02
R1320 1315 1316 1.664 0.8 13.312 37
I1316 0 1316 1.26158e-02
R1321 1316 1317 1.696 0.8 13.568 37
I1317 0 1317 1.34816e-02
R1322 1317 1318 1.632 0.8 13.056 37
I1318 0 1318 1.31105e-02
R1323 1318 1319 1.712 0.8 13.696 37
I1319 0 1319 1.27395e-02
R1324 1319 1320 1.712 0.8 13.696 37
I1320 0 1320 1.28631e-02
R1325 1320 1321 1.68 0.8 13.44 37
I1321 0 1321 1.31105e-02
R1326 1321 1322 1.712 0.8 13.696 37
I1322 0 1322 1.32342e-02
R1327 1322 1323 1.728 0.8 13.824 37
I1323 0 1323 1.33579e-02
R1328 1323 1324 1.68 0.8 13.44 37
I1324 0 1324 1.34816e-02
R1329 1324 1325 1.728 0.8 13.824 37
I1325 0 1325 1.23684e-02
R1330 1325 1326 1.696 0.8 13.568 37
I1326 0 1326 1.32342e-02
R1331 1326 1327 1.664 0.8 13.312 37
I1327 0 1327 1.32342e-02
R1332 1327 1328 1.712 0.8 13.696 37
I1328 0 1328 1.23684e-02
R1333 1328 1329 1.632 0.8 13.056 37
I1329 0 1329 1.32342e-02
R1334 1329 1330 1.648 0.8 13.184 37
I1330 0 1330 1.31105e-02
R1335 1330 1331 1.664 0.8 13.312 37
I1331 0 1331 1.31105e-02
R1336 1331 1332 1.632 0.8 13.056 37
I1332 0 1332 1.31105e-02
R1337 1332 1333 1.728 0.8 13.824 37
I1333 0 1333 1.24921e-02
R1338 1333 1334 1.712 0.8 13.696 37
I1334 0 1334 1.29868e-02
R1339 1334 1335 1.712 0.8 13.696 37
I1335 0 1335 1.31105e-02
R1340 1335 1336 1.712 0.8 13.696 37
I1336 0 1336 1.34816e-02
R1341 1336 1337 1.648 0.8 13.184 37
I1337 0 1337 1.32342e-02
R1342 1337 1338 1.664 0.8 13.312 37
I1338 0 1338 1.34816e-02
R1343 1338 1339 1.616 0.8 12.928 37
I1339 0 1339 1.28631e-02
R1344 1339 1340 1.6 0.8 12.8 37
I1340 0 1340 1.32342e-02
R1345 1340 1341 1.616 0.8 12.928 37
I1341 0 1341 1.24921e-02
R1346 1341 1342 1.728 0.8 13.824 37
I1342 0 1342 1.31105e-02
R1347 1342 1343 1.744 0.8 13.952 37
I1343 0 1343 1.33579e-02
R1348 1343 1344 1.68 0.8 13.44 37
I1344 0 1344 1.23684e-02
R1349 1344 1345 1.616 0.8 12.928 37
I1345 0 1345 1.32342e-02
R1350 1345 1346 1.632 0.8 13.056 37
I1346 0 1346 1.33579e-02
R1351 1346 1347 1.632 0.8 13.056 37
I1347 0 1347 1.26158e-02
R1352 1347 1348 1.616 0.8 12.928 37
I1348 0 1348 1.24921e-02
R1353 1348 1349 1.712 0.8 13.696 37
I1349 0 1349 1.27395e-02
R1354 1349 1350 1.648 0.8 13.184 37
I1350 0 1350 1.28631e-02
R1355 1350 1351 1.664 0.8 13.312 37
I1351 0 1351 1.27395e-02
R1356 1351 1352 1.712 0.8 13.696 37
I1352 0 1352 1.34816e-02
R1357 1352 1353 1.616 0.8 12.928 37
I1353 0 1353 1.29868e-02
R1358 1353 1354 1.616 0.8 12.928 37
I1354 0 1354 1.31105e-02
R1359 1354 1355 1.648 0.8 13.184 37
I1355 0 1355 1.32342e-02
R1360 1355 1356 1.6 0.8 12.8 37
I1356 0 1356 1.28631e-02
R1361 1356 1357 1.728 0.8 13.824 37
I1357 0 1357 1.24921e-02
R1362 1357 1358 1.728 0.8 13.824 37
I1358 0 1358 1.23684e-02
R1363 1358 1359 1.68 0.8 13.44 37
I1359 0 1359 1.27395e-02
R1364 1359 1360 1.68 0.8 13.44 37
I1360 0 1360 1.31105e-02
R1365 1360 1361 1.712 0.8 13.696 37
I1361 0 1361 1.24921e-02
R1366 1361 1362 1.744 0.8 13.952 37
I1362 0 1362 1.31105e-02
R1367 1362 1363 1.664 0.8 13.312 37
I1363 0 1363 1.34816e-02
R1368 1363 1364 1.68 0.8 13.44 37
I1364 0 1364 1.23684e-02
R1369 1364 1365 1.6 0.8 12.8 37
I1365 0 1365 1.23684e-02
R1370 1365 1366 1.648 0.8 13.184 37
I1366 0 1366 1.27395e-02
R1371 1366 1367 1.664 0.8 13.312 37
I1367 0 1367 1.31105e-02
R1372 1367 1368 1.6 0.8 12.8 37
I1368 0 1368 1.34816e-02
R1373 1368 1369 1.712 0.8 13.696 37
I1369 0 1369 1.26158e-02
R1374 1369 1370 1.696 0.8 13.568 37
I1370 0 1370 1.28631e-02
R1375 1370 1371 1.6 0.8 12.8 37
I1371 0 1371 1.33579e-02
R1376 1371 1372 1.6 0.8 12.8 37
I1372 0 1372 1.26158e-02
R1377 1372 1373 1.696 0.8 13.568 37
I1373 0 1373 1.24921e-02
R1378 1373 1374 1.696 0.8 13.568 37
I1374 0 1374 1.32342e-02
R1379 1374 1375 1.648 0.8 13.184 37
I1375 0 1375 1.34816e-02
R1380 1375 1376 1.632 0.8 13.056 37
I1376 0 1376 1.26158e-02
R1381 1376 1377 1.696 0.8 13.568 37
I1377 0 1377 1.31105e-02
R1382 1377 1378 1.712 0.8 13.696 37
I1378 0 1378 1.32342e-02
R1383 1378 1379 1.68 0.8 13.44 37
I1379 0 1379 1.32342e-02
R1384 1379 1380 1.744 0.8 13.952 37
I1380 0 1380 1.34816e-02
R1385 1380 1381 1.632 0.8 13.056 37
I1381 0 1381 1.34816e-02
R1386 1381 1382 1.632 0.8 13.056 37
I1382 0 1382 1.29868e-02
R1387 1382 1383 1.744 0.8 13.952 37
I1383 0 1383 1.23684e-02
R1388 1383 1384 1.616 0.8 12.928 37
I1384 0 1384 1.26158e-02
R1389 1384 1385 1.648 0.8 13.184 37
I1385 0 1385 1.34816e-02
R1390 1385 1386 1.696 0.8 13.568 37
I1386 0 1386 1.28631e-02
R1391 1386 1387 1.6 0.8 12.8 37
I1387 0 1387 1.33579e-02
R1392 1387 1388 1.664 0.8 13.312 37
I1388 0 1388 1.24921e-02
R1393 1388 1389 1.616 0.8 12.928 37
I1389 0 1389 1.27395e-02
R1394 1389 1390 1.744 0.8 13.952 37
I1390 0 1390 1.28631e-02
R1395 1390 1391 1.68 0.8 13.44 37
I1391 0 1391 1.26158e-02
R1396 1391 1392 1.728 0.8 13.824 37
I1392 0 1392 1.29868e-02
R1397 1392 1393 1.648 0.8 13.184 37
I1393 0 1393 1.33579e-02
R1398 1393 1394 1.696 0.8 13.568 37
I1394 0 1394 1.24921e-02
R1399 1394 1395 1.632 0.8 13.056 37
I1395 0 1395 1.24921e-02
R1400 1395 1396 1.664 0.8 13.312 37
I1396 0 1396 1.29868e-02
R1401 1396 1397 1.648 0.8 13.184 37
I1397 0 1397 1.29868e-02
R1402 1397 1398 1.648 0.8 13.184 37
I1398 0 1398 1.24921e-02
R1403 1398 1399 1.728 0.8 13.824 37
I1399 0 1399 1.34816e-02
R1404 1399 1400 1.664 0.8 13.312 37
I1400 0 1400 1.29868e-02
R1405 1400 1401 1.728 0.8 13.824 37
I1401 0 1401 1.23684e-02
R1406 1401 1402 1.744 0.8 13.952 37
I1402 0 1402 1.24921e-02
R1407 1402 1403 1.6 0.8 12.8 37
I1403 0 1403 1.27395e-02
R1408 1403 1404 1.712 0.8 13.696 37
I1404 0 1404 1.23684e-02
R1409 1404 1405 1.68 0.8 13.44 37
I1405 0 1405 1.29868e-02
R1410 1405 1406 1.648 0.8 13.184 37
I1406 0 1406 1.33579e-02
R1411 1406 1407 1.664 0.8 13.312 37
I1407 0 1407 1.31105e-02
R1412 1407 1408 1.744 0.8 13.952 37
I1408 0 1408 1.28631e-02
R1413 1408 1409 1.664 0.8 13.312 37
I1409 0 1409 1.34816e-02
R1414 1409 1410 1.616 0.8 12.928 37
I1410 0 1410 1.27395e-02
R1415 1410 1411 1.648 0.8 13.184 37
I1411 0 1411 1.34816e-02
R1416 1411 1412 1.696 0.8 13.568 37
I1412 0 1412 1.31105e-02
R1417 1412 1413 1.68 0.8 13.44 37
I1413 0 1413 1.27395e-02
R1418 1413 1414 1.696 0.8 13.568 37
I1414 0 1414 1.29868e-02
R1419 1414 1415 1.712 0.8 13.696 37
I1415 0 1415 1.32342e-02
R1420 1415 1416 1.6 0.8 12.8 37
I1416 0 1416 1.28631e-02
R1421 1416 1417 1.728 0.8 13.824 37
I1417 0 1417 1.24921e-02
R1422 1417 1418 1.712 0.8 13.696 37
I1418 0 1418 1.29868e-02
R1423 1418 1419 1.632 0.8 13.056 37
I1419 0 1419 1.29868e-02
R1424 1419 1420 1.632 0.8 13.056 37
I1420 0 1420 1.32342e-02
R1425 1420 1421 1.6 0.8 12.8 37
I1421 0 1421 1.26158e-02
R1426 1421 1422 1.712 0.8 13.696 37
I1422 0 1422 1.29868e-02
R1427 1422 1423 1.696 0.8 13.568 37
I1423 0 1423 1.23684e-02
R1428 1423 1424 1.68 0.8 13.44 37
I1424 0 1424 1.31105e-02
R1429 1424 1425 1.728 0.8 13.824 37
I1425 0 1425 1.23684e-02
R1430 1425 1426 1.664 0.8 13.312 37
I1426 0 1426 1.26158e-02
R1431 1426 1427 1.744 0.8 13.952 37
I1427 0 1427 1.27395e-02
R1432 1427 1428 1.744 0.8 13.952 37
I1428 0 1428 1.32342e-02
R1433 1428 1429 1.696 0.8 13.568 37
I1429 0 1429 1.23684e-02
R1434 1429 1430 1.648 0.8 13.184 37
I1430 0 1430 1.28631e-02
R1435 1430 1431 1.68 0.8 13.44 37
I1431 0 1431 1.27395e-02
R1436 1431 1432 1.664 0.8 13.312 37
I1432 0 1432 1.26158e-02
R1437 1432 1433 1.6 0.8 12.8 37
I1433 0 1433 1.27395e-02
R1438 1433 1434 1.648 0.8 13.184 37
I1434 0 1434 1.33579e-02
R1439 1434 1435 1.696 0.8 13.568 37
I1435 0 1435 1.28631e-02
R1440 1435 1436 1.664 0.8 13.312 37
I1436 0 1436 1.31105e-02
R1441 1436 1437 1.632 0.8 13.056 37
I1437 0 1437 1.33579e-02
R1442 1437 1438 1.6 0.8 12.8 37
I1438 0 1438 1.33579e-02
R1443 1438 1439 1.712 0.8 13.696 37
I1439 0 1439 1.23684e-02
R1444 1439 1440 1.696 0.8 13.568 37
I1440 0 1440 1.32342e-02
R1445 1440 1441 1.68 0.8 13.44 37
I1441 0 1441 1.29868e-02
R1446 1441 1442 1.6 0.8 12.8 37
I1442 0 1442 1.28631e-02
R1447 1442 1443 1.728 0.8 13.824 37
I1443 0 1443 1.31105e-02
R1448 1443 1444 1.696 0.8 13.568 37
I1444 0 1444 1.34816e-02
R1449 1444 1445 1.728 0.8 13.824 37
I1445 0 1445 1.27395e-02
R1450 1445 1446 1.744 0.8 13.952 37
I1446 0 1446 1.26158e-02
R1451 1446 1447 1.712 0.8 13.696 37
I1447 0 1447 1.26158e-02
R1452 1447 1448 1.648 0.8 13.184 37
I1448 0 1448 1.27395e-02
R1453 1448 1449 1.68 0.8 13.44 37
I1449 0 1449 1.24921e-02
R1454 1449 1450 1.648 0.8 13.184 37
I1450 0 1450 1.27395e-02
R1455 1450 1451 1.664 0.8 13.312 37
I1451 0 1451 1.26158e-02
R1456 1451 1452 1.696 0.8 13.568 37
I1452 0 1452 1.27395e-02
R1457 1452 1453 1.728 0.8 13.824 37
I1453 0 1453 1.24921e-02
R1458 1453 1454 1.728 0.8 13.824 37
I1454 0 1454 1.31105e-02
R1459 1454 1455 1.68 0.8 13.44 37
I1455 0 1455 1.32342e-02
R1460 1455 1456 1.744 0.8 13.952 37
I1456 0 1456 1.29868e-02
R1461 1456 1457 1.664 0.8 13.312 37
I1457 0 1457 1.28631e-02
R1462 1457 1458 1.712 0.8 13.696 37
I1458 0 1458 1.31105e-02
R1463 1458 1459 1.6 0.8 12.8 37
I1459 0 1459 1.23684e-02
R1464 1459 1460 1.616 0.8 12.928 37
I1460 0 1460 1.28631e-02
R1465 1460 1461 1.696 0.8 13.568 37
I1461 0 1461 1.34816e-02
R1466 1461 1462 1.632 0.8 13.056 37
I1462 0 1462 1.28631e-02
R1467 1462 1463 1.712 0.8 13.696 37
I1463 0 1463 1.33579e-02
R1468 1463 1464 1.632 0.8 13.056 37
I1464 0 1464 1.24921e-02
R1469 1464 1465 1.648 0.8 13.184 37
I1465 0 1465 1.27395e-02
R1470 1465 1466 1.6 0.8 12.8 37
I1466 0 1466 1.26158e-02
R1471 1466 1467 1.728 0.8 13.824 37
I1467 0 1467 1.29868e-02
R1472 1467 1468 1.616 0.8 12.928 37
I1468 0 1468 1.32342e-02
R1473 1468 1469 1.6 0.8 12.8 37
I1469 0 1469 1.33579e-02
R1474 1469 1470 1.616 0.8 12.928 37
I1470 0 1470 1.27395e-02
R1475 1470 1471 1.664 0.8 13.312 37
I1471 0 1471 1.29868e-02
R1476 1471 1472 1.6 0.8 12.8 37
I1472 0 1472 1.27395e-02
R1477 1472 1473 1.632 0.8 13.056 37
I1473 0 1473 1.26158e-02
R1478 1473 1474 1.664 0.8 13.312 37
I1474 0 1474 1.28631e-02
R1479 1474 1475 1.648 0.8 13.184 37
I1475 0 1475 1.34816e-02
R1480 1475 1476 1.616 0.8 12.928 37
I1476 0 1476 1.34816e-02
R1481 1476 1477 1.632 0.8 13.056 37
I1477 0 1477 1.33579e-02
R1482 1477 1478 1.712 0.8 13.696 37
I1478 0 1478 1.33579e-02
R1483 1478 1479 1.616 0.8 12.928 37
I1479 0 1479 1.24921e-02
R1484 1479 1480 1.664 0.8 13.312 37
I1480 0 1480 1.33579e-02
R1485 1480 1481 1.664 0.8 13.312 37
I1481 0 1481 1.24921e-02
R1486 1481 1482 1.728 0.8 13.824 37
I1482 0 1482 1.29868e-02
R1487 1482 1483 1.6 0.8 12.8 37
I1483 0 1483 1.27395e-02
R1488 1483 1484 1.728 0.8 13.824 37
I1484 0 1484 1.28631e-02
R1489 1484 1485 1.616 0.8 12.928 37
I1485 0 1485 1.29868e-02
R1490 1485 1486 1.696 0.8 13.568 37
I1486 0 1486 1.28631e-02
R1491 1486 1487 1.696 0.8 13.568 37
I1487 0 1487 1.23684e-02
R1492 1487 1488 1.664 0.8 13.312 37
I1488 0 1488 1.33579e-02
R1493 1488 1489 1.664 0.8 13.312 37
I1489 0 1489 1.24921e-02
R1494 1489 1490 1.6 0.8 12.8 37
I1490 0 1490 1.29868e-02
R1495 1490 1491 1.632 0.8 13.056 37
I1491 0 1491 1.33579e-02
R1496 1491 1492 1.68 0.8 13.44 37
I1492 0 1492 1.23684e-02
R1497 1492 1493 1.6 0.8 12.8 37
I1493 0 1493 1.31105e-02
R1498 1493 1494 1.68 0.8 13.44 37
I1494 0 1494 1.29868e-02
R1499 1494 1495 1.696 0.8 13.568 37
I1495 0 1495 1.33579e-02
R1500 1495 1496 1.632 0.8 13.056 37
I1496 0 1496 1.34816e-02
R1501 1496 1497 1.632 0.8 13.056 37
I1497 0 1497 1.27395e-02
R1502 1497 1498 1.6 0.8 12.8 37
I1498 0 1498 1.28631e-02
R1503 1498 1499 1.664 0.8 13.312 37
I1499 0 1499 1.27395e-02
R1504 1499 1500 1.712 0.8 13.696 37
I1500 0 1500 1.23684e-02
R1505 1500 0 0.5 10 50 37

.op
.end
