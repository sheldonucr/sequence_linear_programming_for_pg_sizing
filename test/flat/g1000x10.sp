num_node 10000
matrix_size 10000

* 1000 x 10 ground network
*seg: 1
R1 0 1 0.1 49.28 49.28 37
R2 5 15 6.16 0.8 49.28 37
I1 0 1 1.33579e-05
R3 1 2 1.728 0.8 13.824 37
I2 0 2 1.27395e-05
R4 2 3 1.68 0.8 13.44 37
I3 0 3 1.24921e-05
R5 3 4 1.712 0.8 13.696 37
I4 0 4 1.23684e-05
R6 4 5 1.744 0.8 13.952 37
I5 0 5 1.26158e-05
R7 5 6 1.696 0.8 13.568 37
I6 0 6 1.34816e-05
R8 6 7 1.712 0.8 13.696 37
I7 0 7 1.28631e-05
R9 7 8 1.6 0.8 12.8 37
I8 0 8 1.29868e-05
R10 8 9 1.648 0.8 13.184 37
I9 0 9 1.34816e-05
R11 9 10 1.648 0.8 13.184 37
I10 0 10 1.23684e-05
R12 10 0 0.1 49.28 49.28 37
*seg: 2
R13 0 11 0.1 49.28 49.28 37
R14 15 25 6.16 0.8 49.28 37
I11 0 11 1.32342e-05
R15 11 12 1.696 0.8 13.568 37
I12 0 12 1.31105e-05
R16 12 13 1.728 0.8 13.824 37
I13 0 13 1.29868e-05
R17 13 14 1.616 0.8 12.928 37
I14 0 14 1.32342e-05
R18 14 15 1.664 0.8 13.312 37
I15 0 15 1.24921e-05
R19 15 16 1.68 0.8 13.44 37
I16 0 16 1.26158e-05
R20 16 17 1.696 0.8 13.568 37
I17 0 17 1.28631e-05
R21 17 18 1.68 0.8 13.44 37
I18 0 18 1.28631e-05
R22 18 19 1.632 0.8 13.056 37
I19 0 19 1.24921e-05
R23 19 20 1.712 0.8 13.696 37
I20 0 20 1.23684e-05
R24 20 0 0.1 49.28 49.28 37
*seg: 3
R25 0 21 0.1 49.28 49.28 37
R26 25 35 6.16 0.8 49.28 37
I21 0 21 1.28631e-05
R27 21 22 1.648 0.8 13.184 37
I22 0 22 1.24921e-05
R28 22 23 1.696 0.8 13.568 37
I23 0 23 1.33579e-05
R29 23 24 1.728 0.8 13.824 37
I24 0 24 1.29868e-05
R30 24 25 1.648 0.8 13.184 37
I25 0 25 1.32342e-05
R31 25 26 1.696 0.8 13.568 37
I26 0 26 1.29868e-05
R32 26 27 1.648 0.8 13.184 37
I27 0 27 1.26158e-05
R33 27 28 1.664 0.8 13.312 37
I28 0 28 1.27395e-05
R34 28 29 1.6 0.8 12.8 37
I29 0 29 1.28631e-05
R35 29 30 1.648 0.8 13.184 37
I30 0 30 1.23684e-05
R36 30 0 0.1 49.28 49.28 37
*seg: 4
R37 0 31 0.1 49.28 49.28 37
R38 35 45 6.16 0.8 49.28 37
I31 0 31 1.26158e-05
R39 31 32 1.728 0.8 13.824 37
I32 0 32 1.26158e-05
R40 32 33 1.712 0.8 13.696 37
I33 0 33 1.32342e-05
R41 33 34 1.68 0.8 13.44 37
I34 0 34 1.34816e-05
R42 34 35 1.648 0.8 13.184 37
I35 0 35 1.24921e-05
R43 35 36 1.664 0.8 13.312 37
I36 0 36 1.23684e-05
R44 36 37 1.744 0.8 13.952 37
I37 0 37 1.33579e-05
R45 37 38 1.712 0.8 13.696 37
I38 0 38 1.34816e-05
R46 38 39 1.696 0.8 13.568 37
I39 0 39 1.31105e-05
R47 39 40 1.6 0.8 12.8 37
I40 0 40 1.23684e-05
R48 40 0 0.1 49.28 49.28 37
*seg: 5
R49 0 41 0.1 49.28 49.28 37
R50 45 55 6.16 0.8 49.28 37
I41 0 41 1.33579e-05
R51 41 42 1.696 0.8 13.568 37
I42 0 42 1.28631e-05
R52 42 43 1.632 0.8 13.056 37
I43 0 43 1.31105e-05
R53 43 44 1.68 0.8 13.44 37
I44 0 44 1.24921e-05
R54 44 45 1.664 0.8 13.312 37
I45 0 45 1.27395e-05
R55 45 46 1.632 0.8 13.056 37
I46 0 46 1.27395e-05
R56 46 47 1.696 0.8 13.568 37
I47 0 47 1.23684e-05
R57 47 48 1.744 0.8 13.952 37
I48 0 48 1.24921e-05
R58 48 49 1.616 0.8 12.928 37
I49 0 49 1.31105e-05
R59 49 50 1.616 0.8 12.928 37
I50 0 50 1.23684e-05
R60 50 0 0.1 49.28 49.28 37
*seg: 6
R61 0 51 0.1 49.28 49.28 37
R62 55 65 6.16 0.8 49.28 37
I51 0 51 1.23684e-05
R63 51 52 1.68 0.8 13.44 37
I52 0 52 1.34816e-05
R64 52 53 1.664 0.8 13.312 37
I53 0 53 1.29868e-05
R65 53 54 1.648 0.8 13.184 37
I54 0 54 1.28631e-05
R66 54 55 1.744 0.8 13.952 37
I55 0 55 1.33579e-05
R67 55 56 1.616 0.8 12.928 37
I56 0 56 1.26158e-05
R68 56 57 1.616 0.8 12.928 37
I57 0 57 1.28631e-05
R69 57 58 1.712 0.8 13.696 37
I58 0 58 1.26158e-05
R70 58 59 1.68 0.8 13.44 37
I59 0 59 1.31105e-05
R71 59 60 1.648 0.8 13.184 37
I60 0 60 1.23684e-05
R72 60 0 0.1 49.28 49.28 37
*seg: 7
R73 0 61 0.1 49.28 49.28 37
R74 65 75 6.16 0.8 49.28 37
I61 0 61 1.31105e-05
R75 61 62 1.664 0.8 13.312 37
I62 0 62 1.24921e-05
R76 62 63 1.728 0.8 13.824 37
I63 0 63 1.27395e-05
R77 63 64 1.664 0.8 13.312 37
I64 0 64 1.27395e-05
R78 64 65 1.6 0.8 12.8 37
I65 0 65 1.33579e-05
R79 65 66 1.6 0.8 12.8 37
I66 0 66 1.23684e-05
R80 66 67 1.744 0.8 13.952 37
I67 0 67 1.31105e-05
R81 67 68 1.632 0.8 13.056 37
I68 0 68 1.31105e-05
R82 68 69 1.712 0.8 13.696 37
I69 0 69 1.27395e-05
R83 69 70 1.6 0.8 12.8 37
I70 0 70 1.23684e-05
R84 70 0 0.1 49.28 49.28 37
*seg: 8
R85 0 71 0.1 49.28 49.28 37
R86 75 85 6.16 0.8 49.28 37
I71 0 71 1.24921e-05
R87 71 72 1.744 0.8 13.952 37
I72 0 72 1.31105e-05
R88 72 73 1.68 0.8 13.44 37
I73 0 73 1.29868e-05
R89 73 74 1.632 0.8 13.056 37
I74 0 74 1.23684e-05
R90 74 75 1.6 0.8 12.8 37
I75 0 75 1.26158e-05
R91 75 76 1.68 0.8 13.44 37
I76 0 76 1.23684e-05
R92 76 77 1.6 0.8 12.8 37
I77 0 77 1.34816e-05
R93 77 78 1.664 0.8 13.312 37
I78 0 78 1.29868e-05
R94 78 79 1.68 0.8 13.44 37
I79 0 79 1.29868e-05
R95 79 80 1.68 0.8 13.44 37
I80 0 80 1.23684e-05
R96 80 0 0.1 49.28 49.28 37
*seg: 9
R97 0 81 0.1 49.28 49.28 37
R98 85 95 6.16 0.8 49.28 37
I81 0 81 1.28631e-05
R99 81 82 1.616 0.8 12.928 37
I82 0 82 1.31105e-05
R100 82 83 1.712 0.8 13.696 37
I83 0 83 1.27395e-05
R101 83 84 1.712 0.8 13.696 37
I84 0 84 1.34816e-05
R102 84 85 1.712 0.8 13.696 37
I85 0 85 1.27395e-05
R103 85 86 1.744 0.8 13.952 37
I86 0 86 1.29868e-05
R104 86 87 1.696 0.8 13.568 37
I87 0 87 1.27395e-05
R105 87 88 1.616 0.8 12.928 37
I88 0 88 1.27395e-05
R106 88 89 1.712 0.8 13.696 37
I89 0 89 1.34816e-05
R107 89 90 1.712 0.8 13.696 37
I90 0 90 1.23684e-05
R108 90 0 0.1 49.28 49.28 37
*seg: 10
R109 0 91 0.1 49.28 49.28 37
R110 95 105 6.16 0.8 49.28 37
I91 0 91 1.27395e-05
R111 91 92 1.728 0.8 13.824 37
I92 0 92 1.31105e-05
R112 92 93 1.616 0.8 12.928 37
I93 0 93 1.31105e-05
R113 93 94 1.696 0.8 13.568 37
I94 0 94 1.31105e-05
R114 94 95 1.728 0.8 13.824 37
I95 0 95 1.33579e-05
R115 95 96 1.696 0.8 13.568 37
I96 0 96 1.27395e-05
R116 96 97 1.712 0.8 13.696 37
I97 0 97 1.24921e-05
R117 97 98 1.712 0.8 13.696 37
I98 0 98 1.26158e-05
R118 98 99 1.728 0.8 13.824 37
I99 0 99 1.24921e-05
R119 99 100 1.648 0.8 13.184 37
I100 0 100 1.23684e-05
R120 100 0 0.1 49.28 49.28 37
*seg: 11
R121 0 101 0.1 49.28 49.28 37
R122 105 115 6.16 0.8 49.28 37
I101 0 101 1.26158e-05
R123 101 102 1.664 0.8 13.312 37
I102 0 102 1.33579e-05
R124 102 103 1.68 0.8 13.44 37
I103 0 103 1.27395e-05
R125 103 104 1.744 0.8 13.952 37
I104 0 104 1.24921e-05
R126 104 105 1.696 0.8 13.568 37
I105 0 105 1.29868e-05
R127 105 106 1.728 0.8 13.824 37
I106 0 106 1.27395e-05
R128 106 107 1.68 0.8 13.44 37
I107 0 107 1.28631e-05
R129 107 108 1.744 0.8 13.952 37
I108 0 108 1.27395e-05
R130 108 109 1.616 0.8 12.928 37
I109 0 109 1.24921e-05
R131 109 110 1.696 0.8 13.568 37
I110 0 110 1.23684e-05
R132 110 0 0.1 49.28 49.28 37
*seg: 12
R133 0 111 0.1 49.28 49.28 37
R134 115 125 6.16 0.8 49.28 37
I111 0 111 1.29868e-05
R135 111 112 1.696 0.8 13.568 37
I112 0 112 1.27395e-05
R136 112 113 1.6 0.8 12.8 37
I113 0 113 1.23684e-05
R137 113 114 1.744 0.8 13.952 37
I114 0 114 1.34816e-05
R138 114 115 1.6 0.8 12.8 37
I115 0 115 1.32342e-05
R139 115 116 1.728 0.8 13.824 37
I116 0 116 1.29868e-05
R140 116 117 1.712 0.8 13.696 37
I117 0 117 1.26158e-05
R141 117 118 1.664 0.8 13.312 37
I118 0 118 1.24921e-05
R142 118 119 1.632 0.8 13.056 37
I119 0 119 1.26158e-05
R143 119 120 1.664 0.8 13.312 37
I120 0 120 1.23684e-05
R144 120 0 0.1 49.28 49.28 37
*seg: 13
R145 0 121 0.1 49.28 49.28 37
R146 125 135 6.16 0.8 49.28 37
I121 0 121 1.28631e-05
R147 121 122 1.68 0.8 13.44 37
I122 0 122 1.32342e-05
R148 122 123 1.696 0.8 13.568 37
I123 0 123 1.33579e-05
R149 123 124 1.68 0.8 13.44 37
I124 0 124 1.31105e-05
R150 124 125 1.696 0.8 13.568 37
I125 0 125 1.26158e-05
R151 125 126 1.616 0.8 12.928 37
I126 0 126 1.33579e-05
R152 126 127 1.648 0.8 13.184 37
I127 0 127 1.24921e-05
R153 127 128 1.648 0.8 13.184 37
I128 0 128 1.26158e-05
R154 128 129 1.696 0.8 13.568 37
I129 0 129 1.24921e-05
R155 129 130 1.664 0.8 13.312 37
I130 0 130 1.23684e-05
R156 130 0 0.1 49.28 49.28 37
*seg: 14
R157 0 131 0.1 49.28 49.28 37
R158 135 145 6.16 0.8 49.28 37
I131 0 131 1.33579e-05
R159 131 132 1.664 0.8 13.312 37
I132 0 132 1.34816e-05
R160 132 133 1.664 0.8 13.312 37
I133 0 133 1.24921e-05
R161 133 134 1.744 0.8 13.952 37
I134 0 134 1.29868e-05
R162 134 135 1.68 0.8 13.44 37
I135 0 135 1.28631e-05
R163 135 136 1.6 0.8 12.8 37
I136 0 136 1.26158e-05
R164 136 137 1.68 0.8 13.44 37
I137 0 137 1.34816e-05
R165 137 138 1.632 0.8 13.056 37
I138 0 138 1.23684e-05
R166 138 139 1.6 0.8 12.8 37
I139 0 139 1.29868e-05
R167 139 140 1.728 0.8 13.824 37
I140 0 140 1.23684e-05
R168 140 0 0.1 49.28 49.28 37
*seg: 15
R169 0 141 0.1 49.28 49.28 37
R170 145 155 6.16 0.8 49.28 37
I141 0 141 1.24921e-05
R171 141 142 1.744 0.8 13.952 37
I142 0 142 1.24921e-05
R172 142 143 1.632 0.8 13.056 37
I143 0 143 1.23684e-05
R173 143 144 1.696 0.8 13.568 37
I144 0 144 1.24921e-05
R174 144 145 1.6 0.8 12.8 37
I145 0 145 1.24921e-05
R175 145 146 1.712 0.8 13.696 37
I146 0 146 1.34816e-05
R176 146 147 1.6 0.8 12.8 37
I147 0 147 1.31105e-05
R177 147 148 1.648 0.8 13.184 37
I148 0 148 1.33579e-05
R178 148 149 1.648 0.8 13.184 37
I149 0 149 1.24921e-05
R179 149 150 1.616 0.8 12.928 37
I150 0 150 1.23684e-05
R180 150 0 0.1 49.28 49.28 37
*seg: 16
R181 0 151 0.1 49.28 49.28 37
R182 155 165 6.16 0.8 49.28 37
I151 0 151 1.34816e-05
R183 151 152 1.696 0.8 13.568 37
I152 0 152 1.28631e-05
R184 152 153 1.744 0.8 13.952 37
I153 0 153 1.26158e-05
R185 153 154 1.712 0.8 13.696 37
I154 0 154 1.33579e-05
R186 154 155 1.632 0.8 13.056 37
I155 0 155 1.29868e-05
R187 155 156 1.6 0.8 12.8 37
I156 0 156 1.34816e-05
R188 156 157 1.68 0.8 13.44 37
I157 0 157 1.34816e-05
R189 157 158 1.616 0.8 12.928 37
I158 0 158 1.33579e-05
R190 158 159 1.632 0.8 13.056 37
I159 0 159 1.27395e-05
R191 159 160 1.68 0.8 13.44 37
I160 0 160 1.23684e-05
R192 160 0 0.1 49.28 49.28 37
*seg: 17
R193 0 161 0.1 49.28 49.28 37
R194 165 175 6.16 0.8 49.28 37
I161 0 161 1.34816e-05
R195 161 162 1.632 0.8 13.056 37
I162 0 162 1.28631e-05
R196 162 163 1.632 0.8 13.056 37
I163 0 163 1.34816e-05
R197 163 164 1.648 0.8 13.184 37
I164 0 164 1.32342e-05
R198 164 165 1.632 0.8 13.056 37
I165 0 165 1.24921e-05
R199 165 166 1.68 0.8 13.44 37
I166 0 166 1.28631e-05
R200 166 167 1.744 0.8 13.952 37
I167 0 167 1.23684e-05
R201 167 168 1.744 0.8 13.952 37
I168 0 168 1.34816e-05
R202 168 169 1.664 0.8 13.312 37
I169 0 169 1.26158e-05
R203 169 170 1.664 0.8 13.312 37
I170 0 170 1.23684e-05
R204 170 0 0.1 49.28 49.28 37
*seg: 18
R205 0 171 0.1 49.28 49.28 37
R206 175 185 6.16 0.8 49.28 37
I171 0 171 1.23684e-05
R207 171 172 1.744 0.8 13.952 37
I172 0 172 1.29868e-05
R208 172 173 1.632 0.8 13.056 37
I173 0 173 1.29868e-05
R209 173 174 1.696 0.8 13.568 37
I174 0 174 1.27395e-05
R210 174 175 1.744 0.8 13.952 37
I175 0 175 1.33579e-05
R211 175 176 1.712 0.8 13.696 37
I176 0 176 1.34816e-05
R212 176 177 1.712 0.8 13.696 37
I177 0 177 1.28631e-05
R213 177 178 1.712 0.8 13.696 37
I178 0 178 1.23684e-05
R214 178 179 1.632 0.8 13.056 37
I179 0 179 1.34816e-05
R215 179 180 1.744 0.8 13.952 37
I180 0 180 1.23684e-05
R216 180 0 0.1 49.28 49.28 37
*seg: 19
R217 0 181 0.1 49.28 49.28 37
R218 185 195 6.16 0.8 49.28 37
I181 0 181 1.34816e-05
R219 181 182 1.648 0.8 13.184 37
I182 0 182 1.31105e-05
R220 182 183 1.632 0.8 13.056 37
I183 0 183 1.34816e-05
R221 183 184 1.648 0.8 13.184 37
I184 0 184 1.34816e-05
R222 184 185 1.696 0.8 13.568 37
I185 0 185 1.32342e-05
R223 185 186 1.616 0.8 12.928 37
I186 0 186 1.24921e-05
R224 186 187 1.6 0.8 12.8 37
I187 0 187 1.27395e-05
R225 187 188 1.68 0.8 13.44 37
I188 0 188 1.34816e-05
R226 188 189 1.6 0.8 12.8 37
I189 0 189 1.32342e-05
R227 189 190 1.664 0.8 13.312 37
I190 0 190 1.23684e-05
R228 190 0 0.1 49.28 49.28 37
*seg: 20
R229 0 191 0.1 49.28 49.28 37
R230 195 205 6.16 0.8 49.28 37
I191 0 191 1.28631e-05
R231 191 192 1.648 0.8 13.184 37
I192 0 192 1.26158e-05
R232 192 193 1.744 0.8 13.952 37
I193 0 193 1.31105e-05
R233 193 194 1.648 0.8 13.184 37
I194 0 194 1.32342e-05
R234 194 195 1.68 0.8 13.44 37
I195 0 195 1.27395e-05
R235 195 196 1.664 0.8 13.312 37
I196 0 196 1.26158e-05
R236 196 197 1.632 0.8 13.056 37
I197 0 197 1.29868e-05
R237 197 198 1.632 0.8 13.056 37
I198 0 198 1.28631e-05
R238 198 199 1.6 0.8 12.8 37
I199 0 199 1.29868e-05
R239 199 200 1.696 0.8 13.568 37
I200 0 200 1.23684e-05
R240 200 0 0.1 49.28 49.28 37
*seg: 21
R241 0 201 0.1 49.28 49.28 37
R242 205 215 6.16 0.8 49.28 37
I201 0 201 1.33579e-05
R243 201 202 1.68 0.8 13.44 37
I202 0 202 1.33579e-05
R244 202 203 1.6 0.8 12.8 37
I203 0 203 1.31105e-05
R245 203 204 1.68 0.8 13.44 37
I204 0 204 1.31105e-05
R246 204 205 1.648 0.8 13.184 37
I205 0 205 1.24921e-05
R247 205 206 1.616 0.8 12.928 37
I206 0 206 1.33579e-05
R248 206 207 1.744 0.8 13.952 37
I207 0 207 1.32342e-05
R249 207 208 1.616 0.8 12.928 37
I208 0 208 1.23684e-05
R250 208 209 1.664 0.8 13.312 37
I209 0 209 1.23684e-05
R251 209 210 1.648 0.8 13.184 37
I210 0 210 1.23684e-05
R252 210 0 0.1 49.28 49.28 37
*seg: 22
R253 0 211 0.1 49.28 49.28 37
R254 215 225 6.16 0.8 49.28 37
I211 0 211 1.33579e-05
R255 211 212 1.728 0.8 13.824 37
I212 0 212 1.28631e-05
R256 212 213 1.68 0.8 13.44 37
I213 0 213 1.29868e-05
R257 213 214 1.632 0.8 13.056 37
I214 0 214 1.33579e-05
R258 214 215 1.744 0.8 13.952 37
I215 0 215 1.29868e-05
R259 215 216 1.632 0.8 13.056 37
I216 0 216 1.33579e-05
R260 216 217 1.664 0.8 13.312 37
I217 0 217 1.33579e-05
R261 217 218 1.632 0.8 13.056 37
I218 0 218 1.28631e-05
R262 218 219 1.616 0.8 12.928 37
I219 0 219 1.28631e-05
R263 219 220 1.744 0.8 13.952 37
I220 0 220 1.23684e-05
R264 220 0 0.1 49.28 49.28 37
*seg: 23
R265 0 221 0.1 49.28 49.28 37
R266 225 235 6.16 0.8 49.28 37
I221 0 221 1.24921e-05
R267 221 222 1.632 0.8 13.056 37
I222 0 222 1.27395e-05
R268 222 223 1.728 0.8 13.824 37
I223 0 223 1.33579e-05
R269 223 224 1.648 0.8 13.184 37
I224 0 224 1.32342e-05
R270 224 225 1.632 0.8 13.056 37
I225 0 225 1.29868e-05
R271 225 226 1.744 0.8 13.952 37
I226 0 226 1.29868e-05
R272 226 227 1.68 0.8 13.44 37
I227 0 227 1.29868e-05
R273 227 228 1.728 0.8 13.824 37
I228 0 228 1.27395e-05
R274 228 229 1.712 0.8 13.696 37
I229 0 229 1.33579e-05
R275 229 230 1.632 0.8 13.056 37
I230 0 230 1.23684e-05
R276 230 0 0.1 49.28 49.28 37
*seg: 24
R277 0 231 0.1 49.28 49.28 37
R278 235 245 6.16 0.8 49.28 37
I231 0 231 1.33579e-05
R279 231 232 1.68 0.8 13.44 37
I232 0 232 1.28631e-05
R280 232 233 1.6 0.8 12.8 37
I233 0 233 1.24921e-05
R281 233 234 1.68 0.8 13.44 37
I234 0 234 1.24921e-05
R282 234 235 1.616 0.8 12.928 37
I235 0 235 1.33579e-05
R283 235 236 1.664 0.8 13.312 37
I236 0 236 1.32342e-05
R284 236 237 1.68 0.8 13.44 37
I237 0 237 1.34816e-05
R285 237 238 1.68 0.8 13.44 37
I238 0 238 1.23684e-05
R286 238 239 1.712 0.8 13.696 37
I239 0 239 1.34816e-05
R287 239 240 1.712 0.8 13.696 37
I240 0 240 1.23684e-05
R288 240 0 0.1 49.28 49.28 37
*seg: 25
R289 0 241 0.1 49.28 49.28 37
R290 245 255 6.16 0.8 49.28 37
I241 0 241 1.34816e-05
R291 241 242 1.744 0.8 13.952 37
I242 0 242 1.24921e-05
R292 242 243 1.712 0.8 13.696 37
I243 0 243 1.32342e-05
R293 243 244 1.744 0.8 13.952 37
I244 0 244 1.31105e-05
R294 244 245 1.712 0.8 13.696 37
I245 0 245 1.29868e-05
R295 245 246 1.616 0.8 12.928 37
I246 0 246 1.32342e-05
R296 246 247 1.744 0.8 13.952 37
I247 0 247 1.29868e-05
R297 247 248 1.68 0.8 13.44 37
I248 0 248 1.31105e-05
R298 248 249 1.648 0.8 13.184 37
I249 0 249 1.31105e-05
R299 249 250 1.6 0.8 12.8 37
I250 0 250 1.23684e-05
R300 250 0 0.1 49.28 49.28 37
*seg: 26
R301 0 251 0.1 49.28 49.28 37
R302 255 265 6.16 0.8 49.28 37
I251 0 251 1.33579e-05
R303 251 252 1.6 0.8 12.8 37
I252 0 252 1.34816e-05
R304 252 253 1.728 0.8 13.824 37
I253 0 253 1.26158e-05
R305 253 254 1.744 0.8 13.952 37
I254 0 254 1.34816e-05
R306 254 255 1.696 0.8 13.568 37
I255 0 255 1.33579e-05
R307 255 256 1.616 0.8 12.928 37
I256 0 256 1.24921e-05
R308 256 257 1.696 0.8 13.568 37
I257 0 257 1.33579e-05
R309 257 258 1.712 0.8 13.696 37
I258 0 258 1.32342e-05
R310 258 259 1.6 0.8 12.8 37
I259 0 259 1.34816e-05
R311 259 260 1.696 0.8 13.568 37
I260 0 260 1.23684e-05
R312 260 0 0.1 49.28 49.28 37
*seg: 27
R313 0 261 0.1 49.28 49.28 37
R314 265 275 6.16 0.8 49.28 37
I261 0 261 1.31105e-05
R315 261 262 1.68 0.8 13.44 37
I262 0 262 1.24921e-05
R316 262 263 1.696 0.8 13.568 37
I263 0 263 1.27395e-05
R317 263 264 1.744 0.8 13.952 37
I264 0 264 1.24921e-05
R318 264 265 1.632 0.8 13.056 37
I265 0 265 1.31105e-05
R319 265 266 1.712 0.8 13.696 37
I266 0 266 1.31105e-05
R320 266 267 1.632 0.8 13.056 37
I267 0 267 1.23684e-05
R321 267 268 1.664 0.8 13.312 37
I268 0 268 1.27395e-05
R322 268 269 1.744 0.8 13.952 37
I269 0 269 1.34816e-05
R323 269 270 1.632 0.8 13.056 37
I270 0 270 1.23684e-05
R324 270 0 0.1 49.28 49.28 37
*seg: 28
R325 0 271 0.1 49.28 49.28 37
R326 275 285 6.16 0.8 49.28 37
I271 0 271 1.26158e-05
R327 271 272 1.712 0.8 13.696 37
I272 0 272 1.33579e-05
R328 272 273 1.632 0.8 13.056 37
I273 0 273 1.26158e-05
R329 273 274 1.632 0.8 13.056 37
I274 0 274 1.29868e-05
R330 274 275 1.744 0.8 13.952 37
I275 0 275 1.31105e-05
R331 275 276 1.664 0.8 13.312 37
I276 0 276 1.23684e-05
R332 276 277 1.68 0.8 13.44 37
I277 0 277 1.34816e-05
R333 277 278 1.68 0.8 13.44 37
I278 0 278 1.27395e-05
R334 278 279 1.616 0.8 12.928 37
I279 0 279 1.28631e-05
R335 279 280 1.744 0.8 13.952 37
I280 0 280 1.23684e-05
R336 280 0 0.1 49.28 49.28 37
*seg: 29
R337 0 281 0.1 49.28 49.28 37
R338 285 295 6.16 0.8 49.28 37
I281 0 281 1.23684e-05
R339 281 282 1.616 0.8 12.928 37
I282 0 282 1.28631e-05
R340 282 283 1.68 0.8 13.44 37
I283 0 283 1.28631e-05
R341 283 284 1.6 0.8 12.8 37
I284 0 284 1.34816e-05
R342 284 285 1.616 0.8 12.928 37
I285 0 285 1.27395e-05
R343 285 286 1.616 0.8 12.928 37
I286 0 286 1.34816e-05
R344 286 287 1.6 0.8 12.8 37
I287 0 287 1.28631e-05
R345 287 288 1.712 0.8 13.696 37
I288 0 288 1.27395e-05
R346 288 289 1.712 0.8 13.696 37
I289 0 289 1.33579e-05
R347 289 290 1.6 0.8 12.8 37
I290 0 290 1.23684e-05
R348 290 0 0.1 49.28 49.28 37
*seg: 30
R349 0 291 0.1 49.28 49.28 37
R350 295 305 6.16 0.8 49.28 37
I291 0 291 1.29868e-05
R351 291 292 1.6 0.8 12.8 37
I292 0 292 1.34816e-05
R352 292 293 1.696 0.8 13.568 37
I293 0 293 1.31105e-05
R353 293 294 1.712 0.8 13.696 37
I294 0 294 1.26158e-05
R354 294 295 1.648 0.8 13.184 37
I295 0 295 1.32342e-05
R355 295 296 1.632 0.8 13.056 37
I296 0 296 1.31105e-05
R356 296 297 1.632 0.8 13.056 37
I297 0 297 1.34816e-05
R357 297 298 1.664 0.8 13.312 37
I298 0 298 1.26158e-05
R358 298 299 1.664 0.8 13.312 37
I299 0 299 1.29868e-05
R359 299 300 1.728 0.8 13.824 37
I300 0 300 1.23684e-05
R360 300 0 0.1 49.28 49.28 37
*seg: 31
R361 0 301 0.1 49.28 49.28 37
R362 305 315 6.16 0.8 49.28 37
I301 0 301 1.28631e-05
R363 301 302 1.712 0.8 13.696 37
I302 0 302 1.31105e-05
R364 302 303 1.632 0.8 13.056 37
I303 0 303 1.28631e-05
R365 303 304 1.696 0.8 13.568 37
I304 0 304 1.26158e-05
R366 304 305 1.68 0.8 13.44 37
I305 0 305 1.33579e-05
R367 305 306 1.632 0.8 13.056 37
I306 0 306 1.23684e-05
R368 306 307 1.616 0.8 12.928 37
I307 0 307 1.34816e-05
R369 307 308 1.712 0.8 13.696 37
I308 0 308 1.28631e-05
R370 308 309 1.664 0.8 13.312 37
I309 0 309 1.29868e-05
R371 309 310 1.712 0.8 13.696 37
I310 0 310 1.23684e-05
R372 310 0 0.1 49.28 49.28 37
*seg: 32
R373 0 311 0.1 49.28 49.28 37
R374 315 325 6.16 0.8 49.28 37
I311 0 311 1.29868e-05
R375 311 312 1.6 0.8 12.8 37
I312 0 312 1.33579e-05
R376 312 313 1.68 0.8 13.44 37
I313 0 313 1.23684e-05
R377 313 314 1.616 0.8 12.928 37
I314 0 314 1.34816e-05
R378 314 315 1.712 0.8 13.696 37
I315 0 315 1.32342e-05
R379 315 316 1.6 0.8 12.8 37
I316 0 316 1.32342e-05
R380 316 317 1.712 0.8 13.696 37
I317 0 317 1.31105e-05
R381 317 318 1.648 0.8 13.184 37
I318 0 318 1.27395e-05
R382 318 319 1.712 0.8 13.696 37
I319 0 319 1.32342e-05
R383 319 320 1.68 0.8 13.44 37
I320 0 320 1.23684e-05
R384 320 0 0.1 49.28 49.28 37
*seg: 33
R385 0 321 0.1 49.28 49.28 37
R386 325 335 6.16 0.8 49.28 37
I321 0 321 1.24921e-05
R387 321 322 1.68 0.8 13.44 37
I322 0 322 1.31105e-05
R388 322 323 1.712 0.8 13.696 37
I323 0 323 1.24921e-05
R389 323 324 1.616 0.8 12.928 37
I324 0 324 1.23684e-05
R390 324 325 1.696 0.8 13.568 37
I325 0 325 1.34816e-05
R391 325 326 1.68 0.8 13.44 37
I326 0 326 1.32342e-05
R392 326 327 1.728 0.8 13.824 37
I327 0 327 1.27395e-05
R393 327 328 1.616 0.8 12.928 37
I328 0 328 1.31105e-05
R394 328 329 1.664 0.8 13.312 37
I329 0 329 1.33579e-05
R395 329 330 1.632 0.8 13.056 37
I330 0 330 1.23684e-05
R396 330 0 0.1 49.28 49.28 37
*seg: 34
R397 0 331 0.1 49.28 49.28 37
R398 335 345 6.16 0.8 49.28 37
I331 0 331 1.32342e-05
R399 331 332 1.664 0.8 13.312 37
I332 0 332 1.31105e-05
R400 332 333 1.68 0.8 13.44 37
I333 0 333 1.29868e-05
R401 333 334 1.632 0.8 13.056 37
I334 0 334 1.31105e-05
R402 334 335 1.68 0.8 13.44 37
I335 0 335 1.29868e-05
R403 335 336 1.632 0.8 13.056 37
I336 0 336 1.33579e-05
R404 336 337 1.68 0.8 13.44 37
I337 0 337 1.32342e-05
R405 337 338 1.632 0.8 13.056 37
I338 0 338 1.23684e-05
R406 338 339 1.712 0.8 13.696 37
I339 0 339 1.26158e-05
R407 339 340 1.632 0.8 13.056 37
I340 0 340 1.23684e-05
R408 340 0 0.1 49.28 49.28 37
*seg: 35
R409 0 341 0.1 49.28 49.28 37
R410 345 355 6.16 0.8 49.28 37
I341 0 341 1.27395e-05
R411 341 342 1.728 0.8 13.824 37
I342 0 342 1.29868e-05
R412 342 343 1.6 0.8 12.8 37
I343 0 343 1.33579e-05
R413 343 344 1.696 0.8 13.568 37
I344 0 344 1.26158e-05
R414 344 345 1.632 0.8 13.056 37
I345 0 345 1.28631e-05
R415 345 346 1.712 0.8 13.696 37
I346 0 346 1.29868e-05
R416 346 347 1.744 0.8 13.952 37
I347 0 347 1.28631e-05
R417 347 348 1.648 0.8 13.184 37
I348 0 348 1.34816e-05
R418 348 349 1.68 0.8 13.44 37
I349 0 349 1.29868e-05
R419 349 350 1.712 0.8 13.696 37
I350 0 350 1.23684e-05
R420 350 0 0.1 49.28 49.28 37
*seg: 36
R421 0 351 0.1 49.28 49.28 37
R422 355 365 6.16 0.8 49.28 37
I351 0 351 1.24921e-05
R423 351 352 1.648 0.8 13.184 37
I352 0 352 1.32342e-05
R424 352 353 1.616 0.8 12.928 37
I353 0 353 1.32342e-05
R425 353 354 1.712 0.8 13.696 37
I354 0 354 1.26158e-05
R426 354 355 1.664 0.8 13.312 37
I355 0 355 1.24921e-05
R427 355 356 1.712 0.8 13.696 37
I356 0 356 1.27395e-05
R428 356 357 1.712 0.8 13.696 37
I357 0 357 1.32342e-05
R429 357 358 1.648 0.8 13.184 37
I358 0 358 1.24921e-05
R430 358 359 1.728 0.8 13.824 37
I359 0 359 1.34816e-05
R431 359 360 1.728 0.8 13.824 37
I360 0 360 1.23684e-05
R432 360 0 0.1 49.28 49.28 37
*seg: 37
R433 0 361 0.1 49.28 49.28 37
R434 365 375 6.16 0.8 49.28 37
I361 0 361 1.31105e-05
R435 361 362 1.632 0.8 13.056 37
I362 0 362 1.23684e-05
R436 362 363 1.632 0.8 13.056 37
I363 0 363 1.33579e-05
R437 363 364 1.68 0.8 13.44 37
I364 0 364 1.26158e-05
R438 364 365 1.696 0.8 13.568 37
I365 0 365 1.34816e-05
R439 365 366 1.664 0.8 13.312 37
I366 0 366 1.31105e-05
R440 366 367 1.744 0.8 13.952 37
I367 0 367 1.27395e-05
R441 367 368 1.712 0.8 13.696 37
I368 0 368 1.23684e-05
R442 368 369 1.728 0.8 13.824 37
I369 0 369 1.33579e-05
R443 369 370 1.712 0.8 13.696 37
I370 0 370 1.23684e-05
R444 370 0 0.1 49.28 49.28 37
*seg: 38
R445 0 371 0.1 49.28 49.28 37
R446 375 385 6.16 0.8 49.28 37
I371 0 371 1.29868e-05
R447 371 372 1.632 0.8 13.056 37
I372 0 372 1.23684e-05
R448 372 373 1.648 0.8 13.184 37
I373 0 373 1.27395e-05
R449 373 374 1.616 0.8 12.928 37
I374 0 374 1.24921e-05
R450 374 375 1.632 0.8 13.056 37
I375 0 375 1.28631e-05
R451 375 376 1.68 0.8 13.44 37
I376 0 376 1.31105e-05
R452 376 377 1.728 0.8 13.824 37
I377 0 377 1.24921e-05
R453 377 378 1.632 0.8 13.056 37
I378 0 378 1.24921e-05
R454 378 379 1.744 0.8 13.952 37
I379 0 379 1.34816e-05
R455 379 380 1.632 0.8 13.056 37
I380 0 380 1.23684e-05
R456 380 0 0.1 49.28 49.28 37
*seg: 39
R457 0 381 0.1 49.28 49.28 37
R458 385 395 6.16 0.8 49.28 37
I381 0 381 1.34816e-05
R459 381 382 1.728 0.8 13.824 37
I382 0 382 1.27395e-05
R460 382 383 1.712 0.8 13.696 37
I383 0 383 1.24921e-05
R461 383 384 1.664 0.8 13.312 37
I384 0 384 1.24921e-05
R462 384 385 1.664 0.8 13.312 37
I385 0 385 1.32342e-05
R463 385 386 1.68 0.8 13.44 37
I386 0 386 1.27395e-05
R464 386 387 1.616 0.8 12.928 37
I387 0 387 1.24921e-05
R465 387 388 1.664 0.8 13.312 37
I388 0 388 1.28631e-05
R466 388 389 1.648 0.8 13.184 37
I389 0 389 1.29868e-05
R467 389 390 1.744 0.8 13.952 37
I390 0 390 1.23684e-05
R468 390 0 0.1 49.28 49.28 37
*seg: 40
R469 0 391 0.1 49.28 49.28 37
R470 395 405 6.16 0.8 49.28 37
I391 0 391 1.26158e-05
R471 391 392 1.616 0.8 12.928 37
I392 0 392 1.34816e-05
R472 392 393 1.616 0.8 12.928 37
I393 0 393 1.27395e-05
R473 393 394 1.664 0.8 13.312 37
I394 0 394 1.33579e-05
R474 394 395 1.616 0.8 12.928 37
I395 0 395 1.31105e-05
R475 395 396 1.648 0.8 13.184 37
I396 0 396 1.28631e-05
R476 396 397 1.6 0.8 12.8 37
I397 0 397 1.29868e-05
R477 397 398 1.696 0.8 13.568 37
I398 0 398 1.33579e-05
R478 398 399 1.6 0.8 12.8 37
I399 0 399 1.26158e-05
R479 399 400 1.648 0.8 13.184 37
I400 0 400 1.23684e-05
R480 400 0 0.1 49.28 49.28 37
*seg: 41
R481 0 401 0.1 49.28 49.28 37
R482 405 415 6.16 0.8 49.28 37
I401 0 401 1.28631e-05
R483 401 402 1.712 0.8 13.696 37
I402 0 402 1.27395e-05
R484 402 403 1.648 0.8 13.184 37
I403 0 403 1.27395e-05
R485 403 404 1.696 0.8 13.568 37
I404 0 404 1.28631e-05
R486 404 405 1.616 0.8 12.928 37
I405 0 405 1.24921e-05
R487 405 406 1.648 0.8 13.184 37
I406 0 406 1.28631e-05
R488 406 407 1.728 0.8 13.824 37
I407 0 407 1.32342e-05
R489 407 408 1.728 0.8 13.824 37
I408 0 408 1.33579e-05
R490 408 409 1.616 0.8 12.928 37
I409 0 409 1.24921e-05
R491 409 410 1.744 0.8 13.952 37
I410 0 410 1.23684e-05
R492 410 0 0.1 49.28 49.28 37
*seg: 42
R493 0 411 0.1 49.28 49.28 37
R494 415 425 6.16 0.8 49.28 37
I411 0 411 1.34816e-05
R495 411 412 1.728 0.8 13.824 37
I412 0 412 1.29868e-05
R496 412 413 1.632 0.8 13.056 37
I413 0 413 1.28631e-05
R497 413 414 1.744 0.8 13.952 37
I414 0 414 1.23684e-05
R498 414 415 1.664 0.8 13.312 37
I415 0 415 1.28631e-05
R499 415 416 1.744 0.8 13.952 37
I416 0 416 1.23684e-05
R500 416 417 1.744 0.8 13.952 37
I417 0 417 1.34816e-05
R501 417 418 1.6 0.8 12.8 37
I418 0 418 1.24921e-05
R502 418 419 1.664 0.8 13.312 37
I419 0 419 1.26158e-05
R503 419 420 1.712 0.8 13.696 37
I420 0 420 1.23684e-05
R504 420 0 0.1 49.28 49.28 37
*seg: 43
R505 0 421 0.1 49.28 49.28 37
R506 425 435 6.16 0.8 49.28 37
I421 0 421 1.24921e-05
R507 421 422 1.728 0.8 13.824 37
I422 0 422 1.26158e-05
R508 422 423 1.728 0.8 13.824 37
I423 0 423 1.27395e-05
R509 423 424 1.744 0.8 13.952 37
I424 0 424 1.34816e-05
R510 424 425 1.744 0.8 13.952 37
I425 0 425 1.26158e-05
R511 425 426 1.744 0.8 13.952 37
I426 0 426 1.32342e-05
R512 426 427 1.6 0.8 12.8 37
I427 0 427 1.34816e-05
R513 427 428 1.648 0.8 13.184 37
I428 0 428 1.29868e-05
R514 428 429 1.712 0.8 13.696 37
I429 0 429 1.34816e-05
R515 429 430 1.68 0.8 13.44 37
I430 0 430 1.23684e-05
R516 430 0 0.1 49.28 49.28 37
*seg: 44
R517 0 431 0.1 49.28 49.28 37
R518 435 445 6.16 0.8 49.28 37
I431 0 431 1.33579e-05
R519 431 432 1.648 0.8 13.184 37
I432 0 432 1.33579e-05
R520 432 433 1.632 0.8 13.056 37
I433 0 433 1.32342e-05
R521 433 434 1.648 0.8 13.184 37
I434 0 434 1.33579e-05
R522 434 435 1.712 0.8 13.696 37
I435 0 435 1.33579e-05
R523 435 436 1.616 0.8 12.928 37
I436 0 436 1.28631e-05
R524 436 437 1.744 0.8 13.952 37
I437 0 437 1.29868e-05
R525 437 438 1.648 0.8 13.184 37
I438 0 438 1.33579e-05
R526 438 439 1.6 0.8 12.8 37
I439 0 439 1.34816e-05
R527 439 440 1.632 0.8 13.056 37
I440 0 440 1.23684e-05
R528 440 0 0.1 49.28 49.28 37
*seg: 45
R529 0 441 0.1 49.28 49.28 37
R530 445 455 6.16 0.8 49.28 37
I441 0 441 1.27395e-05
R531 441 442 1.744 0.8 13.952 37
I442 0 442 1.34816e-05
R532 442 443 1.68 0.8 13.44 37
I443 0 443 1.34816e-05
R533 443 444 1.664 0.8 13.312 37
I444 0 444 1.28631e-05
R534 444 445 1.664 0.8 13.312 37
I445 0 445 1.27395e-05
R535 445 446 1.616 0.8 12.928 37
I446 0 446 1.34816e-05
R536 446 447 1.712 0.8 13.696 37
I447 0 447 1.32342e-05
R537 447 448 1.632 0.8 13.056 37
I448 0 448 1.29868e-05
R538 448 449 1.744 0.8 13.952 37
I449 0 449 1.23684e-05
R539 449 450 1.6 0.8 12.8 37
I450 0 450 1.23684e-05
R540 450 0 0.1 49.28 49.28 37
*seg: 46
R541 0 451 0.1 49.28 49.28 37
R542 455 465 6.16 0.8 49.28 37
I451 0 451 1.24921e-05
R543 451 452 1.648 0.8 13.184 37
I452 0 452 1.28631e-05
R544 452 453 1.632 0.8 13.056 37
I453 0 453 1.24921e-05
R545 453 454 1.632 0.8 13.056 37
I454 0 454 1.33579e-05
R546 454 455 1.616 0.8 12.928 37
I455 0 455 1.33579e-05
R547 455 456 1.664 0.8 13.312 37
I456 0 456 1.31105e-05
R548 456 457 1.616 0.8 12.928 37
I457 0 457 1.28631e-05
R549 457 458 1.664 0.8 13.312 37
I458 0 458 1.29868e-05
R550 458 459 1.712 0.8 13.696 37
I459 0 459 1.23684e-05
R551 459 460 1.728 0.8 13.824 37
I460 0 460 1.23684e-05
R552 460 0 0.1 49.28 49.28 37
*seg: 47
R553 0 461 0.1 49.28 49.28 37
R554 465 475 6.16 0.8 49.28 37
I461 0 461 1.31105e-05
R555 461 462 1.696 0.8 13.568 37
I462 0 462 1.24921e-05
R556 462 463 1.616 0.8 12.928 37
I463 0 463 1.29868e-05
R557 463 464 1.632 0.8 13.056 37
I464 0 464 1.32342e-05
R558 464 465 1.6 0.8 12.8 37
I465 0 465 1.34816e-05
R559 465 466 1.728 0.8 13.824 37
I466 0 466 1.33579e-05
R560 466 467 1.744 0.8 13.952 37
I467 0 467 1.33579e-05
R561 467 468 1.712 0.8 13.696 37
I468 0 468 1.23684e-05
R562 468 469 1.728 0.8 13.824 37
I469 0 469 1.31105e-05
R563 469 470 1.744 0.8 13.952 37
I470 0 470 1.23684e-05
R564 470 0 0.1 49.28 49.28 37
*seg: 48
R565 0 471 0.1 49.28 49.28 37
R566 475 485 6.16 0.8 49.28 37
I471 0 471 1.23684e-05
R567 471 472 1.616 0.8 12.928 37
I472 0 472 1.29868e-05
R568 472 473 1.712 0.8 13.696 37
I473 0 473 1.26158e-05
R569 473 474 1.696 0.8 13.568 37
I474 0 474 1.29868e-05
R570 474 475 1.68 0.8 13.44 37
I475 0 475 1.26158e-05
R571 475 476 1.616 0.8 12.928 37
I476 0 476 1.32342e-05
R572 476 477 1.6 0.8 12.8 37
I477 0 477 1.33579e-05
R573 477 478 1.696 0.8 13.568 37
I478 0 478 1.27395e-05
R574 478 479 1.616 0.8 12.928 37
I479 0 479 1.23684e-05
R575 479 480 1.616 0.8 12.928 37
I480 0 480 1.23684e-05
R576 480 0 0.1 49.28 49.28 37
*seg: 49
R577 0 481 0.1 49.28 49.28 37
R578 485 495 6.16 0.8 49.28 37
I481 0 481 1.23684e-05
R579 481 482 1.6 0.8 12.8 37
I482 0 482 1.31105e-05
R580 482 483 1.728 0.8 13.824 37
I483 0 483 1.34816e-05
R581 483 484 1.744 0.8 13.952 37
I484 0 484 1.34816e-05
R582 484 485 1.712 0.8 13.696 37
I485 0 485 1.24921e-05
R583 485 486 1.664 0.8 13.312 37
I486 0 486 1.32342e-05
R584 486 487 1.6 0.8 12.8 37
I487 0 487 1.33579e-05
R585 487 488 1.632 0.8 13.056 37
I488 0 488 1.31105e-05
R586 488 489 1.632 0.8 13.056 37
I489 0 489 1.24921e-05
R587 489 490 1.68 0.8 13.44 37
I490 0 490 1.23684e-05
R588 490 0 0.1 49.28 49.28 37
*seg: 50
R589 0 491 0.1 49.28 49.28 37
R590 495 505 6.16 0.8 49.28 37
I491 0 491 1.27395e-05
R591 491 492 1.664 0.8 13.312 37
I492 0 492 1.23684e-05
R592 492 493 1.664 0.8 13.312 37
I493 0 493 1.34816e-05
R593 493 494 1.632 0.8 13.056 37
I494 0 494 1.31105e-05
R594 494 495 1.664 0.8 13.312 37
I495 0 495 1.23684e-05
R595 495 496 1.712 0.8 13.696 37
I496 0 496 1.32342e-05
R596 496 497 1.664 0.8 13.312 37
I497 0 497 1.24921e-05
R597 497 498 1.696 0.8 13.568 37
I498 0 498 1.34816e-05
R598 498 499 1.712 0.8 13.696 37
I499 0 499 1.27395e-05
R599 499 500 1.6 0.8 12.8 37
I500 0 500 1.23684e-05
R600 500 0 0.1 49.28 49.28 37
*seg: 51
R601 0 501 0.1 49.28 49.28 37
R602 505 515 6.16 0.8 49.28 37
I501 0 501 1.31105e-05
R603 501 502 1.664 0.8 13.312 37
I502 0 502 1.33579e-05
R604 502 503 1.648 0.8 13.184 37
I503 0 503 1.27395e-05
R605 503 504 1.728 0.8 13.824 37
I504 0 504 1.29868e-05
R606 504 505 1.744 0.8 13.952 37
I505 0 505 1.28631e-05
R607 505 506 1.728 0.8 13.824 37
I506 0 506 1.23684e-05
R608 506 507 1.68 0.8 13.44 37
I507 0 507 1.27395e-05
R609 507 508 1.6 0.8 12.8 37
I508 0 508 1.26158e-05
R610 508 509 1.728 0.8 13.824 37
I509 0 509 1.32342e-05
R611 509 510 1.712 0.8 13.696 37
I510 0 510 1.23684e-05
R612 510 0 0.1 49.28 49.28 37
*seg: 52
R613 0 511 0.1 49.28 49.28 37
R614 515 525 6.16 0.8 49.28 37
I511 0 511 1.31105e-05
R615 511 512 1.728 0.8 13.824 37
I512 0 512 1.32342e-05
R616 512 513 1.632 0.8 13.056 37
I513 0 513 1.34816e-05
R617 513 514 1.68 0.8 13.44 37
I514 0 514 1.24921e-05
R618 514 515 1.6 0.8 12.8 37
I515 0 515 1.32342e-05
R619 515 516 1.696 0.8 13.568 37
I516 0 516 1.33579e-05
R620 516 517 1.728 0.8 13.824 37
I517 0 517 1.26158e-05
R621 517 518 1.632 0.8 13.056 37
I518 0 518 1.26158e-05
R622 518 519 1.6 0.8 12.8 37
I519 0 519 1.23684e-05
R623 519 520 1.696 0.8 13.568 37
I520 0 520 1.23684e-05
R624 520 0 0.1 49.28 49.28 37
*seg: 53
R625 0 521 0.1 49.28 49.28 37
R626 525 535 6.16 0.8 49.28 37
I521 0 521 1.33579e-05
R627 521 522 1.728 0.8 13.824 37
I522 0 522 1.23684e-05
R628 522 523 1.696 0.8 13.568 37
I523 0 523 1.27395e-05
R629 523 524 1.664 0.8 13.312 37
I524 0 524 1.27395e-05
R630 524 525 1.616 0.8 12.928 37
I525 0 525 1.32342e-05
R631 525 526 1.696 0.8 13.568 37
I526 0 526 1.26158e-05
R632 526 527 1.664 0.8 13.312 37
I527 0 527 1.31105e-05
R633 527 528 1.728 0.8 13.824 37
I528 0 528 1.27395e-05
R634 528 529 1.648 0.8 13.184 37
I529 0 529 1.26158e-05
R635 529 530 1.6 0.8 12.8 37
I530 0 530 1.23684e-05
R636 530 0 0.1 49.28 49.28 37
*seg: 54
R637 0 531 0.1 49.28 49.28 37
R638 535 545 6.16 0.8 49.28 37
I531 0 531 1.26158e-05
R639 531 532 1.664 0.8 13.312 37
I532 0 532 1.32342e-05
R640 532 533 1.616 0.8 12.928 37
I533 0 533 1.29868e-05
R641 533 534 1.648 0.8 13.184 37
I534 0 534 1.24921e-05
R642 534 535 1.728 0.8 13.824 37
I535 0 535 1.33579e-05
R643 535 536 1.728 0.8 13.824 37
I536 0 536 1.28631e-05
R644 536 537 1.696 0.8 13.568 37
I537 0 537 1.23684e-05
R645 537 538 1.648 0.8 13.184 37
I538 0 538 1.32342e-05
R646 538 539 1.632 0.8 13.056 37
I539 0 539 1.34816e-05
R647 539 540 1.696 0.8 13.568 37
I540 0 540 1.23684e-05
R648 540 0 0.1 49.28 49.28 37
*seg: 55
R649 0 541 0.1 49.28 49.28 37
R650 545 555 6.16 0.8 49.28 37
I541 0 541 1.34816e-05
R651 541 542 1.696 0.8 13.568 37
I542 0 542 1.29868e-05
R652 542 543 1.744 0.8 13.952 37
I543 0 543 1.27395e-05
R653 543 544 1.664 0.8 13.312 37
I544 0 544 1.34816e-05
R654 544 545 1.68 0.8 13.44 37
I545 0 545 1.33579e-05
R655 545 546 1.696 0.8 13.568 37
I546 0 546 1.34816e-05
R656 546 547 1.648 0.8 13.184 37
I547 0 547 1.32342e-05
R657 547 548 1.712 0.8 13.696 37
I548 0 548 1.32342e-05
R658 548 549 1.664 0.8 13.312 37
I549 0 549 1.23684e-05
R659 549 550 1.728 0.8 13.824 37
I550 0 550 1.23684e-05
R660 550 0 0.1 49.28 49.28 37
*seg: 56
R661 0 551 0.1 49.28 49.28 37
R662 555 565 6.16 0.8 49.28 37
I551 0 551 1.26158e-05
R663 551 552 1.728 0.8 13.824 37
I552 0 552 1.24921e-05
R664 552 553 1.648 0.8 13.184 37
I553 0 553 1.23684e-05
R665 553 554 1.6 0.8 12.8 37
I554 0 554 1.31105e-05
R666 554 555 1.68 0.8 13.44 37
I555 0 555 1.27395e-05
R667 555 556 1.664 0.8 13.312 37
I556 0 556 1.29868e-05
R668 556 557 1.68 0.8 13.44 37
I557 0 557 1.26158e-05
R669 557 558 1.744 0.8 13.952 37
I558 0 558 1.26158e-05
R670 558 559 1.664 0.8 13.312 37
I559 0 559 1.23684e-05
R671 559 560 1.712 0.8 13.696 37
I560 0 560 1.23684e-05
R672 560 0 0.1 49.28 49.28 37
*seg: 57
R673 0 561 0.1 49.28 49.28 37
R674 565 575 6.16 0.8 49.28 37
I561 0 561 1.31105e-05
R675 561 562 1.696 0.8 13.568 37
I562 0 562 1.26158e-05
R676 562 563 1.744 0.8 13.952 37
I563 0 563 1.29868e-05
R677 563 564 1.696 0.8 13.568 37
I564 0 564 1.27395e-05
R678 564 565 1.68 0.8 13.44 37
I565 0 565 1.33579e-05
R679 565 566 1.696 0.8 13.568 37
I566 0 566 1.27395e-05
R680 566 567 1.6 0.8 12.8 37
I567 0 567 1.32342e-05
R681 567 568 1.616 0.8 12.928 37
I568 0 568 1.23684e-05
R682 568 569 1.616 0.8 12.928 37
I569 0 569 1.28631e-05
R683 569 570 1.68 0.8 13.44 37
I570 0 570 1.23684e-05
R684 570 0 0.1 49.28 49.28 37
*seg: 58
R685 0 571 0.1 49.28 49.28 37
R686 575 585 6.16 0.8 49.28 37
I571 0 571 1.29868e-05
R687 571 572 1.696 0.8 13.568 37
I572 0 572 1.33579e-05
R688 572 573 1.744 0.8 13.952 37
I573 0 573 1.24921e-05
R689 573 574 1.664 0.8 13.312 37
I574 0 574 1.31105e-05
R690 574 575 1.744 0.8 13.952 37
I575 0 575 1.28631e-05
R691 575 576 1.696 0.8 13.568 37
I576 0 576 1.31105e-05
R692 576 577 1.632 0.8 13.056 37
I577 0 577 1.27395e-05
R693 577 578 1.664 0.8 13.312 37
I578 0 578 1.34816e-05
R694 578 579 1.616 0.8 12.928 37
I579 0 579 1.31105e-05
R695 579 580 1.664 0.8 13.312 37
I580 0 580 1.23684e-05
R696 580 0 0.1 49.28 49.28 37
*seg: 59
R697 0 581 0.1 49.28 49.28 37
R698 585 595 6.16 0.8 49.28 37
I581 0 581 1.31105e-05
R699 581 582 1.6 0.8 12.8 37
I582 0 582 1.27395e-05
R700 582 583 1.68 0.8 13.44 37
I583 0 583 1.24921e-05
R701 583 584 1.632 0.8 13.056 37
I584 0 584 1.26158e-05
R702 584 585 1.6 0.8 12.8 37
I585 0 585 1.24921e-05
R703 585 586 1.616 0.8 12.928 37
I586 0 586 1.32342e-05
R704 586 587 1.6 0.8 12.8 37
I587 0 587 1.23684e-05
R705 587 588 1.648 0.8 13.184 37
I588 0 588 1.32342e-05
R706 588 589 1.664 0.8 13.312 37
I589 0 589 1.29868e-05
R707 589 590 1.712 0.8 13.696 37
I590 0 590 1.23684e-05
R708 590 0 0.1 49.28 49.28 37
*seg: 60
R709 0 591 0.1 49.28 49.28 37
R710 595 605 6.16 0.8 49.28 37
I591 0 591 1.23684e-05
R711 591 592 1.744 0.8 13.952 37
I592 0 592 1.27395e-05
R712 592 593 1.728 0.8 13.824 37
I593 0 593 1.26158e-05
R713 593 594 1.712 0.8 13.696 37
I594 0 594 1.31105e-05
R714 594 595 1.632 0.8 13.056 37
I595 0 595 1.29868e-05
R715 595 596 1.696 0.8 13.568 37
I596 0 596 1.32342e-05
R716 596 597 1.664 0.8 13.312 37
I597 0 597 1.33579e-05
R717 597 598 1.728 0.8 13.824 37
I598 0 598 1.27395e-05
R718 598 599 1.728 0.8 13.824 37
I599 0 599 1.33579e-05
R719 599 600 1.616 0.8 12.928 37
I600 0 600 1.23684e-05
R720 600 0 0.1 49.28 49.28 37
*seg: 61
R721 0 601 0.1 49.28 49.28 37
R722 605 615 6.16 0.8 49.28 37
I601 0 601 1.29868e-05
R723 601 602 1.696 0.8 13.568 37
I602 0 602 1.34816e-05
R724 602 603 1.696 0.8 13.568 37
I603 0 603 1.23684e-05
R725 603 604 1.696 0.8 13.568 37
I604 0 604 1.28631e-05
R726 604 605 1.744 0.8 13.952 37
I605 0 605 1.33579e-05
R727 605 606 1.68 0.8 13.44 37
I606 0 606 1.26158e-05
R728 606 607 1.728 0.8 13.824 37
I607 0 607 1.29868e-05
R729 607 608 1.616 0.8 12.928 37
I608 0 608 1.24921e-05
R730 608 609 1.648 0.8 13.184 37
I609 0 609 1.29868e-05
R731 609 610 1.744 0.8 13.952 37
I610 0 610 1.23684e-05
R732 610 0 0.1 49.28 49.28 37
*seg: 62
R733 0 611 0.1 49.28 49.28 37
R734 615 625 6.16 0.8 49.28 37
I611 0 611 1.28631e-05
R735 611 612 1.632 0.8 13.056 37
I612 0 612 1.23684e-05
R736 612 613 1.616 0.8 12.928 37
I613 0 613 1.33579e-05
R737 613 614 1.616 0.8 12.928 37
I614 0 614 1.31105e-05
R738 614 615 1.664 0.8 13.312 37
I615 0 615 1.31105e-05
R739 615 616 1.632 0.8 13.056 37
I616 0 616 1.23684e-05
R740 616 617 1.6 0.8 12.8 37
I617 0 617 1.29868e-05
R741 617 618 1.68 0.8 13.44 37
I618 0 618 1.29868e-05
R742 618 619 1.6 0.8 12.8 37
I619 0 619 1.32342e-05
R743 619 620 1.728 0.8 13.824 37
I620 0 620 1.23684e-05
R744 620 0 0.1 49.28 49.28 37
*seg: 63
R745 0 621 0.1 49.28 49.28 37
R746 625 635 6.16 0.8 49.28 37
I621 0 621 1.24921e-05
R747 621 622 1.68 0.8 13.44 37
I622 0 622 1.33579e-05
R748 622 623 1.696 0.8 13.568 37
I623 0 623 1.23684e-05
R749 623 624 1.632 0.8 13.056 37
I624 0 624 1.34816e-05
R750 624 625 1.6 0.8 12.8 37
I625 0 625 1.24921e-05
R751 625 626 1.728 0.8 13.824 37
I626 0 626 1.32342e-05
R752 626 627 1.728 0.8 13.824 37
I627 0 627 1.29868e-05
R753 627 628 1.648 0.8 13.184 37
I628 0 628 1.27395e-05
R754 628 629 1.712 0.8 13.696 37
I629 0 629 1.23684e-05
R755 629 630 1.728 0.8 13.824 37
I630 0 630 1.23684e-05
R756 630 0 0.1 49.28 49.28 37
*seg: 64
R757 0 631 0.1 49.28 49.28 37
R758 635 645 6.16 0.8 49.28 37
I631 0 631 1.32342e-05
R759 631 632 1.648 0.8 13.184 37
I632 0 632 1.26158e-05
R760 632 633 1.632 0.8 13.056 37
I633 0 633 1.31105e-05
R761 633 634 1.6 0.8 12.8 37
I634 0 634 1.33579e-05
R762 634 635 1.664 0.8 13.312 37
I635 0 635 1.27395e-05
R763 635 636 1.648 0.8 13.184 37
I636 0 636 1.32342e-05
R764 636 637 1.744 0.8 13.952 37
I637 0 637 1.26158e-05
R765 637 638 1.664 0.8 13.312 37
I638 0 638 1.31105e-05
R766 638 639 1.712 0.8 13.696 37
I639 0 639 1.24921e-05
R767 639 640 1.712 0.8 13.696 37
I640 0 640 1.23684e-05
R768 640 0 0.1 49.28 49.28 37
*seg: 65
R769 0 641 0.1 49.28 49.28 37
R770 645 655 6.16 0.8 49.28 37
I641 0 641 1.28631e-05
R771 641 642 1.6 0.8 12.8 37
I642 0 642 1.34816e-05
R772 642 643 1.712 0.8 13.696 37
I643 0 643 1.27395e-05
R773 643 644 1.696 0.8 13.568 37
I644 0 644 1.24921e-05
R774 644 645 1.696 0.8 13.568 37
I645 0 645 1.24921e-05
R775 645 646 1.616 0.8 12.928 37
I646 0 646 1.23684e-05
R776 646 647 1.6 0.8 12.8 37
I647 0 647 1.32342e-05
R777 647 648 1.68 0.8 13.44 37
I648 0 648 1.27395e-05
R778 648 649 1.6 0.8 12.8 37
I649 0 649 1.34816e-05
R779 649 650 1.632 0.8 13.056 37
I650 0 650 1.23684e-05
R780 650 0 0.1 49.28 49.28 37
*seg: 66
R781 0 651 0.1 49.28 49.28 37
R782 655 665 6.16 0.8 49.28 37
I651 0 651 1.24921e-05
R783 651 652 1.68 0.8 13.44 37
I652 0 652 1.24921e-05
R784 652 653 1.744 0.8 13.952 37
I653 0 653 1.23684e-05
R785 653 654 1.616 0.8 12.928 37
I654 0 654 1.27395e-05
R786 654 655 1.712 0.8 13.696 37
I655 0 655 1.27395e-05
R787 655 656 1.632 0.8 13.056 37
I656 0 656 1.34816e-05
R788 656 657 1.664 0.8 13.312 37
I657 0 657 1.33579e-05
R789 657 658 1.664 0.8 13.312 37
I658 0 658 1.29868e-05
R790 658 659 1.744 0.8 13.952 37
I659 0 659 1.29868e-05
R791 659 660 1.616 0.8 12.928 37
I660 0 660 1.23684e-05
R792 660 0 0.1 49.28 49.28 37
*seg: 67
R793 0 661 0.1 49.28 49.28 37
R794 665 675 6.16 0.8 49.28 37
I661 0 661 1.34816e-05
R795 661 662 1.6 0.8 12.8 37
I662 0 662 1.28631e-05
R796 662 663 1.616 0.8 12.928 37
I663 0 663 1.33579e-05
R797 663 664 1.632 0.8 13.056 37
I664 0 664 1.29868e-05
R798 664 665 1.648 0.8 13.184 37
I665 0 665 1.31105e-05
R799 665 666 1.616 0.8 12.928 37
I666 0 666 1.31105e-05
R800 666 667 1.648 0.8 13.184 37
I667 0 667 1.27395e-05
R801 667 668 1.712 0.8 13.696 37
I668 0 668 1.26158e-05
R802 668 669 1.712 0.8 13.696 37
I669 0 669 1.31105e-05
R803 669 670 1.712 0.8 13.696 37
I670 0 670 1.23684e-05
R804 670 0 0.1 49.28 49.28 37
*seg: 68
R805 0 671 0.1 49.28 49.28 37
R806 675 685 6.16 0.8 49.28 37
I671 0 671 1.23684e-05
R807 671 672 1.712 0.8 13.696 37
I672 0 672 1.26158e-05
R808 672 673 1.664 0.8 13.312 37
I673 0 673 1.23684e-05
R809 673 674 1.632 0.8 13.056 37
I674 0 674 1.32342e-05
R810 674 675 1.744 0.8 13.952 37
I675 0 675 1.26158e-05
R811 675 676 1.632 0.8 13.056 37
I676 0 676 1.28631e-05
R812 676 677 1.68 0.8 13.44 37
I677 0 677 1.24921e-05
R813 677 678 1.648 0.8 13.184 37
I678 0 678 1.31105e-05
R814 678 679 1.712 0.8 13.696 37
I679 0 679 1.26158e-05
R815 679 680 1.6 0.8 12.8 37
I680 0 680 1.23684e-05
R816 680 0 0.1 49.28 49.28 37
*seg: 69
R817 0 681 0.1 49.28 49.28 37
R818 685 695 6.16 0.8 49.28 37
I681 0 681 1.31105e-05
R819 681 682 1.632 0.8 13.056 37
I682 0 682 1.23684e-05
R820 682 683 1.696 0.8 13.568 37
I683 0 683 1.27395e-05
R821 683 684 1.696 0.8 13.568 37
I684 0 684 1.34816e-05
R822 684 685 1.696 0.8 13.568 37
I685 0 685 1.29868e-05
R823 685 686 1.68 0.8 13.44 37
I686 0 686 1.34816e-05
R824 686 687 1.744 0.8 13.952 37
I687 0 687 1.24921e-05
R825 687 688 1.648 0.8 13.184 37
I688 0 688 1.28631e-05
R826 688 689 1.664 0.8 13.312 37
I689 0 689 1.33579e-05
R827 689 690 1.712 0.8 13.696 37
I690 0 690 1.23684e-05
R828 690 0 0.1 49.28 49.28 37
*seg: 70
R829 0 691 0.1 49.28 49.28 37
R830 695 705 6.16 0.8 49.28 37
I691 0 691 1.31105e-05
R831 691 692 1.696 0.8 13.568 37
I692 0 692 1.31105e-05
R832 692 693 1.728 0.8 13.824 37
I693 0 693 1.29868e-05
R833 693 694 1.6 0.8 12.8 37
I694 0 694 1.24921e-05
R834 694 695 1.6 0.8 12.8 37
I695 0 695 1.23684e-05
R835 695 696 1.696 0.8 13.568 37
I696 0 696 1.23684e-05
R836 696 697 1.696 0.8 13.568 37
I697 0 697 1.24921e-05
R837 697 698 1.712 0.8 13.696 37
I698 0 698 1.34816e-05
R838 698 699 1.744 0.8 13.952 37
I699 0 699 1.28631e-05
R839 699 700 1.712 0.8 13.696 37
I700 0 700 1.23684e-05
R840 700 0 0.1 49.28 49.28 37
*seg: 71
R841 0 701 0.1 49.28 49.28 37
R842 705 715 6.16 0.8 49.28 37
I701 0 701 1.31105e-05
R843 701 702 1.6 0.8 12.8 37
I702 0 702 1.29868e-05
R844 702 703 1.632 0.8 13.056 37
I703 0 703 1.24921e-05
R845 703 704 1.648 0.8 13.184 37
I704 0 704 1.34816e-05
R846 704 705 1.6 0.8 12.8 37
I705 0 705 1.31105e-05
R847 705 706 1.616 0.8 12.928 37
I706 0 706 1.27395e-05
R848 706 707 1.6 0.8 12.8 37
I707 0 707 1.29868e-05
R849 707 708 1.68 0.8 13.44 37
I708 0 708 1.28631e-05
R850 708 709 1.68 0.8 13.44 37
I709 0 709 1.31105e-05
R851 709 710 1.696 0.8 13.568 37
I710 0 710 1.23684e-05
R852 710 0 0.1 49.28 49.28 37
*seg: 72
R853 0 711 0.1 49.28 49.28 37
R854 715 725 6.16 0.8 49.28 37
I711 0 711 1.23684e-05
R855 711 712 1.728 0.8 13.824 37
I712 0 712 1.23684e-05
R856 712 713 1.648 0.8 13.184 37
I713 0 713 1.27395e-05
R857 713 714 1.648 0.8 13.184 37
I714 0 714 1.23684e-05
R858 714 715 1.664 0.8 13.312 37
I715 0 715 1.31105e-05
R859 715 716 1.744 0.8 13.952 37
I716 0 716 1.23684e-05
R860 716 717 1.664 0.8 13.312 37
I717 0 717 1.28631e-05
R861 717 718 1.616 0.8 12.928 37
I718 0 718 1.26158e-05
R862 718 719 1.648 0.8 13.184 37
I719 0 719 1.23684e-05
R863 719 720 1.696 0.8 13.568 37
I720 0 720 1.23684e-05
R864 720 0 0.1 49.28 49.28 37
*seg: 73
R865 0 721 0.1 49.28 49.28 37
R866 725 735 6.16 0.8 49.28 37
I721 0 721 1.29868e-05
R867 721 722 1.616 0.8 12.928 37
I722 0 722 1.29868e-05
R868 722 723 1.616 0.8 12.928 37
I723 0 723 1.28631e-05
R869 723 724 1.68 0.8 13.44 37
I724 0 724 1.34816e-05
R870 724 725 1.68 0.8 13.44 37
I725 0 725 1.31105e-05
R871 725 726 1.696 0.8 13.568 37
I726 0 726 1.31105e-05
R872 726 727 1.616 0.8 12.928 37
I727 0 727 1.23684e-05
R873 727 728 1.68 0.8 13.44 37
I728 0 728 1.23684e-05
R874 728 729 1.744 0.8 13.952 37
I729 0 729 1.32342e-05
R875 729 730 1.616 0.8 12.928 37
I730 0 730 1.23684e-05
R876 730 0 0.1 49.28 49.28 37
*seg: 74
R877 0 731 0.1 49.28 49.28 37
R878 735 745 6.16 0.8 49.28 37
I731 0 731 1.28631e-05
R879 731 732 1.712 0.8 13.696 37
I732 0 732 1.26158e-05
R880 732 733 1.616 0.8 12.928 37
I733 0 733 1.31105e-05
R881 733 734 1.68 0.8 13.44 37
I734 0 734 1.32342e-05
R882 734 735 1.68 0.8 13.44 37
I735 0 735 1.27395e-05
R883 735 736 1.632 0.8 13.056 37
I736 0 736 1.29868e-05
R884 736 737 1.68 0.8 13.44 37
I737 0 737 1.32342e-05
R885 737 738 1.696 0.8 13.568 37
I738 0 738 1.24921e-05
R886 738 739 1.6 0.8 12.8 37
I739 0 739 1.29868e-05
R887 739 740 1.744 0.8 13.952 37
I740 0 740 1.23684e-05
R888 740 0 0.1 49.28 49.28 37
*seg: 75
R889 0 741 0.1 49.28 49.28 37
R890 745 755 6.16 0.8 49.28 37
I741 0 741 1.24921e-05
R891 741 742 1.6 0.8 12.8 37
I742 0 742 1.27395e-05
R892 742 743 1.712 0.8 13.696 37
I743 0 743 1.29868e-05
R893 743 744 1.632 0.8 13.056 37
I744 0 744 1.24921e-05
R894 744 745 1.744 0.8 13.952 37
I745 0 745 1.26158e-05
R895 745 746 1.632 0.8 13.056 37
I746 0 746 1.29868e-05
R896 746 747 1.744 0.8 13.952 37
I747 0 747 1.23684e-05
R897 747 748 1.616 0.8 12.928 37
I748 0 748 1.24921e-05
R898 748 749 1.696 0.8 13.568 37
I749 0 749 1.23684e-05
R899 749 750 1.664 0.8 13.312 37
I750 0 750 1.23684e-05
R900 750 0 0.1 49.28 49.28 37
*seg: 76
R901 0 751 0.1 49.28 49.28 37
R902 755 765 6.16 0.8 49.28 37
I751 0 751 1.27395e-05
R903 751 752 1.648 0.8 13.184 37
I752 0 752 1.31105e-05
R904 752 753 1.744 0.8 13.952 37
I753 0 753 1.31105e-05
R905 753 754 1.632 0.8 13.056 37
I754 0 754 1.34816e-05
R906 754 755 1.744 0.8 13.952 37
I755 0 755 1.34816e-05
R907 755 756 1.632 0.8 13.056 37
I756 0 756 1.33579e-05
R908 756 757 1.68 0.8 13.44 37
I757 0 757 1.33579e-05
R909 757 758 1.696 0.8 13.568 37
I758 0 758 1.29868e-05
R910 758 759 1.616 0.8 12.928 37
I759 0 759 1.28631e-05
R911 759 760 1.664 0.8 13.312 37
I760 0 760 1.23684e-05
R912 760 0 0.1 49.28 49.28 37
*seg: 77
R913 0 761 0.1 49.28 49.28 37
R914 765 775 6.16 0.8 49.28 37
I761 0 761 1.34816e-05
R915 761 762 1.696 0.8 13.568 37
I762 0 762 1.31105e-05
R916 762 763 1.664 0.8 13.312 37
I763 0 763 1.33579e-05
R917 763 764 1.6 0.8 12.8 37
I764 0 764 1.33579e-05
R918 764 765 1.6 0.8 12.8 37
I765 0 765 1.23684e-05
R919 765 766 1.744 0.8 13.952 37
I766 0 766 1.32342e-05
R920 766 767 1.648 0.8 13.184 37
I767 0 767 1.29868e-05
R921 767 768 1.664 0.8 13.312 37
I768 0 768 1.33579e-05
R922 768 769 1.616 0.8 12.928 37
I769 0 769 1.23684e-05
R923 769 770 1.712 0.8 13.696 37
I770 0 770 1.23684e-05
R924 770 0 0.1 49.28 49.28 37
*seg: 78
R925 0 771 0.1 49.28 49.28 37
R926 775 785 6.16 0.8 49.28 37
I771 0 771 1.32342e-05
R927 771 772 1.712 0.8 13.696 37
I772 0 772 1.28631e-05
R928 772 773 1.648 0.8 13.184 37
I773 0 773 1.23684e-05
R929 773 774 1.6 0.8 12.8 37
I774 0 774 1.24921e-05
R930 774 775 1.696 0.8 13.568 37
I775 0 775 1.24921e-05
R931 775 776 1.648 0.8 13.184 37
I776 0 776 1.29868e-05
R932 776 777 1.632 0.8 13.056 37
I777 0 777 1.28631e-05
R933 777 778 1.632 0.8 13.056 37
I778 0 778 1.33579e-05
R934 778 779 1.648 0.8 13.184 37
I779 0 779 1.32342e-05
R935 779 780 1.6 0.8 12.8 37
I780 0 780 1.23684e-05
R936 780 0 0.1 49.28 49.28 37
*seg: 79
R937 0 781 0.1 49.28 49.28 37
R938 785 795 6.16 0.8 49.28 37
I781 0 781 1.34816e-05
R939 781 782 1.696 0.8 13.568 37
I782 0 782 1.27395e-05
R940 782 783 1.6 0.8 12.8 37
I783 0 783 1.23684e-05
R941 783 784 1.728 0.8 13.824 37
I784 0 784 1.29868e-05
R942 784 785 1.712 0.8 13.696 37
I785 0 785 1.27395e-05
R943 785 786 1.6 0.8 12.8 37
I786 0 786 1.33579e-05
R944 786 787 1.648 0.8 13.184 37
I787 0 787 1.24921e-05
R945 787 788 1.696 0.8 13.568 37
I788 0 788 1.26158e-05
R946 788 789 1.648 0.8 13.184 37
I789 0 789 1.34816e-05
R947 789 790 1.6 0.8 12.8 37
I790 0 790 1.23684e-05
R948 790 0 0.1 49.28 49.28 37
*seg: 80
R949 0 791 0.1 49.28 49.28 37
R950 795 805 6.16 0.8 49.28 37
I791 0 791 1.27395e-05
R951 791 792 1.6 0.8 12.8 37
I792 0 792 1.29868e-05
R952 792 793 1.696 0.8 13.568 37
I793 0 793 1.31105e-05
R953 793 794 1.664 0.8 13.312 37
I794 0 794 1.34816e-05
R954 794 795 1.616 0.8 12.928 37
I795 0 795 1.23684e-05
R955 795 796 1.744 0.8 13.952 37
I796 0 796 1.28631e-05
R956 796 797 1.68 0.8 13.44 37
I797 0 797 1.32342e-05
R957 797 798 1.68 0.8 13.44 37
I798 0 798 1.27395e-05
R958 798 799 1.616 0.8 12.928 37
I799 0 799 1.29868e-05
R959 799 800 1.6 0.8 12.8 37
I800 0 800 1.23684e-05
R960 800 0 0.1 49.28 49.28 37
*seg: 81
R961 0 801 0.1 49.28 49.28 37
R962 805 815 6.16 0.8 49.28 37
I801 0 801 1.26158e-05
R963 801 802 1.744 0.8 13.952 37
I802 0 802 1.27395e-05
R964 802 803 1.664 0.8 13.312 37
I803 0 803 1.26158e-05
R965 803 804 1.744 0.8 13.952 37
I804 0 804 1.29868e-05
R966 804 805 1.712 0.8 13.696 37
I805 0 805 1.29868e-05
R967 805 806 1.712 0.8 13.696 37
I806 0 806 1.33579e-05
R968 806 807 1.728 0.8 13.824 37
I807 0 807 1.32342e-05
R969 807 808 1.744 0.8 13.952 37
I808 0 808 1.23684e-05
R970 808 809 1.712 0.8 13.696 37
I809 0 809 1.24921e-05
R971 809 810 1.648 0.8 13.184 37
I810 0 810 1.23684e-05
R972 810 0 0.1 49.28 49.28 37
*seg: 82
R973 0 811 0.1 49.28 49.28 37
R974 815 825 6.16 0.8 49.28 37
I811 0 811 1.33579e-05
R975 811 812 1.6 0.8 12.8 37
I812 0 812 1.32342e-05
R976 812 813 1.712 0.8 13.696 37
I813 0 813 1.29868e-05
R977 813 814 1.68 0.8 13.44 37
I814 0 814 1.26158e-05
R978 814 815 1.744 0.8 13.952 37
I815 0 815 1.27395e-05
R979 815 816 1.664 0.8 13.312 37
I816 0 816 1.32342e-05
R980 816 817 1.696 0.8 13.568 37
I817 0 817 1.24921e-05
R981 817 818 1.664 0.8 13.312 37
I818 0 818 1.31105e-05
R982 818 819 1.68 0.8 13.44 37
I819 0 819 1.26158e-05
R983 819 820 1.68 0.8 13.44 37
I820 0 820 1.23684e-05
R984 820 0 0.1 49.28 49.28 37
*seg: 83
R985 0 821 0.1 49.28 49.28 37
R986 825 835 6.16 0.8 49.28 37
I821 0 821 1.28631e-05
R987 821 822 1.632 0.8 13.056 37
I822 0 822 1.33579e-05
R988 822 823 1.6 0.8 12.8 37
I823 0 823 1.24921e-05
R989 823 824 1.728 0.8 13.824 37
I824 0 824 1.28631e-05
R990 824 825 1.728 0.8 13.824 37
I825 0 825 1.23684e-05
R991 825 826 1.632 0.8 13.056 37
I826 0 826 1.23684e-05
R992 826 827 1.728 0.8 13.824 37
I827 0 827 1.31105e-05
R993 827 828 1.664 0.8 13.312 37
I828 0 828 1.33579e-05
R994 828 829 1.712 0.8 13.696 37
I829 0 829 1.23684e-05
R995 829 830 1.6 0.8 12.8 37
I830 0 830 1.23684e-05
R996 830 0 0.1 49.28 49.28 37
*seg: 84
R997 0 831 0.1 49.28 49.28 37
R998 835 845 6.16 0.8 49.28 37
I831 0 831 1.32342e-05
R999 831 832 1.632 0.8 13.056 37
I832 0 832 1.28631e-05
R1000 832 833 1.696 0.8 13.568 37
I833 0 833 1.27395e-05
R1001 833 834 1.728 0.8 13.824 37
I834 0 834 1.24921e-05
R1002 834 835 1.6 0.8 12.8 37
I835 0 835 1.32342e-05
R1003 835 836 1.68 0.8 13.44 37
I836 0 836 1.34816e-05
R1004 836 837 1.648 0.8 13.184 37
I837 0 837 1.27395e-05
R1005 837 838 1.6 0.8 12.8 37
I838 0 838 1.33579e-05
R1006 838 839 1.6 0.8 12.8 37
I839 0 839 1.32342e-05
R1007 839 840 1.6 0.8 12.8 37
I840 0 840 1.23684e-05
R1008 840 0 0.1 49.28 49.28 37
*seg: 85
R1009 0 841 0.1 49.28 49.28 37
R1010 845 855 6.16 0.8 49.28 37
I841 0 841 1.27395e-05
R1011 841 842 1.728 0.8 13.824 37
I842 0 842 1.33579e-05
R1012 842 843 1.664 0.8 13.312 37
I843 0 843 1.31105e-05
R1013 843 844 1.712 0.8 13.696 37
I844 0 844 1.28631e-05
R1014 844 845 1.712 0.8 13.696 37
I845 0 845 1.29868e-05
R1015 845 846 1.616 0.8 12.928 37
I846 0 846 1.33579e-05
R1016 846 847 1.6 0.8 12.8 37
I847 0 847 1.23684e-05
R1017 847 848 1.648 0.8 13.184 37
I848 0 848 1.31105e-05
R1018 848 849 1.744 0.8 13.952 37
I849 0 849 1.26158e-05
R1019 849 850 1.68 0.8 13.44 37
I850 0 850 1.23684e-05
R1020 850 0 0.1 49.28 49.28 37
*seg: 86
R1021 0 851 0.1 49.28 49.28 37
R1022 855 865 6.16 0.8 49.28 37
I851 0 851 1.34816e-05
R1023 851 852 1.68 0.8 13.44 37
I852 0 852 1.32342e-05
R1024 852 853 1.616 0.8 12.928 37
I853 0 853 1.28631e-05
R1025 853 854 1.68 0.8 13.44 37
I854 0 854 1.27395e-05
R1026 854 855 1.744 0.8 13.952 37
I855 0 855 1.27395e-05
R1027 855 856 1.744 0.8 13.952 37
I856 0 856 1.24921e-05
R1028 856 857 1.728 0.8 13.824 37
I857 0 857 1.32342e-05
R1029 857 858 1.68 0.8 13.44 37
I858 0 858 1.23684e-05
R1030 858 859 1.68 0.8 13.44 37
I859 0 859 1.29868e-05
R1031 859 860 1.664 0.8 13.312 37
I860 0 860 1.23684e-05
R1032 860 0 0.1 49.28 49.28 37
*seg: 87
R1033 0 861 0.1 49.28 49.28 37
R1034 865 875 6.16 0.8 49.28 37
I861 0 861 1.27395e-05
R1035 861 862 1.632 0.8 13.056 37
I862 0 862 1.28631e-05
R1036 862 863 1.648 0.8 13.184 37
I863 0 863 1.24921e-05
R1037 863 864 1.648 0.8 13.184 37
I864 0 864 1.26158e-05
R1038 864 865 1.664 0.8 13.312 37
I865 0 865 1.31105e-05
R1039 865 866 1.648 0.8 13.184 37
I866 0 866 1.32342e-05
R1040 866 867 1.728 0.8 13.824 37
I867 0 867 1.27395e-05
R1041 867 868 1.68 0.8 13.44 37
I868 0 868 1.28631e-05
R1042 868 869 1.696 0.8 13.568 37
I869 0 869 1.26158e-05
R1043 869 870 1.696 0.8 13.568 37
I870 0 870 1.23684e-05
R1044 870 0 0.1 49.28 49.28 37
*seg: 88
R1045 0 871 0.1 49.28 49.28 37
R1046 875 885 6.16 0.8 49.28 37
I871 0 871 1.28631e-05
R1047 871 872 1.616 0.8 12.928 37
I872 0 872 1.23684e-05
R1048 872 873 1.6 0.8 12.8 37
I873 0 873 1.33579e-05
R1049 873 874 1.664 0.8 13.312 37
I874 0 874 1.32342e-05
R1050 874 875 1.712 0.8 13.696 37
I875 0 875 1.27395e-05
R1051 875 876 1.6 0.8 12.8 37
I876 0 876 1.33579e-05
R1052 876 877 1.664 0.8 13.312 37
I877 0 877 1.28631e-05
R1053 877 878 1.6 0.8 12.8 37
I878 0 878 1.28631e-05
R1054 878 879 1.616 0.8 12.928 37
I879 0 879 1.29868e-05
R1055 879 880 1.664 0.8 13.312 37
I880 0 880 1.23684e-05
R1056 880 0 0.1 49.28 49.28 37
*seg: 89
R1057 0 881 0.1 49.28 49.28 37
R1058 885 895 6.16 0.8 49.28 37
I881 0 881 1.27395e-05
R1059 881 882 1.616 0.8 12.928 37
I882 0 882 1.24921e-05
R1060 882 883 1.744 0.8 13.952 37
I883 0 883 1.33579e-05
R1061 883 884 1.68 0.8 13.44 37
I884 0 884 1.24921e-05
R1062 884 885 1.712 0.8 13.696 37
I885 0 885 1.29868e-05
R1063 885 886 1.632 0.8 13.056 37
I886 0 886 1.32342e-05
R1064 886 887 1.648 0.8 13.184 37
I887 0 887 1.26158e-05
R1065 887 888 1.728 0.8 13.824 37
I888 0 888 1.28631e-05
R1066 888 889 1.744 0.8 13.952 37
I889 0 889 1.34816e-05
R1067 889 890 1.632 0.8 13.056 37
I890 0 890 1.23684e-05
R1068 890 0 0.1 49.28 49.28 37
*seg: 90
R1069 0 891 0.1 49.28 49.28 37
R1070 895 905 6.16 0.8 49.28 37
I891 0 891 1.23684e-05
R1071 891 892 1.696 0.8 13.568 37
I892 0 892 1.31105e-05
R1072 892 893 1.616 0.8 12.928 37
I893 0 893 1.32342e-05
R1073 893 894 1.616 0.8 12.928 37
I894 0 894 1.27395e-05
R1074 894 895 1.712 0.8 13.696 37
I895 0 895 1.34816e-05
R1075 895 896 1.648 0.8 13.184 37
I896 0 896 1.33579e-05
R1076 896 897 1.712 0.8 13.696 37
I897 0 897 1.27395e-05
R1077 897 898 1.696 0.8 13.568 37
I898 0 898 1.34816e-05
R1078 898 899 1.664 0.8 13.312 37
I899 0 899 1.28631e-05
R1079 899 900 1.632 0.8 13.056 37
I900 0 900 1.23684e-05
R1080 900 0 0.1 49.28 49.28 37
*seg: 91
R1081 0 901 0.1 49.28 49.28 37
R1082 905 915 6.16 0.8 49.28 37
I901 0 901 1.28631e-05
R1083 901 902 1.664 0.8 13.312 37
I902 0 902 1.29868e-05
R1084 902 903 1.664 0.8 13.312 37
I903 0 903 1.31105e-05
R1085 903 904 1.664 0.8 13.312 37
I904 0 904 1.29868e-05
R1086 904 905 1.696 0.8 13.568 37
I905 0 905 1.29868e-05
R1087 905 906 1.632 0.8 13.056 37
I906 0 906 1.27395e-05
R1088 906 907 1.712 0.8 13.696 37
I907 0 907 1.31105e-05
R1089 907 908 1.664 0.8 13.312 37
I908 0 908 1.26158e-05
R1090 908 909 1.616 0.8 12.928 37
I909 0 909 1.23684e-05
R1091 909 910 1.68 0.8 13.44 37
I910 0 910 1.23684e-05
R1092 910 0 0.1 49.28 49.28 37
*seg: 92
R1093 0 911 0.1 49.28 49.28 37
R1094 915 925 6.16 0.8 49.28 37
I911 0 911 1.23684e-05
R1095 911 912 1.632 0.8 13.056 37
I912 0 912 1.28631e-05
R1096 912 913 1.744 0.8 13.952 37
I913 0 913 1.24921e-05
R1097 913 914 1.68 0.8 13.44 37
I914 0 914 1.28631e-05
R1098 914 915 1.712 0.8 13.696 37
I915 0 915 1.34816e-05
R1099 915 916 1.648 0.8 13.184 37
I916 0 916 1.24921e-05
R1100 916 917 1.648 0.8 13.184 37
I917 0 917 1.28631e-05
R1101 917 918 1.616 0.8 12.928 37
I918 0 918 1.24921e-05
R1102 918 919 1.648 0.8 13.184 37
I919 0 919 1.33579e-05
R1103 919 920 1.744 0.8 13.952 37
I920 0 920 1.23684e-05
R1104 920 0 0.1 49.28 49.28 37
*seg: 93
R1105 0 921 0.1 49.28 49.28 37
R1106 925 935 6.16 0.8 49.28 37
I921 0 921 1.34816e-05
R1107 921 922 1.632 0.8 13.056 37
I922 0 922 1.34816e-05
R1108 922 923 1.744 0.8 13.952 37
I923 0 923 1.28631e-05
R1109 923 924 1.712 0.8 13.696 37
I924 0 924 1.26158e-05
R1110 924 925 1.728 0.8 13.824 37
I925 0 925 1.23684e-05
R1111 925 926 1.728 0.8 13.824 37
I926 0 926 1.32342e-05
R1112 926 927 1.632 0.8 13.056 37
I927 0 927 1.23684e-05
R1113 927 928 1.696 0.8 13.568 37
I928 0 928 1.33579e-05
R1114 928 929 1.712 0.8 13.696 37
I929 0 929 1.32342e-05
R1115 929 930 1.744 0.8 13.952 37
I930 0 930 1.23684e-05
R1116 930 0 0.1 49.28 49.28 37
*seg: 94
R1117 0 931 0.1 49.28 49.28 37
R1118 935 945 6.16 0.8 49.28 37
I931 0 931 1.34816e-05
R1119 931 932 1.6 0.8 12.8 37
I932 0 932 1.29868e-05
R1120 932 933 1.68 0.8 13.44 37
I933 0 933 1.33579e-05
R1121 933 934 1.648 0.8 13.184 37
I934 0 934 1.26158e-05
R1122 934 935 1.664 0.8 13.312 37
I935 0 935 1.29868e-05
R1123 935 936 1.712 0.8 13.696 37
I936 0 936 1.32342e-05
R1124 936 937 1.648 0.8 13.184 37
I937 0 937 1.31105e-05
R1125 937 938 1.696 0.8 13.568 37
I938 0 938 1.34816e-05
R1126 938 939 1.632 0.8 13.056 37
I939 0 939 1.32342e-05
R1127 939 940 1.696 0.8 13.568 37
I940 0 940 1.23684e-05
R1128 940 0 0.1 49.28 49.28 37
*seg: 95
R1129 0 941 0.1 49.28 49.28 37
R1130 945 955 6.16 0.8 49.28 37
I941 0 941 1.23684e-05
R1131 941 942 1.696 0.8 13.568 37
I942 0 942 1.34816e-05
R1132 942 943 1.744 0.8 13.952 37
I943 0 943 1.27395e-05
R1133 943 944 1.68 0.8 13.44 37
I944 0 944 1.26158e-05
R1134 944 945 1.712 0.8 13.696 37
I945 0 945 1.27395e-05
R1135 945 946 1.68 0.8 13.44 37
I946 0 946 1.23684e-05
R1136 946 947 1.616 0.8 12.928 37
I947 0 947 1.27395e-05
R1137 947 948 1.648 0.8 13.184 37
I948 0 948 1.32342e-05
R1138 948 949 1.664 0.8 13.312 37
I949 0 949 1.33579e-05
R1139 949 950 1.664 0.8 13.312 37
I950 0 950 1.23684e-05
R1140 950 0 0.1 49.28 49.28 37
*seg: 96
R1141 0 951 0.1 49.28 49.28 37
R1142 955 965 6.16 0.8 49.28 37
I951 0 951 1.28631e-05
R1143 951 952 1.728 0.8 13.824 37
I952 0 952 1.33579e-05
R1144 952 953 1.696 0.8 13.568 37
I953 0 953 1.26158e-05
R1145 953 954 1.6 0.8 12.8 37
I954 0 954 1.29868e-05
R1146 954 955 1.696 0.8 13.568 37
I955 0 955 1.34816e-05
R1147 955 956 1.648 0.8 13.184 37
I956 0 956 1.23684e-05
R1148 956 957 1.744 0.8 13.952 37
I957 0 957 1.29868e-05
R1149 957 958 1.648 0.8 13.184 37
I958 0 958 1.23684e-05
R1150 958 959 1.664 0.8 13.312 37
I959 0 959 1.23684e-05
R1151 959 960 1.6 0.8 12.8 37
I960 0 960 1.23684e-05
R1152 960 0 0.1 49.28 49.28 37
*seg: 97
R1153 0 961 0.1 49.28 49.28 37
R1154 965 975 6.16 0.8 49.28 37
I961 0 961 1.27395e-05
R1155 961 962 1.632 0.8 13.056 37
I962 0 962 1.32342e-05
R1156 962 963 1.712 0.8 13.696 37
I963 0 963 1.32342e-05
R1157 963 964 1.616 0.8 12.928 37
I964 0 964 1.24921e-05
R1158 964 965 1.696 0.8 13.568 37
I965 0 965 1.33579e-05
R1159 965 966 1.696 0.8 13.568 37
I966 0 966 1.26158e-05
R1160 966 967 1.6 0.8 12.8 37
I967 0 967 1.28631e-05
R1161 967 968 1.632 0.8 13.056 37
I968 0 968 1.23684e-05
R1162 968 969 1.616 0.8 12.928 37
I969 0 969 1.32342e-05
R1163 969 970 1.616 0.8 12.928 37
I970 0 970 1.23684e-05
R1164 970 0 0.1 49.28 49.28 37
*seg: 98
R1165 0 971 0.1 49.28 49.28 37
R1166 975 985 6.16 0.8 49.28 37
I971 0 971 1.33579e-05
R1167 971 972 1.68 0.8 13.44 37
I972 0 972 1.29868e-05
R1168 972 973 1.744 0.8 13.952 37
I973 0 973 1.33579e-05
R1169 973 974 1.68 0.8 13.44 37
I974 0 974 1.28631e-05
R1170 974 975 1.728 0.8 13.824 37
I975 0 975 1.28631e-05
R1171 975 976 1.648 0.8 13.184 37
I976 0 976 1.29868e-05
R1172 976 977 1.744 0.8 13.952 37
I977 0 977 1.29868e-05
R1173 977 978 1.6 0.8 12.8 37
I978 0 978 1.27395e-05
R1174 978 979 1.648 0.8 13.184 37
I979 0 979 1.27395e-05
R1175 979 980 1.696 0.8 13.568 37
I980 0 980 1.23684e-05
R1176 980 0 0.1 49.28 49.28 37
*seg: 99
R1177 0 981 0.1 49.28 49.28 37
R1178 985 995 6.16 0.8 49.28 37
I981 0 981 1.33579e-05
R1179 981 982 1.744 0.8 13.952 37
I982 0 982 1.31105e-05
R1180 982 983 1.6 0.8 12.8 37
I983 0 983 1.31105e-05
R1181 983 984 1.696 0.8 13.568 37
I984 0 984 1.28631e-05
R1182 984 985 1.696 0.8 13.568 37
I985 0 985 1.33579e-05
R1183 985 986 1.648 0.8 13.184 37
I986 0 986 1.32342e-05
R1184 986 987 1.696 0.8 13.568 37
I987 0 987 1.23684e-05
R1185 987 988 1.616 0.8 12.928 37
I988 0 988 1.27395e-05
R1186 988 989 1.744 0.8 13.952 37
I989 0 989 1.32342e-05
R1187 989 990 1.744 0.8 13.952 37
I990 0 990 1.23684e-05
R1188 990 0 0.1 49.28 49.28 37
*seg: 100
R1189 0 991 0.1 49.28 49.28 37
R1190 995 1005 6.16 0.8 49.28 37
I991 0 991 1.28631e-05
R1191 991 992 1.664 0.8 13.312 37
I992 0 992 1.32342e-05
R1192 992 993 1.664 0.8 13.312 37
I993 0 993 1.32342e-05
R1193 993 994 1.696 0.8 13.568 37
I994 0 994 1.23684e-05
R1194 994 995 1.728 0.8 13.824 37
I995 0 995 1.26158e-05
R1195 995 996 1.68 0.8 13.44 37
I996 0 996 1.27395e-05
R1196 996 997 1.712 0.8 13.696 37
I997 0 997 1.32342e-05
R1197 997 998 1.728 0.8 13.824 37
I998 0 998 1.23684e-05
R1198 998 999 1.728 0.8 13.824 37
I999 0 999 1.32342e-05
R1199 999 1000 1.696 0.8 13.568 37
I1000 0 1000 1.23684e-05
R1200 1000 0 0.1 49.28 49.28 37
*seg: 101
R1201 0 1001 0.1 49.28 49.28 37
R1202 1005 1015 6.16 0.8 49.28 37
I1001 0 1001 1.26158e-05
R1203 1001 1002 1.664 0.8 13.312 37
I1002 0 1002 1.31105e-05
R1204 1002 1003 1.728 0.8 13.824 37
I1003 0 1003 1.34816e-05
R1205 1003 1004 1.648 0.8 13.184 37
I1004 0 1004 1.24921e-05
R1206 1004 1005 1.6 0.8 12.8 37
I1005 0 1005 1.32342e-05
R1207 1005 1006 1.648 0.8 13.184 37
I1006 0 1006 1.31105e-05
R1208 1006 1007 1.616 0.8 12.928 37
I1007 0 1007 1.31105e-05
R1209 1007 1008 1.648 0.8 13.184 37
I1008 0 1008 1.27395e-05
R1210 1008 1009 1.728 0.8 13.824 37
I1009 0 1009 1.29868e-05
R1211 1009 1010 1.664 0.8 13.312 37
I1010 0 1010 1.23684e-05
R1212 1010 0 0.1 49.28 49.28 37
*seg: 102
R1213 0 1011 0.1 49.28 49.28 37
R1214 1015 1025 6.16 0.8 49.28 37
I1011 0 1011 1.31105e-05
R1215 1011 1012 1.744 0.8 13.952 37
I1012 0 1012 1.23684e-05
R1216 1012 1013 1.68 0.8 13.44 37
I1013 0 1013 1.32342e-05
R1217 1013 1014 1.648 0.8 13.184 37
I1014 0 1014 1.24921e-05
R1218 1014 1015 1.696 0.8 13.568 37
I1015 0 1015 1.32342e-05
R1219 1015 1016 1.664 0.8 13.312 37
I1016 0 1016 1.32342e-05
R1220 1016 1017 1.6 0.8 12.8 37
I1017 0 1017 1.31105e-05
R1221 1017 1018 1.6 0.8 12.8 37
I1018 0 1018 1.23684e-05
R1222 1018 1019 1.696 0.8 13.568 37
I1019 0 1019 1.29868e-05
R1223 1019 1020 1.68 0.8 13.44 37
I1020 0 1020 1.23684e-05
R1224 1020 0 0.1 49.28 49.28 37
*seg: 103
R1225 0 1021 0.1 49.28 49.28 37
R1226 1025 1035 6.16 0.8 49.28 37
I1021 0 1021 1.34816e-05
R1227 1021 1022 1.696 0.8 13.568 37
I1022 0 1022 1.34816e-05
R1228 1022 1023 1.664 0.8 13.312 37
I1023 0 1023 1.29868e-05
R1229 1023 1024 1.6 0.8 12.8 37
I1024 0 1024 1.32342e-05
R1230 1024 1025 1.664 0.8 13.312 37
I1025 0 1025 1.26158e-05
R1231 1025 1026 1.632 0.8 13.056 37
I1026 0 1026 1.23684e-05
R1232 1026 1027 1.616 0.8 12.928 37
I1027 0 1027 1.28631e-05
R1233 1027 1028 1.616 0.8 12.928 37
I1028 0 1028 1.26158e-05
R1234 1028 1029 1.744 0.8 13.952 37
I1029 0 1029 1.33579e-05
R1235 1029 1030 1.744 0.8 13.952 37
I1030 0 1030 1.23684e-05
R1236 1030 0 0.1 49.28 49.28 37
*seg: 104
R1237 0 1031 0.1 49.28 49.28 37
R1238 1035 1045 6.16 0.8 49.28 37
I1031 0 1031 1.32342e-05
R1239 1031 1032 1.6 0.8 12.8 37
I1032 0 1032 1.31105e-05
R1240 1032 1033 1.744 0.8 13.952 37
I1033 0 1033 1.34816e-05
R1241 1033 1034 1.648 0.8 13.184 37
I1034 0 1034 1.33579e-05
R1242 1034 1035 1.632 0.8 13.056 37
I1035 0 1035 1.34816e-05
R1243 1035 1036 1.632 0.8 13.056 37
I1036 0 1036 1.26158e-05
R1244 1036 1037 1.616 0.8 12.928 37
I1037 0 1037 1.34816e-05
R1245 1037 1038 1.712 0.8 13.696 37
I1038 0 1038 1.31105e-05
R1246 1038 1039 1.744 0.8 13.952 37
I1039 0 1039 1.33579e-05
R1247 1039 1040 1.728 0.8 13.824 37
I1040 0 1040 1.23684e-05
R1248 1040 0 0.1 49.28 49.28 37
*seg: 105
R1249 0 1041 0.1 49.28 49.28 37
R1250 1045 1055 6.16 0.8 49.28 37
I1041 0 1041 1.33579e-05
R1251 1041 1042 1.712 0.8 13.696 37
I1042 0 1042 1.28631e-05
R1252 1042 1043 1.664 0.8 13.312 37
I1043 0 1043 1.34816e-05
R1253 1043 1044 1.744 0.8 13.952 37
I1044 0 1044 1.33579e-05
R1254 1044 1045 1.744 0.8 13.952 37
I1045 0 1045 1.33579e-05
R1255 1045 1046 1.728 0.8 13.824 37
I1046 0 1046 1.31105e-05
R1256 1046 1047 1.728 0.8 13.824 37
I1047 0 1047 1.24921e-05
R1257 1047 1048 1.632 0.8 13.056 37
I1048 0 1048 1.34816e-05
R1258 1048 1049 1.6 0.8 12.8 37
I1049 0 1049 1.33579e-05
R1259 1049 1050 1.728 0.8 13.824 37
I1050 0 1050 1.23684e-05
R1260 1050 0 0.1 49.28 49.28 37
*seg: 106
R1261 0 1051 0.1 49.28 49.28 37
R1262 1055 1065 6.16 0.8 49.28 37
I1051 0 1051 1.33579e-05
R1263 1051 1052 1.712 0.8 13.696 37
I1052 0 1052 1.31105e-05
R1264 1052 1053 1.632 0.8 13.056 37
I1053 0 1053 1.26158e-05
R1265 1053 1054 1.728 0.8 13.824 37
I1054 0 1054 1.31105e-05
R1266 1054 1055 1.6 0.8 12.8 37
I1055 0 1055 1.34816e-05
R1267 1055 1056 1.664 0.8 13.312 37
I1056 0 1056 1.29868e-05
R1268 1056 1057 1.696 0.8 13.568 37
I1057 0 1057 1.31105e-05
R1269 1057 1058 1.696 0.8 13.568 37
I1058 0 1058 1.23684e-05
R1270 1058 1059 1.648 0.8 13.184 37
I1059 0 1059 1.33579e-05
R1271 1059 1060 1.696 0.8 13.568 37
I1060 0 1060 1.23684e-05
R1272 1060 0 0.1 49.28 49.28 37
*seg: 107
R1273 0 1061 0.1 49.28 49.28 37
R1274 1065 1075 6.16 0.8 49.28 37
I1061 0 1061 1.26158e-05
R1275 1061 1062 1.712 0.8 13.696 37
I1062 0 1062 1.32342e-05
R1276 1062 1063 1.632 0.8 13.056 37
I1063 0 1063 1.34816e-05
R1277 1063 1064 1.712 0.8 13.696 37
I1064 0 1064 1.23684e-05
R1278 1064 1065 1.664 0.8 13.312 37
I1065 0 1065 1.34816e-05
R1279 1065 1066 1.648 0.8 13.184 37
I1066 0 1066 1.23684e-05
R1280 1066 1067 1.744 0.8 13.952 37
I1067 0 1067 1.32342e-05
R1281 1067 1068 1.632 0.8 13.056 37
I1068 0 1068 1.34816e-05
R1282 1068 1069 1.744 0.8 13.952 37
I1069 0 1069 1.32342e-05
R1283 1069 1070 1.632 0.8 13.056 37
I1070 0 1070 1.23684e-05
R1284 1070 0 0.1 49.28 49.28 37
*seg: 108
R1285 0 1071 0.1 49.28 49.28 37
R1286 1075 1085 6.16 0.8 49.28 37
I1071 0 1071 1.34816e-05
R1287 1071 1072 1.664 0.8 13.312 37
I1072 0 1072 1.29868e-05
R1288 1072 1073 1.6 0.8 12.8 37
I1073 0 1073 1.27395e-05
R1289 1073 1074 1.696 0.8 13.568 37
I1074 0 1074 1.31105e-05
R1290 1074 1075 1.664 0.8 13.312 37
I1075 0 1075 1.32342e-05
R1291 1075 1076 1.744 0.8 13.952 37
I1076 0 1076 1.31105e-05
R1292 1076 1077 1.632 0.8 13.056 37
I1077 0 1077 1.24921e-05
R1293 1077 1078 1.616 0.8 12.928 37
I1078 0 1078 1.29868e-05
R1294 1078 1079 1.648 0.8 13.184 37
I1079 0 1079 1.31105e-05
R1295 1079 1080 1.696 0.8 13.568 37
I1080 0 1080 1.23684e-05
R1296 1080 0 0.1 49.28 49.28 37
*seg: 109
R1297 0 1081 0.1 49.28 49.28 37
R1298 1085 1095 6.16 0.8 49.28 37
I1081 0 1081 1.32342e-05
R1299 1081 1082 1.744 0.8 13.952 37
I1082 0 1082 1.31105e-05
R1300 1082 1083 1.616 0.8 12.928 37
I1083 0 1083 1.26158e-05
R1301 1083 1084 1.744 0.8 13.952 37
I1084 0 1084 1.31105e-05
R1302 1084 1085 1.744 0.8 13.952 37
I1085 0 1085 1.26158e-05
R1303 1085 1086 1.696 0.8 13.568 37
I1086 0 1086 1.26158e-05
R1304 1086 1087 1.744 0.8 13.952 37
I1087 0 1087 1.34816e-05
R1305 1087 1088 1.712 0.8 13.696 37
I1088 0 1088 1.28631e-05
R1306 1088 1089 1.648 0.8 13.184 37
I1089 0 1089 1.33579e-05
R1307 1089 1090 1.6 0.8 12.8 37
I1090 0 1090 1.23684e-05
R1308 1090 0 0.1 49.28 49.28 37
*seg: 110
R1309 0 1091 0.1 49.28 49.28 37
R1310 1095 1105 6.16 0.8 49.28 37
I1091 0 1091 1.33579e-05
R1311 1091 1092 1.648 0.8 13.184 37
I1092 0 1092 1.27395e-05
R1312 1092 1093 1.6 0.8 12.8 37
I1093 0 1093 1.33579e-05
R1313 1093 1094 1.728 0.8 13.824 37
I1094 0 1094 1.28631e-05
R1314 1094 1095 1.6 0.8 12.8 37
I1095 0 1095 1.24921e-05
R1315 1095 1096 1.648 0.8 13.184 37
I1096 0 1096 1.23684e-05
R1316 1096 1097 1.632 0.8 13.056 37
I1097 0 1097 1.31105e-05
R1317 1097 1098 1.616 0.8 12.928 37
I1098 0 1098 1.31105e-05
R1318 1098 1099 1.744 0.8 13.952 37
I1099 0 1099 1.27395e-05
R1319 1099 1100 1.616 0.8 12.928 37
I1100 0 1100 1.23684e-05
R1320 1100 0 0.1 49.28 49.28 37
*seg: 111
R1321 0 1101 0.1 49.28 49.28 37
R1322 1105 1115 6.16 0.8 49.28 37
I1101 0 1101 1.26158e-05
R1323 1101 1102 1.696 0.8 13.568 37
I1102 0 1102 1.24921e-05
R1324 1102 1103 1.696 0.8 13.568 37
I1103 0 1103 1.32342e-05
R1325 1103 1104 1.744 0.8 13.952 37
I1104 0 1104 1.31105e-05
R1326 1104 1105 1.648 0.8 13.184 37
I1105 0 1105 1.24921e-05
R1327 1105 1106 1.728 0.8 13.824 37
I1106 0 1106 1.29868e-05
R1328 1106 1107 1.6 0.8 12.8 37
I1107 0 1107 1.32342e-05
R1329 1107 1108 1.728 0.8 13.824 37
I1108 0 1108 1.24921e-05
R1330 1108 1109 1.632 0.8 13.056 37
I1109 0 1109 1.24921e-05
R1331 1109 1110 1.728 0.8 13.824 37
I1110 0 1110 1.23684e-05
R1332 1110 0 0.1 49.28 49.28 37
*seg: 112
R1333 0 1111 0.1 49.28 49.28 37
R1334 1115 1125 6.16 0.8 49.28 37
I1111 0 1111 1.28631e-05
R1335 1111 1112 1.744 0.8 13.952 37
I1112 0 1112 1.32342e-05
R1336 1112 1113 1.648 0.8 13.184 37
I1113 0 1113 1.31105e-05
R1337 1113 1114 1.648 0.8 13.184 37
I1114 0 1114 1.28631e-05
R1338 1114 1115 1.664 0.8 13.312 37
I1115 0 1115 1.29868e-05
R1339 1115 1116 1.616 0.8 12.928 37
I1116 0 1116 1.29868e-05
R1340 1116 1117 1.728 0.8 13.824 37
I1117 0 1117 1.34816e-05
R1341 1117 1118 1.68 0.8 13.44 37
I1118 0 1118 1.31105e-05
R1342 1118 1119 1.616 0.8 12.928 37
I1119 0 1119 1.26158e-05
R1343 1119 1120 1.6 0.8 12.8 37
I1120 0 1120 1.23684e-05
R1344 1120 0 0.1 49.28 49.28 37
*seg: 113
R1345 0 1121 0.1 49.28 49.28 37
R1346 1125 1135 6.16 0.8 49.28 37
I1121 0 1121 1.24921e-05
R1347 1121 1122 1.6 0.8 12.8 37
I1122 0 1122 1.28631e-05
R1348 1122 1123 1.712 0.8 13.696 37
I1123 0 1123 1.32342e-05
R1349 1123 1124 1.68 0.8 13.44 37
I1124 0 1124 1.26158e-05
R1350 1124 1125 1.712 0.8 13.696 37
I1125 0 1125 1.31105e-05
R1351 1125 1126 1.744 0.8 13.952 37
I1126 0 1126 1.24921e-05
R1352 1126 1127 1.696 0.8 13.568 37
I1127 0 1127 1.26158e-05
R1353 1127 1128 1.6 0.8 12.8 37
I1128 0 1128 1.26158e-05
R1354 1128 1129 1.648 0.8 13.184 37
I1129 0 1129 1.27395e-05
R1355 1129 1130 1.6 0.8 12.8 37
I1130 0 1130 1.23684e-05
R1356 1130 0 0.1 49.28 49.28 37
*seg: 114
R1357 0 1131 0.1 49.28 49.28 37
R1358 1135 1145 6.16 0.8 49.28 37
I1131 0 1131 1.24921e-05
R1359 1131 1132 1.648 0.8 13.184 37
I1132 0 1132 1.29868e-05
R1360 1132 1133 1.664 0.8 13.312 37
I1133 0 1133 1.27395e-05
R1361 1133 1134 1.616 0.8 12.928 37
I1134 0 1134 1.34816e-05
R1362 1134 1135 1.744 0.8 13.952 37
I1135 0 1135 1.33579e-05
R1363 1135 1136 1.632 0.8 13.056 37
I1136 0 1136 1.27395e-05
R1364 1136 1137 1.664 0.8 13.312 37
I1137 0 1137 1.26158e-05
R1365 1137 1138 1.664 0.8 13.312 37
I1138 0 1138 1.31105e-05
R1366 1138 1139 1.664 0.8 13.312 37
I1139 0 1139 1.27395e-05
R1367 1139 1140 1.68 0.8 13.44 37
I1140 0 1140 1.23684e-05
R1368 1140 0 0.1 49.28 49.28 37
*seg: 115
R1369 0 1141 0.1 49.28 49.28 37
R1370 1145 1155 6.16 0.8 49.28 37
I1141 0 1141 1.32342e-05
R1371 1141 1142 1.6 0.8 12.8 37
I1142 0 1142 1.26158e-05
R1372 1142 1143 1.68 0.8 13.44 37
I1143 0 1143 1.31105e-05
R1373 1143 1144 1.648 0.8 13.184 37
I1144 0 1144 1.33579e-05
R1374 1144 1145 1.712 0.8 13.696 37
I1145 0 1145 1.23684e-05
R1375 1145 1146 1.632 0.8 13.056 37
I1146 0 1146 1.27395e-05
R1376 1146 1147 1.728 0.8 13.824 37
I1147 0 1147 1.23684e-05
R1377 1147 1148 1.648 0.8 13.184 37
I1148 0 1148 1.29868e-05
R1378 1148 1149 1.648 0.8 13.184 37
I1149 0 1149 1.28631e-05
R1379 1149 1150 1.616 0.8 12.928 37
I1150 0 1150 1.23684e-05
R1380 1150 0 0.1 49.28 49.28 37
*seg: 116
R1381 0 1151 0.1 49.28 49.28 37
R1382 1155 1165 6.16 0.8 49.28 37
I1151 0 1151 1.34816e-05
R1383 1151 1152 1.744 0.8 13.952 37
I1152 0 1152 1.23684e-05
R1384 1152 1153 1.68 0.8 13.44 37
I1153 0 1153 1.31105e-05
R1385 1153 1154 1.632 0.8 13.056 37
I1154 0 1154 1.34816e-05
R1386 1154 1155 1.664 0.8 13.312 37
I1155 0 1155 1.33579e-05
R1387 1155 1156 1.696 0.8 13.568 37
I1156 0 1156 1.31105e-05
R1388 1156 1157 1.6 0.8 12.8 37
I1157 0 1157 1.27395e-05
R1389 1157 1158 1.648 0.8 13.184 37
I1158 0 1158 1.28631e-05
R1390 1158 1159 1.664 0.8 13.312 37
I1159 0 1159 1.31105e-05
R1391 1159 1160 1.696 0.8 13.568 37
I1160 0 1160 1.23684e-05
R1392 1160 0 0.1 49.28 49.28 37
*seg: 117
R1393 0 1161 0.1 49.28 49.28 37
R1394 1165 1175 6.16 0.8 49.28 37
I1161 0 1161 1.34816e-05
R1395 1161 1162 1.616 0.8 12.928 37
I1162 0 1162 1.26158e-05
R1396 1162 1163 1.664 0.8 13.312 37
I1163 0 1163 1.26158e-05
R1397 1163 1164 1.632 0.8 13.056 37
I1164 0 1164 1.32342e-05
R1398 1164 1165 1.6 0.8 12.8 37
I1165 0 1165 1.29868e-05
R1399 1165 1166 1.696 0.8 13.568 37
I1166 0 1166 1.27395e-05
R1400 1166 1167 1.696 0.8 13.568 37
I1167 0 1167 1.27395e-05
R1401 1167 1168 1.728 0.8 13.824 37
I1168 0 1168 1.33579e-05
R1402 1168 1169 1.648 0.8 13.184 37
I1169 0 1169 1.33579e-05
R1403 1169 1170 1.744 0.8 13.952 37
I1170 0 1170 1.23684e-05
R1404 1170 0 0.1 49.28 49.28 37
*seg: 118
R1405 0 1171 0.1 49.28 49.28 37
R1406 1175 1185 6.16 0.8 49.28 37
I1171 0 1171 1.31105e-05
R1407 1171 1172 1.664 0.8 13.312 37
I1172 0 1172 1.33579e-05
R1408 1172 1173 1.68 0.8 13.44 37
I1173 0 1173 1.29868e-05
R1409 1173 1174 1.6 0.8 12.8 37
I1174 0 1174 1.31105e-05
R1410 1174 1175 1.6 0.8 12.8 37
I1175 0 1175 1.31105e-05
R1411 1175 1176 1.616 0.8 12.928 37
I1176 0 1176 1.23684e-05
R1412 1176 1177 1.712 0.8 13.696 37
I1177 0 1177 1.32342e-05
R1413 1177 1178 1.6 0.8 12.8 37
I1178 0 1178 1.24921e-05
R1414 1178 1179 1.616 0.8 12.928 37
I1179 0 1179 1.31105e-05
R1415 1179 1180 1.616 0.8 12.928 37
I1180 0 1180 1.23684e-05
R1416 1180 0 0.1 49.28 49.28 37
*seg: 119
R1417 0 1181 0.1 49.28 49.28 37
R1418 1185 1195 6.16 0.8 49.28 37
I1181 0 1181 1.27395e-05
R1419 1181 1182 1.744 0.8 13.952 37
I1182 0 1182 1.26158e-05
R1420 1182 1183 1.744 0.8 13.952 37
I1183 0 1183 1.33579e-05
R1421 1183 1184 1.68 0.8 13.44 37
I1184 0 1184 1.32342e-05
R1422 1184 1185 1.664 0.8 13.312 37
I1185 0 1185 1.33579e-05
R1423 1185 1186 1.696 0.8 13.568 37
I1186 0 1186 1.27395e-05
R1424 1186 1187 1.68 0.8 13.44 37
I1187 0 1187 1.23684e-05
R1425 1187 1188 1.6 0.8 12.8 37
I1188 0 1188 1.27395e-05
R1426 1188 1189 1.664 0.8 13.312 37
I1189 0 1189 1.28631e-05
R1427 1189 1190 1.664 0.8 13.312 37
I1190 0 1190 1.23684e-05
R1428 1190 0 0.1 49.28 49.28 37
*seg: 120
R1429 0 1191 0.1 49.28 49.28 37
R1430 1195 1205 6.16 0.8 49.28 37
I1191 0 1191 1.29868e-05
R1431 1191 1192 1.632 0.8 13.056 37
I1192 0 1192 1.28631e-05
R1432 1192 1193 1.744 0.8 13.952 37
I1193 0 1193 1.32342e-05
R1433 1193 1194 1.712 0.8 13.696 37
I1194 0 1194 1.28631e-05
R1434 1194 1195 1.6 0.8 12.8 37
I1195 0 1195 1.24921e-05
R1435 1195 1196 1.712 0.8 13.696 37
I1196 0 1196 1.29868e-05
R1436 1196 1197 1.6 0.8 12.8 37
I1197 0 1197 1.27395e-05
R1437 1197 1198 1.728 0.8 13.824 37
I1198 0 1198 1.32342e-05
R1438 1198 1199 1.632 0.8 13.056 37
I1199 0 1199 1.34816e-05
R1439 1199 1200 1.68 0.8 13.44 37
I1200 0 1200 1.23684e-05
R1440 1200 0 0.1 49.28 49.28 37
*seg: 121
R1441 0 1201 0.1 49.28 49.28 37
R1442 1205 1215 6.16 0.8 49.28 37
I1201 0 1201 1.32342e-05
R1443 1201 1202 1.696 0.8 13.568 37
I1202 0 1202 1.29868e-05
R1444 1202 1203 1.632 0.8 13.056 37
I1203 0 1203 1.26158e-05
R1445 1203 1204 1.744 0.8 13.952 37
I1204 0 1204 1.29868e-05
R1446 1204 1205 1.616 0.8 12.928 37
I1205 0 1205 1.28631e-05
R1447 1205 1206 1.728 0.8 13.824 37
I1206 0 1206 1.34816e-05
R1448 1206 1207 1.632 0.8 13.056 37
I1207 0 1207 1.28631e-05
R1449 1207 1208 1.696 0.8 13.568 37
I1208 0 1208 1.28631e-05
R1450 1208 1209 1.664 0.8 13.312 37
I1209 0 1209 1.34816e-05
R1451 1209 1210 1.696 0.8 13.568 37
I1210 0 1210 1.23684e-05
R1452 1210 0 0.1 49.28 49.28 37
*seg: 122
R1453 0 1211 0.1 49.28 49.28 37
R1454 1215 1225 6.16 0.8 49.28 37
I1211 0 1211 1.29868e-05
R1455 1211 1212 1.728 0.8 13.824 37
I1212 0 1212 1.23684e-05
R1456 1212 1213 1.728 0.8 13.824 37
I1213 0 1213 1.33579e-05
R1457 1213 1214 1.648 0.8 13.184 37
I1214 0 1214 1.29868e-05
R1458 1214 1215 1.648 0.8 13.184 37
I1215 0 1215 1.23684e-05
R1459 1215 1216 1.616 0.8 12.928 37
I1216 0 1216 1.26158e-05
R1460 1216 1217 1.648 0.8 13.184 37
I1217 0 1217 1.29868e-05
R1461 1217 1218 1.696 0.8 13.568 37
I1218 0 1218 1.33579e-05
R1462 1218 1219 1.6 0.8 12.8 37
I1219 0 1219 1.23684e-05
R1463 1219 1220 1.664 0.8 13.312 37
I1220 0 1220 1.23684e-05
R1464 1220 0 0.1 49.28 49.28 37
*seg: 123
R1465 0 1221 0.1 49.28 49.28 37
R1466 1225 1235 6.16 0.8 49.28 37
I1221 0 1221 1.24921e-05
R1467 1221 1222 1.6 0.8 12.8 37
I1222 0 1222 1.23684e-05
R1468 1222 1223 1.68 0.8 13.44 37
I1223 0 1223 1.31105e-05
R1469 1223 1224 1.632 0.8 13.056 37
I1224 0 1224 1.33579e-05
R1470 1224 1225 1.664 0.8 13.312 37
I1225 0 1225 1.28631e-05
R1471 1225 1226 1.712 0.8 13.696 37
I1226 0 1226 1.29868e-05
R1472 1226 1227 1.616 0.8 12.928 37
I1227 0 1227 1.29868e-05
R1473 1227 1228 1.6 0.8 12.8 37
I1228 0 1228 1.34816e-05
R1474 1228 1229 1.728 0.8 13.824 37
I1229 0 1229 1.23684e-05
R1475 1229 1230 1.632 0.8 13.056 37
I1230 0 1230 1.23684e-05
R1476 1230 0 0.1 49.28 49.28 37
*seg: 124
R1477 0 1231 0.1 49.28 49.28 37
R1478 1235 1245 6.16 0.8 49.28 37
I1231 0 1231 1.24921e-05
R1479 1231 1232 1.632 0.8 13.056 37
I1232 0 1232 1.34816e-05
R1480 1232 1233 1.696 0.8 13.568 37
I1233 0 1233 1.24921e-05
R1481 1233 1234 1.632 0.8 13.056 37
I1234 0 1234 1.31105e-05
R1482 1234 1235 1.744 0.8 13.952 37
I1235 0 1235 1.23684e-05
R1483 1235 1236 1.6 0.8 12.8 37
I1236 0 1236 1.31105e-05
R1484 1236 1237 1.744 0.8 13.952 37
I1237 0 1237 1.27395e-05
R1485 1237 1238 1.712 0.8 13.696 37
I1238 0 1238 1.23684e-05
R1486 1238 1239 1.744 0.8 13.952 37
I1239 0 1239 1.33579e-05
R1487 1239 1240 1.712 0.8 13.696 37
I1240 0 1240 1.23684e-05
R1488 1240 0 0.1 49.28 49.28 37
*seg: 125
R1489 0 1241 0.1 49.28 49.28 37
R1490 1245 1255 6.16 0.8 49.28 37
I1241 0 1241 1.23684e-05
R1491 1241 1242 1.632 0.8 13.056 37
I1242 0 1242 1.26158e-05
R1492 1242 1243 1.664 0.8 13.312 37
I1243 0 1243 1.33579e-05
R1493 1243 1244 1.728 0.8 13.824 37
I1244 0 1244 1.34816e-05
R1494 1244 1245 1.696 0.8 13.568 37
I1245 0 1245 1.28631e-05
R1495 1245 1246 1.6 0.8 12.8 37
I1246 0 1246 1.34816e-05
R1496 1246 1247 1.728 0.8 13.824 37
I1247 0 1247 1.32342e-05
R1497 1247 1248 1.744 0.8 13.952 37
I1248 0 1248 1.24921e-05
R1498 1248 1249 1.712 0.8 13.696 37
I1249 0 1249 1.33579e-05
R1499 1249 1250 1.632 0.8 13.056 37
I1250 0 1250 1.23684e-05
R1500 1250 0 0.1 49.28 49.28 37
*seg: 126
R1501 0 1251 0.1 49.28 49.28 37
R1502 1255 1265 6.16 0.8 49.28 37
I1251 0 1251 1.27395e-05
R1503 1251 1252 1.728 0.8 13.824 37
I1252 0 1252 1.28631e-05
R1504 1252 1253 1.632 0.8 13.056 37
I1253 0 1253 1.24921e-05
R1505 1253 1254 1.632 0.8 13.056 37
I1254 0 1254 1.26158e-05
R1506 1254 1255 1.664 0.8 13.312 37
I1255 0 1255 1.26158e-05
R1507 1255 1256 1.744 0.8 13.952 37
I1256 0 1256 1.32342e-05
R1508 1256 1257 1.616 0.8 12.928 37
I1257 0 1257 1.33579e-05
R1509 1257 1258 1.632 0.8 13.056 37
I1258 0 1258 1.34816e-05
R1510 1258 1259 1.6 0.8 12.8 37
I1259 0 1259 1.32342e-05
R1511 1259 1260 1.744 0.8 13.952 37
I1260 0 1260 1.23684e-05
R1512 1260 0 0.1 49.28 49.28 37
*seg: 127
R1513 0 1261 0.1 49.28 49.28 37
R1514 1265 1275 6.16 0.8 49.28 37
I1261 0 1261 1.29868e-05
R1515 1261 1262 1.712 0.8 13.696 37
I1262 0 1262 1.26158e-05
R1516 1262 1263 1.68 0.8 13.44 37
I1263 0 1263 1.29868e-05
R1517 1263 1264 1.648 0.8 13.184 37
I1264 0 1264 1.33579e-05
R1518 1264 1265 1.712 0.8 13.696 37
I1265 0 1265 1.29868e-05
R1519 1265 1266 1.696 0.8 13.568 37
I1266 0 1266 1.23684e-05
R1520 1266 1267 1.696 0.8 13.568 37
I1267 0 1267 1.27395e-05
R1521 1267 1268 1.744 0.8 13.952 37
I1268 0 1268 1.34816e-05
R1522 1268 1269 1.68 0.8 13.44 37
I1269 0 1269 1.31105e-05
R1523 1269 1270 1.664 0.8 13.312 37
I1270 0 1270 1.23684e-05
R1524 1270 0 0.1 49.28 49.28 37
*seg: 128
R1525 0 1271 0.1 49.28 49.28 37
R1526 1275 1285 6.16 0.8 49.28 37
I1271 0 1271 1.29868e-05
R1527 1271 1272 1.632 0.8 13.056 37
I1272 0 1272 1.26158e-05
R1528 1272 1273 1.6 0.8 12.8 37
I1273 0 1273 1.33579e-05
R1529 1273 1274 1.664 0.8 13.312 37
I1274 0 1274 1.26158e-05
R1530 1274 1275 1.728 0.8 13.824 37
I1275 0 1275 1.32342e-05
R1531 1275 1276 1.632 0.8 13.056 37
I1276 0 1276 1.31105e-05
R1532 1276 1277 1.648 0.8 13.184 37
I1277 0 1277 1.24921e-05
R1533 1277 1278 1.648 0.8 13.184 37
I1278 0 1278 1.28631e-05
R1534 1278 1279 1.712 0.8 13.696 37
I1279 0 1279 1.27395e-05
R1535 1279 1280 1.648 0.8 13.184 37
I1280 0 1280 1.23684e-05
R1536 1280 0 0.1 49.28 49.28 37
*seg: 129
R1537 0 1281 0.1 49.28 49.28 37
R1538 1285 1295 6.16 0.8 49.28 37
I1281 0 1281 1.31105e-05
R1539 1281 1282 1.6 0.8 12.8 37
I1282 0 1282 1.34816e-05
R1540 1282 1283 1.648 0.8 13.184 37
I1283 0 1283 1.23684e-05
R1541 1283 1284 1.632 0.8 13.056 37
I1284 0 1284 1.24921e-05
R1542 1284 1285 1.696 0.8 13.568 37
I1285 0 1285 1.34816e-05
R1543 1285 1286 1.728 0.8 13.824 37
I1286 0 1286 1.32342e-05
R1544 1286 1287 1.664 0.8 13.312 37
I1287 0 1287 1.26158e-05
R1545 1287 1288 1.616 0.8 12.928 37
I1288 0 1288 1.26158e-05
R1546 1288 1289 1.616 0.8 12.928 37
I1289 0 1289 1.23684e-05
R1547 1289 1290 1.712 0.8 13.696 37
I1290 0 1290 1.23684e-05
R1548 1290 0 0.1 49.28 49.28 37
*seg: 130
R1549 0 1291 0.1 49.28 49.28 37
R1550 1295 1305 6.16 0.8 49.28 37
I1291 0 1291 1.23684e-05
R1551 1291 1292 1.696 0.8 13.568 37
I1292 0 1292 1.26158e-05
R1552 1292 1293 1.744 0.8 13.952 37
I1293 0 1293 1.24921e-05
R1553 1293 1294 1.648 0.8 13.184 37
I1294 0 1294 1.27395e-05
R1554 1294 1295 1.664 0.8 13.312 37
I1295 0 1295 1.33579e-05
R1555 1295 1296 1.744 0.8 13.952 37
I1296 0 1296 1.34816e-05
R1556 1296 1297 1.6 0.8 12.8 37
I1297 0 1297 1.33579e-05
R1557 1297 1298 1.632 0.8 13.056 37
I1298 0 1298 1.32342e-05
R1558 1298 1299 1.744 0.8 13.952 37
I1299 0 1299 1.26158e-05
R1559 1299 1300 1.696 0.8 13.568 37
I1300 0 1300 1.23684e-05
R1560 1300 0 0.1 49.28 49.28 37
*seg: 131
R1561 0 1301 0.1 49.28 49.28 37
R1562 1305 1315 6.16 0.8 49.28 37
I1301 0 1301 1.29868e-05
R1563 1301 1302 1.632 0.8 13.056 37
I1302 0 1302 1.24921e-05
R1564 1302 1303 1.632 0.8 13.056 37
I1303 0 1303 1.27395e-05
R1565 1303 1304 1.712 0.8 13.696 37
I1304 0 1304 1.32342e-05
R1566 1304 1305 1.664 0.8 13.312 37
I1305 0 1305 1.34816e-05
R1567 1305 1306 1.664 0.8 13.312 37
I1306 0 1306 1.29868e-05
R1568 1306 1307 1.728 0.8 13.824 37
I1307 0 1307 1.23684e-05
R1569 1307 1308 1.68 0.8 13.44 37
I1308 0 1308 1.33579e-05
R1570 1308 1309 1.744 0.8 13.952 37
I1309 0 1309 1.32342e-05
R1571 1309 1310 1.68 0.8 13.44 37
I1310 0 1310 1.23684e-05
R1572 1310 0 0.1 49.28 49.28 37
*seg: 132
R1573 0 1311 0.1 49.28 49.28 37
R1574 1315 1325 6.16 0.8 49.28 37
I1311 0 1311 1.29868e-05
R1575 1311 1312 1.616 0.8 12.928 37
I1312 0 1312 1.33579e-05
R1576 1312 1313 1.616 0.8 12.928 37
I1313 0 1313 1.23684e-05
R1577 1313 1314 1.728 0.8 13.824 37
I1314 0 1314 1.26158e-05
R1578 1314 1315 1.648 0.8 13.184 37
I1315 0 1315 1.31105e-05
R1579 1315 1316 1.728 0.8 13.824 37
I1316 0 1316 1.24921e-05
R1580 1316 1317 1.712 0.8 13.696 37
I1317 0 1317 1.24921e-05
R1581 1317 1318 1.648 0.8 13.184 37
I1318 0 1318 1.29868e-05
R1582 1318 1319 1.664 0.8 13.312 37
I1319 0 1319 1.28631e-05
R1583 1319 1320 1.696 0.8 13.568 37
I1320 0 1320 1.23684e-05
R1584 1320 0 0.1 49.28 49.28 37
*seg: 133
R1585 0 1321 0.1 49.28 49.28 37
R1586 1325 1335 6.16 0.8 49.28 37
I1321 0 1321 1.26158e-05
R1587 1321 1322 1.616 0.8 12.928 37
I1322 0 1322 1.33579e-05
R1588 1322 1323 1.68 0.8 13.44 37
I1323 0 1323 1.32342e-05
R1589 1323 1324 1.616 0.8 12.928 37
I1324 0 1324 1.29868e-05
R1590 1324 1325 1.68 0.8 13.44 37
I1325 0 1325 1.24921e-05
R1591 1325 1326 1.664 0.8 13.312 37
I1326 0 1326 1.27395e-05
R1592 1326 1327 1.728 0.8 13.824 37
I1327 0 1327 1.32342e-05
R1593 1327 1328 1.648 0.8 13.184 37
I1328 0 1328 1.31105e-05
R1594 1328 1329 1.6 0.8 12.8 37
I1329 0 1329 1.27395e-05
R1595 1329 1330 1.68 0.8 13.44 37
I1330 0 1330 1.23684e-05
R1596 1330 0 0.1 49.28 49.28 37
*seg: 134
R1597 0 1331 0.1 49.28 49.28 37
R1598 1335 1345 6.16 0.8 49.28 37
I1331 0 1331 1.34816e-05
R1599 1331 1332 1.728 0.8 13.824 37
I1332 0 1332 1.27395e-05
R1600 1332 1333 1.648 0.8 13.184 37
I1333 0 1333 1.26158e-05
R1601 1333 1334 1.744 0.8 13.952 37
I1334 0 1334 1.28631e-05
R1602 1334 1335 1.6 0.8 12.8 37
I1335 0 1335 1.29868e-05
R1603 1335 1336 1.648 0.8 13.184 37
I1336 0 1336 1.33579e-05
R1604 1336 1337 1.68 0.8 13.44 37
I1337 0 1337 1.34816e-05
R1605 1337 1338 1.696 0.8 13.568 37
I1338 0 1338 1.34816e-05
R1606 1338 1339 1.68 0.8 13.44 37
I1339 0 1339 1.34816e-05
R1607 1339 1340 1.744 0.8 13.952 37
I1340 0 1340 1.23684e-05
R1608 1340 0 0.1 49.28 49.28 37
*seg: 135
R1609 0 1341 0.1 49.28 49.28 37
R1610 1345 1355 6.16 0.8 49.28 37
I1341 0 1341 1.32342e-05
R1611 1341 1342 1.648 0.8 13.184 37
I1342 0 1342 1.33579e-05
R1612 1342 1343 1.632 0.8 13.056 37
I1343 0 1343 1.33579e-05
R1613 1343 1344 1.6 0.8 12.8 37
I1344 0 1344 1.33579e-05
R1614 1344 1345 1.616 0.8 12.928 37
I1345 0 1345 1.27395e-05
R1615 1345 1346 1.696 0.8 13.568 37
I1346 0 1346 1.31105e-05
R1616 1346 1347 1.632 0.8 13.056 37
I1347 0 1347 1.27395e-05
R1617 1347 1348 1.6 0.8 12.8 37
I1348 0 1348 1.27395e-05
R1618 1348 1349 1.616 0.8 12.928 37
I1349 0 1349 1.31105e-05
R1619 1349 1350 1.616 0.8 12.928 37
I1350 0 1350 1.23684e-05
R1620 1350 0 0.1 49.28 49.28 37
*seg: 136
R1621 0 1351 0.1 49.28 49.28 37
R1622 1355 1365 6.16 0.8 49.28 37
I1351 0 1351 1.28631e-05
R1623 1351 1352 1.712 0.8 13.696 37
I1352 0 1352 1.28631e-05
R1624 1352 1353 1.6 0.8 12.8 37
I1353 0 1353 1.32342e-05
R1625 1353 1354 1.728 0.8 13.824 37
I1354 0 1354 1.23684e-05
R1626 1354 1355 1.616 0.8 12.928 37
I1355 0 1355 1.32342e-05
R1627 1355 1356 1.648 0.8 13.184 37
I1356 0 1356 1.29868e-05
R1628 1356 1357 1.696 0.8 13.568 37
I1357 0 1357 1.32342e-05
R1629 1357 1358 1.632 0.8 13.056 37
I1358 0 1358 1.32342e-05
R1630 1358 1359 1.664 0.8 13.312 37
I1359 0 1359 1.31105e-05
R1631 1359 1360 1.712 0.8 13.696 37
I1360 0 1360 1.23684e-05
R1632 1360 0 0.1 49.28 49.28 37
*seg: 137
R1633 0 1361 0.1 49.28 49.28 37
R1634 1365 1375 6.16 0.8 49.28 37
I1361 0 1361 1.29868e-05
R1635 1361 1362 1.696 0.8 13.568 37
I1362 0 1362 1.34816e-05
R1636 1362 1363 1.712 0.8 13.696 37
I1363 0 1363 1.27395e-05
R1637 1363 1364 1.6 0.8 12.8 37
I1364 0 1364 1.28631e-05
R1638 1364 1365 1.648 0.8 13.184 37
I1365 0 1365 1.32342e-05
R1639 1365 1366 1.616 0.8 12.928 37
I1366 0 1366 1.31105e-05
R1640 1366 1367 1.744 0.8 13.952 37
I1367 0 1367 1.34816e-05
R1641 1367 1368 1.632 0.8 13.056 37
I1368 0 1368 1.29868e-05
R1642 1368 1369 1.664 0.8 13.312 37
I1369 0 1369 1.23684e-05
R1643 1369 1370 1.6 0.8 12.8 37
I1370 0 1370 1.23684e-05
R1644 1370 0 0.1 49.28 49.28 37
*seg: 138
R1645 0 1371 0.1 49.28 49.28 37
R1646 1375 1385 6.16 0.8 49.28 37
I1371 0 1371 1.32342e-05
R1647 1371 1372 1.712 0.8 13.696 37
I1372 0 1372 1.29868e-05
R1648 1372 1373 1.632 0.8 13.056 37
I1373 0 1373 1.33579e-05
R1649 1373 1374 1.728 0.8 13.824 37
I1374 0 1374 1.29868e-05
R1650 1374 1375 1.744 0.8 13.952 37
I1375 0 1375 1.28631e-05
R1651 1375 1376 1.632 0.8 13.056 37
I1376 0 1376 1.27395e-05
R1652 1376 1377 1.712 0.8 13.696 37
I1377 0 1377 1.23684e-05
R1653 1377 1378 1.6 0.8 12.8 37
I1378 0 1378 1.28631e-05
R1654 1378 1379 1.728 0.8 13.824 37
I1379 0 1379 1.32342e-05
R1655 1379 1380 1.632 0.8 13.056 37
I1380 0 1380 1.23684e-05
R1656 1380 0 0.1 49.28 49.28 37
*seg: 139
R1657 0 1381 0.1 49.28 49.28 37
R1658 1385 1395 6.16 0.8 49.28 37
I1381 0 1381 1.27395e-05
R1659 1381 1382 1.728 0.8 13.824 37
I1382 0 1382 1.24921e-05
R1660 1382 1383 1.648 0.8 13.184 37
I1383 0 1383 1.32342e-05
R1661 1383 1384 1.632 0.8 13.056 37
I1384 0 1384 1.31105e-05
R1662 1384 1385 1.664 0.8 13.312 37
I1385 0 1385 1.31105e-05
R1663 1385 1386 1.68 0.8 13.44 37
I1386 0 1386 1.31105e-05
R1664 1386 1387 1.6 0.8 12.8 37
I1387 0 1387 1.28631e-05
R1665 1387 1388 1.712 0.8 13.696 37
I1388 0 1388 1.28631e-05
R1666 1388 1389 1.632 0.8 13.056 37
I1389 0 1389 1.27395e-05
R1667 1389 1390 1.68 0.8 13.44 37
I1390 0 1390 1.23684e-05
R1668 1390 0 0.1 49.28 49.28 37
*seg: 140
R1669 0 1391 0.1 49.28 49.28 37
R1670 1395 1405 6.16 0.8 49.28 37
I1391 0 1391 1.34816e-05
R1671 1391 1392 1.648 0.8 13.184 37
I1392 0 1392 1.34816e-05
R1672 1392 1393 1.744 0.8 13.952 37
I1393 0 1393 1.26158e-05
R1673 1393 1394 1.68 0.8 13.44 37
I1394 0 1394 1.28631e-05
R1674 1394 1395 1.632 0.8 13.056 37
I1395 0 1395 1.27395e-05
R1675 1395 1396 1.728 0.8 13.824 37
I1396 0 1396 1.27395e-05
R1676 1396 1397 1.712 0.8 13.696 37
I1397 0 1397 1.27395e-05
R1677 1397 1398 1.648 0.8 13.184 37
I1398 0 1398 1.23684e-05
R1678 1398 1399 1.6 0.8 12.8 37
I1399 0 1399 1.29868e-05
R1679 1399 1400 1.616 0.8 12.928 37
I1400 0 1400 1.23684e-05
R1680 1400 0 0.1 49.28 49.28 37
*seg: 141
R1681 0 1401 0.1 49.28 49.28 37
R1682 1405 1415 6.16 0.8 49.28 37
I1401 0 1401 1.24921e-05
R1683 1401 1402 1.696 0.8 13.568 37
I1402 0 1402 1.31105e-05
R1684 1402 1403 1.712 0.8 13.696 37
I1403 0 1403 1.34816e-05
R1685 1403 1404 1.616 0.8 12.928 37
I1404 0 1404 1.28631e-05
R1686 1404 1405 1.6 0.8 12.8 37
I1405 0 1405 1.27395e-05
R1687 1405 1406 1.68 0.8 13.44 37
I1406 0 1406 1.24921e-05
R1688 1406 1407 1.616 0.8 12.928 37
I1407 0 1407 1.24921e-05
R1689 1407 1408 1.68 0.8 13.44 37
I1408 0 1408 1.24921e-05
R1690 1408 1409 1.648 0.8 13.184 37
I1409 0 1409 1.29868e-05
R1691 1409 1410 1.744 0.8 13.952 37
I1410 0 1410 1.23684e-05
R1692 1410 0 0.1 49.28 49.28 37
*seg: 142
R1693 0 1411 0.1 49.28 49.28 37
R1694 1415 1425 6.16 0.8 49.28 37
I1411 0 1411 1.27395e-05
R1695 1411 1412 1.648 0.8 13.184 37
I1412 0 1412 1.23684e-05
R1696 1412 1413 1.68 0.8 13.44 37
I1413 0 1413 1.23684e-05
R1697 1413 1414 1.712 0.8 13.696 37
I1414 0 1414 1.29868e-05
R1698 1414 1415 1.68 0.8 13.44 37
I1415 0 1415 1.29868e-05
R1699 1415 1416 1.728 0.8 13.824 37
I1416 0 1416 1.23684e-05
R1700 1416 1417 1.696 0.8 13.568 37
I1417 0 1417 1.29868e-05
R1701 1417 1418 1.616 0.8 12.928 37
I1418 0 1418 1.34816e-05
R1702 1418 1419 1.728 0.8 13.824 37
I1419 0 1419 1.27395e-05
R1703 1419 1420 1.696 0.8 13.568 37
I1420 0 1420 1.23684e-05
R1704 1420 0 0.1 49.28 49.28 37
*seg: 143
R1705 0 1421 0.1 49.28 49.28 37
R1706 1425 1435 6.16 0.8 49.28 37
I1421 0 1421 1.26158e-05
R1707 1421 1422 1.664 0.8 13.312 37
I1422 0 1422 1.27395e-05
R1708 1422 1423 1.728 0.8 13.824 37
I1423 0 1423 1.29868e-05
R1709 1423 1424 1.6 0.8 12.8 37
I1424 0 1424 1.28631e-05
R1710 1424 1425 1.696 0.8 13.568 37
I1425 0 1425 1.23684e-05
R1711 1425 1426 1.664 0.8 13.312 37
I1426 0 1426 1.26158e-05
R1712 1426 1427 1.632 0.8 13.056 37
I1427 0 1427 1.29868e-05
R1713 1427 1428 1.648 0.8 13.184 37
I1428 0 1428 1.27395e-05
R1714 1428 1429 1.648 0.8 13.184 37
I1429 0 1429 1.33579e-05
R1715 1429 1430 1.664 0.8 13.312 37
I1430 0 1430 1.23684e-05
R1716 1430 0 0.1 49.28 49.28 37
*seg: 144
R1717 0 1431 0.1 49.28 49.28 37
R1718 1435 1445 6.16 0.8 49.28 37
I1431 0 1431 1.32342e-05
R1719 1431 1432 1.68 0.8 13.44 37
I1432 0 1432 1.28631e-05
R1720 1432 1433 1.728 0.8 13.824 37
I1433 0 1433 1.34816e-05
R1721 1433 1434 1.744 0.8 13.952 37
I1434 0 1434 1.28631e-05
R1722 1434 1435 1.648 0.8 13.184 37
I1435 0 1435 1.24921e-05
R1723 1435 1436 1.664 0.8 13.312 37
I1436 0 1436 1.32342e-05
R1724 1436 1437 1.648 0.8 13.184 37
I1437 0 1437 1.33579e-05
R1725 1437 1438 1.632 0.8 13.056 37
I1438 0 1438 1.24921e-05
R1726 1438 1439 1.68 0.8 13.44 37
I1439 0 1439 1.27395e-05
R1727 1439 1440 1.6 0.8 12.8 37
I1440 0 1440 1.23684e-05
R1728 1440 0 0.1 49.28 49.28 37
*seg: 145
R1729 0 1441 0.1 49.28 49.28 37
R1730 1445 1455 6.16 0.8 49.28 37
I1441 0 1441 1.33579e-05
R1731 1441 1442 1.648 0.8 13.184 37
I1442 0 1442 1.31105e-05
R1732 1442 1443 1.68 0.8 13.44 37
I1443 0 1443 1.31105e-05
R1733 1443 1444 1.68 0.8 13.44 37
I1444 0 1444 1.26158e-05
R1734 1444 1445 1.664 0.8 13.312 37
I1445 0 1445 1.26158e-05
R1735 1445 1446 1.6 0.8 12.8 37
I1446 0 1446 1.33579e-05
R1736 1446 1447 1.712 0.8 13.696 37
I1447 0 1447 1.23684e-05
R1737 1447 1448 1.744 0.8 13.952 37
I1448 0 1448 1.32342e-05
R1738 1448 1449 1.728 0.8 13.824 37
I1449 0 1449 1.23684e-05
R1739 1449 1450 1.744 0.8 13.952 37
I1450 0 1450 1.23684e-05
R1740 1450 0 0.1 49.28 49.28 37
*seg: 146
R1741 0 1451 0.1 49.28 49.28 37
R1742 1455 1465 6.16 0.8 49.28 37
I1451 0 1451 1.23684e-05
R1743 1451 1452 1.68 0.8 13.44 37
I1452 0 1452 1.31105e-05
R1744 1452 1453 1.728 0.8 13.824 37
I1453 0 1453 1.33579e-05
R1745 1453 1454 1.648 0.8 13.184 37
I1454 0 1454 1.26158e-05
R1746 1454 1455 1.664 0.8 13.312 37
I1455 0 1455 1.24921e-05
R1747 1455 1456 1.712 0.8 13.696 37
I1456 0 1456 1.34816e-05
R1748 1456 1457 1.712 0.8 13.696 37
I1457 0 1457 1.34816e-05
R1749 1457 1458 1.728 0.8 13.824 37
I1458 0 1458 1.32342e-05
R1750 1458 1459 1.664 0.8 13.312 37
I1459 0 1459 1.26158e-05
R1751 1459 1460 1.696 0.8 13.568 37
I1460 0 1460 1.23684e-05
R1752 1460 0 0.1 49.28 49.28 37
*seg: 147
R1753 0 1461 0.1 49.28 49.28 37
R1754 1465 1475 6.16 0.8 49.28 37
I1461 0 1461 1.34816e-05
R1755 1461 1462 1.632 0.8 13.056 37
I1462 0 1462 1.31105e-05
R1756 1462 1463 1.712 0.8 13.696 37
I1463 0 1463 1.27395e-05
R1757 1463 1464 1.712 0.8 13.696 37
I1464 0 1464 1.28631e-05
R1758 1464 1465 1.68 0.8 13.44 37
I1465 0 1465 1.31105e-05
R1759 1465 1466 1.712 0.8 13.696 37
I1466 0 1466 1.32342e-05
R1760 1466 1467 1.728 0.8 13.824 37
I1467 0 1467 1.33579e-05
R1761 1467 1468 1.68 0.8 13.44 37
I1468 0 1468 1.34816e-05
R1762 1468 1469 1.728 0.8 13.824 37
I1469 0 1469 1.23684e-05
R1763 1469 1470 1.696 0.8 13.568 37
I1470 0 1470 1.23684e-05
R1764 1470 0 0.1 49.28 49.28 37
*seg: 148
R1765 0 1471 0.1 49.28 49.28 37
R1766 1475 1485 6.16 0.8 49.28 37
I1471 0 1471 1.32342e-05
R1767 1471 1472 1.664 0.8 13.312 37
I1472 0 1472 1.32342e-05
R1768 1472 1473 1.712 0.8 13.696 37
I1473 0 1473 1.23684e-05
R1769 1473 1474 1.632 0.8 13.056 37
I1474 0 1474 1.32342e-05
R1770 1474 1475 1.648 0.8 13.184 37
I1475 0 1475 1.31105e-05
R1771 1475 1476 1.664 0.8 13.312 37
I1476 0 1476 1.31105e-05
R1772 1476 1477 1.632 0.8 13.056 37
I1477 0 1477 1.31105e-05
R1773 1477 1478 1.728 0.8 13.824 37
I1478 0 1478 1.24921e-05
R1774 1478 1479 1.712 0.8 13.696 37
I1479 0 1479 1.29868e-05
R1775 1479 1480 1.712 0.8 13.696 37
I1480 0 1480 1.23684e-05
R1776 1480 0 0.1 49.28 49.28 37
*seg: 149
R1777 0 1481 0.1 49.28 49.28 37
R1778 1485 1495 6.16 0.8 49.28 37
I1481 0 1481 1.31105e-05
R1779 1481 1482 1.712 0.8 13.696 37
I1482 0 1482 1.34816e-05
R1780 1482 1483 1.648 0.8 13.184 37
I1483 0 1483 1.32342e-05
R1781 1483 1484 1.664 0.8 13.312 37
I1484 0 1484 1.34816e-05
R1782 1484 1485 1.616 0.8 12.928 37
I1485 0 1485 1.28631e-05
R1783 1485 1486 1.6 0.8 12.8 37
I1486 0 1486 1.32342e-05
R1784 1486 1487 1.616 0.8 12.928 37
I1487 0 1487 1.24921e-05
R1785 1487 1488 1.728 0.8 13.824 37
I1488 0 1488 1.31105e-05
R1786 1488 1489 1.744 0.8 13.952 37
I1489 0 1489 1.33579e-05
R1787 1489 1490 1.68 0.8 13.44 37
I1490 0 1490 1.23684e-05
R1788 1490 0 0.1 49.28 49.28 37
*seg: 150
R1789 0 1491 0.1 49.28 49.28 37
R1790 1495 1505 6.16 0.8 49.28 37
I1491 0 1491 1.23684e-05
R1791 1491 1492 1.616 0.8 12.928 37
I1492 0 1492 1.32342e-05
R1792 1492 1493 1.632 0.8 13.056 37
I1493 0 1493 1.33579e-05
R1793 1493 1494 1.632 0.8 13.056 37
I1494 0 1494 1.26158e-05
R1794 1494 1495 1.616 0.8 12.928 37
I1495 0 1495 1.24921e-05
R1795 1495 1496 1.712 0.8 13.696 37
I1496 0 1496 1.27395e-05
R1796 1496 1497 1.648 0.8 13.184 37
I1497 0 1497 1.28631e-05
R1797 1497 1498 1.664 0.8 13.312 37
I1498 0 1498 1.27395e-05
R1798 1498 1499 1.712 0.8 13.696 37
I1499 0 1499 1.34816e-05
R1799 1499 1500 1.616 0.8 12.928 37
I1500 0 1500 1.23684e-05
R1800 1500 0 0.1 49.28 49.28 37
*seg: 151
R1801 0 1501 0.1 49.28 49.28 37
R1802 1505 1515 6.16 0.8 49.28 37
I1501 0 1501 1.29868e-05
R1803 1501 1502 1.616 0.8 12.928 37
I1502 0 1502 1.31105e-05
R1804 1502 1503 1.648 0.8 13.184 37
I1503 0 1503 1.32342e-05
R1805 1503 1504 1.6 0.8 12.8 37
I1504 0 1504 1.28631e-05
R1806 1504 1505 1.728 0.8 13.824 37
I1505 0 1505 1.24921e-05
R1807 1505 1506 1.728 0.8 13.824 37
I1506 0 1506 1.23684e-05
R1808 1506 1507 1.68 0.8 13.44 37
I1507 0 1507 1.27395e-05
R1809 1507 1508 1.68 0.8 13.44 37
I1508 0 1508 1.31105e-05
R1810 1508 1509 1.712 0.8 13.696 37
I1509 0 1509 1.24921e-05
R1811 1509 1510 1.744 0.8 13.952 37
I1510 0 1510 1.23684e-05
R1812 1510 0 0.1 49.28 49.28 37
*seg: 152
R1813 0 1511 0.1 49.28 49.28 37
R1814 1515 1525 6.16 0.8 49.28 37
I1511 0 1511 1.31105e-05
R1815 1511 1512 1.664 0.8 13.312 37
I1512 0 1512 1.34816e-05
R1816 1512 1513 1.68 0.8 13.44 37
I1513 0 1513 1.23684e-05
R1817 1513 1514 1.6 0.8 12.8 37
I1514 0 1514 1.23684e-05
R1818 1514 1515 1.648 0.8 13.184 37
I1515 0 1515 1.27395e-05
R1819 1515 1516 1.664 0.8 13.312 37
I1516 0 1516 1.31105e-05
R1820 1516 1517 1.6 0.8 12.8 37
I1517 0 1517 1.34816e-05
R1821 1517 1518 1.712 0.8 13.696 37
I1518 0 1518 1.26158e-05
R1822 1518 1519 1.696 0.8 13.568 37
I1519 0 1519 1.28631e-05
R1823 1519 1520 1.6 0.8 12.8 37
I1520 0 1520 1.23684e-05
R1824 1520 0 0.1 49.28 49.28 37
*seg: 153
R1825 0 1521 0.1 49.28 49.28 37
R1826 1525 1535 6.16 0.8 49.28 37
I1521 0 1521 1.33579e-05
R1827 1521 1522 1.6 0.8 12.8 37
I1522 0 1522 1.26158e-05
R1828 1522 1523 1.696 0.8 13.568 37
I1523 0 1523 1.24921e-05
R1829 1523 1524 1.696 0.8 13.568 37
I1524 0 1524 1.32342e-05
R1830 1524 1525 1.648 0.8 13.184 37
I1525 0 1525 1.34816e-05
R1831 1525 1526 1.632 0.8 13.056 37
I1526 0 1526 1.26158e-05
R1832 1526 1527 1.696 0.8 13.568 37
I1527 0 1527 1.31105e-05
R1833 1527 1528 1.712 0.8 13.696 37
I1528 0 1528 1.32342e-05
R1834 1528 1529 1.68 0.8 13.44 37
I1529 0 1529 1.32342e-05
R1835 1529 1530 1.744 0.8 13.952 37
I1530 0 1530 1.23684e-05
R1836 1530 0 0.1 49.28 49.28 37
*seg: 154
R1837 0 1531 0.1 49.28 49.28 37
R1838 1535 1545 6.16 0.8 49.28 37
I1531 0 1531 1.34816e-05
R1839 1531 1532 1.632 0.8 13.056 37
I1532 0 1532 1.34816e-05
R1840 1532 1533 1.632 0.8 13.056 37
I1533 0 1533 1.29868e-05
R1841 1533 1534 1.744 0.8 13.952 37
I1534 0 1534 1.23684e-05
R1842 1534 1535 1.616 0.8 12.928 37
I1535 0 1535 1.26158e-05
R1843 1535 1536 1.648 0.8 13.184 37
I1536 0 1536 1.34816e-05
R1844 1536 1537 1.696 0.8 13.568 37
I1537 0 1537 1.28631e-05
R1845 1537 1538 1.6 0.8 12.8 37
I1538 0 1538 1.33579e-05
R1846 1538 1539 1.664 0.8 13.312 37
I1539 0 1539 1.24921e-05
R1847 1539 1540 1.616 0.8 12.928 37
I1540 0 1540 1.23684e-05
R1848 1540 0 0.1 49.28 49.28 37
*seg: 155
R1849 0 1541 0.1 49.28 49.28 37
R1850 1545 1555 6.16 0.8 49.28 37
I1541 0 1541 1.27395e-05
R1851 1541 1542 1.744 0.8 13.952 37
I1542 0 1542 1.28631e-05
R1852 1542 1543 1.68 0.8 13.44 37
I1543 0 1543 1.26158e-05
R1853 1543 1544 1.728 0.8 13.824 37
I1544 0 1544 1.29868e-05
R1854 1544 1545 1.648 0.8 13.184 37
I1545 0 1545 1.33579e-05
R1855 1545 1546 1.696 0.8 13.568 37
I1546 0 1546 1.24921e-05
R1856 1546 1547 1.632 0.8 13.056 37
I1547 0 1547 1.24921e-05
R1857 1547 1548 1.664 0.8 13.312 37
I1548 0 1548 1.29868e-05
R1858 1548 1549 1.648 0.8 13.184 37
I1549 0 1549 1.29868e-05
R1859 1549 1550 1.648 0.8 13.184 37
I1550 0 1550 1.23684e-05
R1860 1550 0 0.1 49.28 49.28 37
*seg: 156
R1861 0 1551 0.1 49.28 49.28 37
R1862 1555 1565 6.16 0.8 49.28 37
I1551 0 1551 1.24921e-05
R1863 1551 1552 1.728 0.8 13.824 37
I1552 0 1552 1.34816e-05
R1864 1552 1553 1.664 0.8 13.312 37
I1553 0 1553 1.29868e-05
R1865 1553 1554 1.728 0.8 13.824 37
I1554 0 1554 1.23684e-05
R1866 1554 1555 1.744 0.8 13.952 37
I1555 0 1555 1.24921e-05
R1867 1555 1556 1.6 0.8 12.8 37
I1556 0 1556 1.27395e-05
R1868 1556 1557 1.712 0.8 13.696 37
I1557 0 1557 1.23684e-05
R1869 1557 1558 1.68 0.8 13.44 37
I1558 0 1558 1.29868e-05
R1870 1558 1559 1.648 0.8 13.184 37
I1559 0 1559 1.33579e-05
R1871 1559 1560 1.664 0.8 13.312 37
I1560 0 1560 1.23684e-05
R1872 1560 0 0.1 49.28 49.28 37
*seg: 157
R1873 0 1561 0.1 49.28 49.28 37
R1874 1565 1575 6.16 0.8 49.28 37
I1561 0 1561 1.31105e-05
R1875 1561 1562 1.744 0.8 13.952 37
I1562 0 1562 1.28631e-05
R1876 1562 1563 1.664 0.8 13.312 37
I1563 0 1563 1.34816e-05
R1877 1563 1564 1.616 0.8 12.928 37
I1564 0 1564 1.27395e-05
R1878 1564 1565 1.648 0.8 13.184 37
I1565 0 1565 1.34816e-05
R1879 1565 1566 1.696 0.8 13.568 37
I1566 0 1566 1.31105e-05
R1880 1566 1567 1.68 0.8 13.44 37
I1567 0 1567 1.27395e-05
R1881 1567 1568 1.696 0.8 13.568 37
I1568 0 1568 1.29868e-05
R1882 1568 1569 1.712 0.8 13.696 37
I1569 0 1569 1.32342e-05
R1883 1569 1570 1.6 0.8 12.8 37
I1570 0 1570 1.23684e-05
R1884 1570 0 0.1 49.28 49.28 37
*seg: 158
R1885 0 1571 0.1 49.28 49.28 37
R1886 1575 1585 6.16 0.8 49.28 37
I1571 0 1571 1.28631e-05
R1887 1571 1572 1.728 0.8 13.824 37
I1572 0 1572 1.24921e-05
R1888 1572 1573 1.712 0.8 13.696 37
I1573 0 1573 1.29868e-05
R1889 1573 1574 1.632 0.8 13.056 37
I1574 0 1574 1.29868e-05
R1890 1574 1575 1.632 0.8 13.056 37
I1575 0 1575 1.32342e-05
R1891 1575 1576 1.6 0.8 12.8 37
I1576 0 1576 1.26158e-05
R1892 1576 1577 1.712 0.8 13.696 37
I1577 0 1577 1.29868e-05
R1893 1577 1578 1.696 0.8 13.568 37
I1578 0 1578 1.23684e-05
R1894 1578 1579 1.68 0.8 13.44 37
I1579 0 1579 1.31105e-05
R1895 1579 1580 1.728 0.8 13.824 37
I1580 0 1580 1.23684e-05
R1896 1580 0 0.1 49.28 49.28 37
*seg: 159
R1897 0 1581 0.1 49.28 49.28 37
R1898 1585 1595 6.16 0.8 49.28 37
I1581 0 1581 1.23684e-05
R1899 1581 1582 1.664 0.8 13.312 37
I1582 0 1582 1.26158e-05
R1900 1582 1583 1.744 0.8 13.952 37
I1583 0 1583 1.27395e-05
R1901 1583 1584 1.744 0.8 13.952 37
I1584 0 1584 1.32342e-05
R1902 1584 1585 1.696 0.8 13.568 37
I1585 0 1585 1.23684e-05
R1903 1585 1586 1.648 0.8 13.184 37
I1586 0 1586 1.28631e-05
R1904 1586 1587 1.68 0.8 13.44 37
I1587 0 1587 1.27395e-05
R1905 1587 1588 1.664 0.8 13.312 37
I1588 0 1588 1.26158e-05
R1906 1588 1589 1.6 0.8 12.8 37
I1589 0 1589 1.27395e-05
R1907 1589 1590 1.648 0.8 13.184 37
I1590 0 1590 1.23684e-05
R1908 1590 0 0.1 49.28 49.28 37
*seg: 160
R1909 0 1591 0.1 49.28 49.28 37
R1910 1595 1605 6.16 0.8 49.28 37
I1591 0 1591 1.33579e-05
R1911 1591 1592 1.696 0.8 13.568 37
I1592 0 1592 1.28631e-05
R1912 1592 1593 1.664 0.8 13.312 37
I1593 0 1593 1.31105e-05
R1913 1593 1594 1.632 0.8 13.056 37
I1594 0 1594 1.33579e-05
R1914 1594 1595 1.6 0.8 12.8 37
I1595 0 1595 1.33579e-05
R1915 1595 1596 1.712 0.8 13.696 37
I1596 0 1596 1.23684e-05
R1916 1596 1597 1.696 0.8 13.568 37
I1597 0 1597 1.32342e-05
R1917 1597 1598 1.68 0.8 13.44 37
I1598 0 1598 1.29868e-05
R1918 1598 1599 1.6 0.8 12.8 37
I1599 0 1599 1.28631e-05
R1919 1599 1600 1.728 0.8 13.824 37
I1600 0 1600 1.23684e-05
R1920 1600 0 0.1 49.28 49.28 37
*seg: 161
R1921 0 1601 0.1 49.28 49.28 37
R1922 1605 1615 6.16 0.8 49.28 37
I1601 0 1601 1.31105e-05
R1923 1601 1602 1.696 0.8 13.568 37
I1602 0 1602 1.34816e-05
R1924 1602 1603 1.728 0.8 13.824 37
I1603 0 1603 1.27395e-05
R1925 1603 1604 1.744 0.8 13.952 37
I1604 0 1604 1.26158e-05
R1926 1604 1605 1.712 0.8 13.696 37
I1605 0 1605 1.26158e-05
R1927 1605 1606 1.648 0.8 13.184 37
I1606 0 1606 1.27395e-05
R1928 1606 1607 1.68 0.8 13.44 37
I1607 0 1607 1.24921e-05
R1929 1607 1608 1.648 0.8 13.184 37
I1608 0 1608 1.27395e-05
R1930 1608 1609 1.664 0.8 13.312 37
I1609 0 1609 1.26158e-05
R1931 1609 1610 1.696 0.8 13.568 37
I1610 0 1610 1.23684e-05
R1932 1610 0 0.1 49.28 49.28 37
*seg: 162
R1933 0 1611 0.1 49.28 49.28 37
R1934 1615 1625 6.16 0.8 49.28 37
I1611 0 1611 1.27395e-05
R1935 1611 1612 1.728 0.8 13.824 37
I1612 0 1612 1.24921e-05
R1936 1612 1613 1.728 0.8 13.824 37
I1613 0 1613 1.31105e-05
R1937 1613 1614 1.68 0.8 13.44 37
I1614 0 1614 1.32342e-05
R1938 1614 1615 1.744 0.8 13.952 37
I1615 0 1615 1.29868e-05
R1939 1615 1616 1.664 0.8 13.312 37
I1616 0 1616 1.28631e-05
R1940 1616 1617 1.712 0.8 13.696 37
I1617 0 1617 1.31105e-05
R1941 1617 1618 1.6 0.8 12.8 37
I1618 0 1618 1.23684e-05
R1942 1618 1619 1.616 0.8 12.928 37
I1619 0 1619 1.28631e-05
R1943 1619 1620 1.696 0.8 13.568 37
I1620 0 1620 1.23684e-05
R1944 1620 0 0.1 49.28 49.28 37
*seg: 163
R1945 0 1621 0.1 49.28 49.28 37
R1946 1625 1635 6.16 0.8 49.28 37
I1621 0 1621 1.34816e-05
R1947 1621 1622 1.632 0.8 13.056 37
I1622 0 1622 1.28631e-05
R1948 1622 1623 1.712 0.8 13.696 37
I1623 0 1623 1.33579e-05
R1949 1623 1624 1.632 0.8 13.056 37
I1624 0 1624 1.24921e-05
R1950 1624 1625 1.648 0.8 13.184 37
I1625 0 1625 1.27395e-05
R1951 1625 1626 1.6 0.8 12.8 37
I1626 0 1626 1.26158e-05
R1952 1626 1627 1.728 0.8 13.824 37
I1627 0 1627 1.29868e-05
R1953 1627 1628 1.616 0.8 12.928 37
I1628 0 1628 1.32342e-05
R1954 1628 1629 1.6 0.8 12.8 37
I1629 0 1629 1.33579e-05
R1955 1629 1630 1.616 0.8 12.928 37
I1630 0 1630 1.23684e-05
R1956 1630 0 0.1 49.28 49.28 37
*seg: 164
R1957 0 1631 0.1 49.28 49.28 37
R1958 1635 1645 6.16 0.8 49.28 37
I1631 0 1631 1.27395e-05
R1959 1631 1632 1.664 0.8 13.312 37
I1632 0 1632 1.29868e-05
R1960 1632 1633 1.6 0.8 12.8 37
I1633 0 1633 1.27395e-05
R1961 1633 1634 1.632 0.8 13.056 37
I1634 0 1634 1.26158e-05
R1962 1634 1635 1.664 0.8 13.312 37
I1635 0 1635 1.28631e-05
R1963 1635 1636 1.648 0.8 13.184 37
I1636 0 1636 1.34816e-05
R1964 1636 1637 1.616 0.8 12.928 37
I1637 0 1637 1.34816e-05
R1965 1637 1638 1.632 0.8 13.056 37
I1638 0 1638 1.33579e-05
R1966 1638 1639 1.712 0.8 13.696 37
I1639 0 1639 1.33579e-05
R1967 1639 1640 1.616 0.8 12.928 37
I1640 0 1640 1.23684e-05
R1968 1640 0 0.1 49.28 49.28 37
*seg: 165
R1969 0 1641 0.1 49.28 49.28 37
R1970 1645 1655 6.16 0.8 49.28 37
I1641 0 1641 1.24921e-05
R1971 1641 1642 1.664 0.8 13.312 37
I1642 0 1642 1.33579e-05
R1972 1642 1643 1.664 0.8 13.312 37
I1643 0 1643 1.24921e-05
R1973 1643 1644 1.728 0.8 13.824 37
I1644 0 1644 1.29868e-05
R1974 1644 1645 1.6 0.8 12.8 37
I1645 0 1645 1.27395e-05
R1975 1645 1646 1.728 0.8 13.824 37
I1646 0 1646 1.28631e-05
R1976 1646 1647 1.616 0.8 12.928 37
I1647 0 1647 1.29868e-05
R1977 1647 1648 1.696 0.8 13.568 37
I1648 0 1648 1.28631e-05
R1978 1648 1649 1.696 0.8 13.568 37
I1649 0 1649 1.23684e-05
R1979 1649 1650 1.664 0.8 13.312 37
I1650 0 1650 1.23684e-05
R1980 1650 0 0.1 49.28 49.28 37
*seg: 166
R1981 0 1651 0.1 49.28 49.28 37
R1982 1655 1665 6.16 0.8 49.28 37
I1651 0 1651 1.33579e-05
R1983 1651 1652 1.664 0.8 13.312 37
I1652 0 1652 1.24921e-05
R1984 1652 1653 1.6 0.8 12.8 37
I1653 0 1653 1.29868e-05
R1985 1653 1654 1.632 0.8 13.056 37
I1654 0 1654 1.33579e-05
R1986 1654 1655 1.68 0.8 13.44 37
I1655 0 1655 1.23684e-05
R1987 1655 1656 1.6 0.8 12.8 37
I1656 0 1656 1.31105e-05
R1988 1656 1657 1.68 0.8 13.44 37
I1657 0 1657 1.29868e-05
R1989 1657 1658 1.696 0.8 13.568 37
I1658 0 1658 1.33579e-05
R1990 1658 1659 1.632 0.8 13.056 37
I1659 0 1659 1.34816e-05
R1991 1659 1660 1.632 0.8 13.056 37
I1660 0 1660 1.23684e-05
R1992 1660 0 0.1 49.28 49.28 37
*seg: 167
R1993 0 1661 0.1 49.28 49.28 37
R1994 1665 1675 6.16 0.8 49.28 37
I1661 0 1661 1.27395e-05
R1995 1661 1662 1.6 0.8 12.8 37
I1662 0 1662 1.28631e-05
R1996 1662 1663 1.664 0.8 13.312 37
I1663 0 1663 1.27395e-05
R1997 1663 1664 1.712 0.8 13.696 37
I1664 0 1664 1.33579e-05
R1998 1664 1665 1.712 0.8 13.696 37
I1665 0 1665 1.23684e-05
R1999 1665 1666 1.648 0.8 13.184 37
I1666 0 1666 1.26158e-05
R2000 1666 1667 1.744 0.8 13.952 37
I1667 0 1667 1.27395e-05
R2001 1667 1668 1.68 0.8 13.44 37
I1668 0 1668 1.32342e-05
R2002 1668 1669 1.648 0.8 13.184 37
I1669 0 1669 1.31105e-05
R2003 1669 1670 1.744 0.8 13.952 37
I1670 0 1670 1.23684e-05
R2004 1670 0 0.1 49.28 49.28 37
*seg: 168
R2005 0 1671 0.1 49.28 49.28 37
R2006 1675 1685 6.16 0.8 49.28 37
I1671 0 1671 1.28631e-05
R2007 1671 1672 1.68 0.8 13.44 37
I1672 0 1672 1.24921e-05
R2008 1672 1673 1.696 0.8 13.568 37
I1673 0 1673 1.28631e-05
R2009 1673 1674 1.632 0.8 13.056 37
I1674 0 1674 1.28631e-05
R2010 1674 1675 1.648 0.8 13.184 37
I1675 0 1675 1.26158e-05
R2011 1675 1676 1.6 0.8 12.8 37
I1676 0 1676 1.32342e-05
R2012 1676 1677 1.648 0.8 13.184 37
I1677 0 1677 1.31105e-05
R2013 1677 1678 1.744 0.8 13.952 37
I1678 0 1678 1.32342e-05
R2014 1678 1679 1.632 0.8 13.056 37
I1679 0 1679 1.33579e-05
R2015 1679 1680 1.712 0.8 13.696 37
I1680 0 1680 1.23684e-05
R2016 1680 0 0.1 49.28 49.28 37
*seg: 169
R2017 0 1681 0.1 49.28 49.28 37
R2018 1685 1695 6.16 0.8 49.28 37
I1681 0 1681 1.33579e-05
R2019 1681 1682 1.648 0.8 13.184 37
I1682 0 1682 1.24921e-05
R2020 1682 1683 1.712 0.8 13.696 37
I1683 0 1683 1.31105e-05
R2021 1683 1684 1.712 0.8 13.696 37
I1684 0 1684 1.29868e-05
R2022 1684 1685 1.664 0.8 13.312 37
I1685 0 1685 1.26158e-05
R2023 1685 1686 1.648 0.8 13.184 37
I1686 0 1686 1.28631e-05
R2024 1686 1687 1.616 0.8 12.928 37
I1687 0 1687 1.34816e-05
R2025 1687 1688 1.728 0.8 13.824 37
I1688 0 1688 1.32342e-05
R2026 1688 1689 1.616 0.8 12.928 37
I1689 0 1689 1.34816e-05
R2027 1689 1690 1.744 0.8 13.952 37
I1690 0 1690 1.23684e-05
R2028 1690 0 0.1 49.28 49.28 37
*seg: 170
R2029 0 1691 0.1 49.28 49.28 37
R2030 1695 1705 6.16 0.8 49.28 37
I1691 0 1691 1.28631e-05
R2031 1691 1692 1.632 0.8 13.056 37
I1692 0 1692 1.26158e-05
R2032 1692 1693 1.664 0.8 13.312 37
I1693 0 1693 1.27395e-05
R2033 1693 1694 1.6 0.8 12.8 37
I1694 0 1694 1.31105e-05
R2034 1694 1695 1.6 0.8 12.8 37
I1695 0 1695 1.27395e-05
R2035 1695 1696 1.696 0.8 13.568 37
I1696 0 1696 1.34816e-05
R2036 1696 1697 1.728 0.8 13.824 37
I1697 0 1697 1.33579e-05
R2037 1697 1698 1.712 0.8 13.696 37
I1698 0 1698 1.31105e-05
R2038 1698 1699 1.664 0.8 13.312 37
I1699 0 1699 1.26158e-05
R2039 1699 1700 1.616 0.8 12.928 37
I1700 0 1700 1.23684e-05
R2040 1700 0 0.1 49.28 49.28 37
*seg: 171
R2041 0 1701 0.1 49.28 49.28 37
R2042 1705 1715 6.16 0.8 49.28 37
I1701 0 1701 1.29868e-05
R2043 1701 1702 1.616 0.8 12.928 37
I1702 0 1702 1.26158e-05
R2044 1702 1703 1.616 0.8 12.928 37
I1703 0 1703 1.27395e-05
R2045 1703 1704 1.648 0.8 13.184 37
I1704 0 1704 1.26158e-05
R2046 1704 1705 1.616 0.8 12.928 37
I1705 0 1705 1.23684e-05
R2047 1705 1706 1.744 0.8 13.952 37
I1706 0 1706 1.34816e-05
R2048 1706 1707 1.728 0.8 13.824 37
I1707 0 1707 1.27395e-05
R2049 1707 1708 1.664 0.8 13.312 37
I1708 0 1708 1.28631e-05
R2050 1708 1709 1.728 0.8 13.824 37
I1709 0 1709 1.33579e-05
R2051 1709 1710 1.632 0.8 13.056 37
I1710 0 1710 1.23684e-05
R2052 1710 0 0.1 49.28 49.28 37
*seg: 172
R2053 0 1711 0.1 49.28 49.28 37
R2054 1715 1725 6.16 0.8 49.28 37
I1711 0 1711 1.24921e-05
R2055 1711 1712 1.696 0.8 13.568 37
I1712 0 1712 1.32342e-05
R2056 1712 1713 1.648 0.8 13.184 37
I1713 0 1713 1.34816e-05
R2057 1713 1714 1.616 0.8 12.928 37
I1714 0 1714 1.29868e-05
R2058 1714 1715 1.6 0.8 12.8 37
I1715 0 1715 1.31105e-05
R2059 1715 1716 1.696 0.8 13.568 37
I1716 0 1716 1.29868e-05
R2060 1716 1717 1.6 0.8 12.8 37
I1717 0 1717 1.33579e-05
R2061 1717 1718 1.648 0.8 13.184 37
I1718 0 1718 1.28631e-05
R2062 1718 1719 1.6 0.8 12.8 37
I1719 0 1719 1.24921e-05
R2063 1719 1720 1.68 0.8 13.44 37
I1720 0 1720 1.23684e-05
R2064 1720 0 0.1 49.28 49.28 37
*seg: 173
R2065 0 1721 0.1 49.28 49.28 37
R2066 1725 1735 6.16 0.8 49.28 37
I1721 0 1721 1.34816e-05
R2067 1721 1722 1.696 0.8 13.568 37
I1722 0 1722 1.24921e-05
R2068 1722 1723 1.616 0.8 12.928 37
I1723 0 1723 1.31105e-05
R2069 1723 1724 1.616 0.8 12.928 37
I1724 0 1724 1.28631e-05
R2070 1724 1725 1.712 0.8 13.696 37
I1725 0 1725 1.31105e-05
R2071 1725 1726 1.728 0.8 13.824 37
I1726 0 1726 1.24921e-05
R2072 1726 1727 1.728 0.8 13.824 37
I1727 0 1727 1.27395e-05
R2073 1727 1728 1.664 0.8 13.312 37
I1728 0 1728 1.32342e-05
R2074 1728 1729 1.712 0.8 13.696 37
I1729 0 1729 1.32342e-05
R2075 1729 1730 1.648 0.8 13.184 37
I1730 0 1730 1.23684e-05
R2076 1730 0 0.1 49.28 49.28 37
*seg: 174
R2077 0 1731 0.1 49.28 49.28 37
R2078 1735 1745 6.16 0.8 49.28 37
I1731 0 1731 1.34816e-05
R2079 1731 1732 1.6 0.8 12.8 37
I1732 0 1732 1.31105e-05
R2080 1732 1733 1.728 0.8 13.824 37
I1733 0 1733 1.33579e-05
R2081 1733 1734 1.712 0.8 13.696 37
I1734 0 1734 1.26158e-05
R2082 1734 1735 1.6 0.8 12.8 37
I1735 0 1735 1.33579e-05
R2083 1735 1736 1.6 0.8 12.8 37
I1736 0 1736 1.34816e-05
R2084 1736 1737 1.68 0.8 13.44 37
I1737 0 1737 1.27395e-05
R2085 1737 1738 1.68 0.8 13.44 37
I1738 0 1738 1.23684e-05
R2086 1738 1739 1.696 0.8 13.568 37
I1739 0 1739 1.33579e-05
R2087 1739 1740 1.68 0.8 13.44 37
I1740 0 1740 1.23684e-05
R2088 1740 0 0.1 49.28 49.28 37
*seg: 175
R2089 0 1741 0.1 49.28 49.28 37
R2090 1745 1755 6.16 0.8 49.28 37
I1741 0 1741 1.27395e-05
R2091 1741 1742 1.664 0.8 13.312 37
I1742 0 1742 1.32342e-05
R2092 1742 1743 1.696 0.8 13.568 37
I1743 0 1743 1.28631e-05
R2093 1743 1744 1.648 0.8 13.184 37
I1744 0 1744 1.33579e-05
R2094 1744 1745 1.696 0.8 13.568 37
I1745 0 1745 1.27395e-05
R2095 1745 1746 1.632 0.8 13.056 37
I1746 0 1746 1.23684e-05
R2096 1746 1747 1.712 0.8 13.696 37
I1747 0 1747 1.32342e-05
R2097 1747 1748 1.616 0.8 12.928 37
I1748 0 1748 1.27395e-05
R2098 1748 1749 1.712 0.8 13.696 37
I1749 0 1749 1.34816e-05
R2099 1749 1750 1.744 0.8 13.952 37
I1750 0 1750 1.23684e-05
R2100 1750 0 0.1 49.28 49.28 37
*seg: 176
R2101 0 1751 0.1 49.28 49.28 37
R2102 1755 1765 6.16 0.8 49.28 37
I1751 0 1751 1.28631e-05
R2103 1751 1752 1.696 0.8 13.568 37
I1752 0 1752 1.29868e-05
R2104 1752 1753 1.712 0.8 13.696 37
I1753 0 1753 1.31105e-05
R2105 1753 1754 1.632 0.8 13.056 37
I1754 0 1754 1.23684e-05
R2106 1754 1755 1.648 0.8 13.184 37
I1755 0 1755 1.24921e-05
R2107 1755 1756 1.616 0.8 12.928 37
I1756 0 1756 1.28631e-05
R2108 1756 1757 1.648 0.8 13.184 37
I1757 0 1757 1.26158e-05
R2109 1757 1758 1.616 0.8 12.928 37
I1758 0 1758 1.27395e-05
R2110 1758 1759 1.744 0.8 13.952 37
I1759 0 1759 1.24921e-05
R2111 1759 1760 1.616 0.8 12.928 37
I1760 0 1760 1.23684e-05
R2112 1760 0 0.1 49.28 49.28 37
*seg: 177
R2113 0 1761 0.1 49.28 49.28 37
R2114 1765 1775 6.16 0.8 49.28 37
I1761 0 1761 1.28631e-05
R2115 1761 1762 1.632 0.8 13.056 37
I1762 0 1762 1.34816e-05
R2116 1762 1763 1.664 0.8 13.312 37
I1763 0 1763 1.24921e-05
R2117 1763 1764 1.648 0.8 13.184 37
I1764 0 1764 1.33579e-05
R2118 1764 1765 1.696 0.8 13.568 37
I1765 0 1765 1.24921e-05
R2119 1765 1766 1.6 0.8 12.8 37
I1766 0 1766 1.26158e-05
R2120 1766 1767 1.632 0.8 13.056 37
I1767 0 1767 1.32342e-05
R2121 1767 1768 1.68 0.8 13.44 37
I1768 0 1768 1.32342e-05
R2122 1768 1769 1.648 0.8 13.184 37
I1769 0 1769 1.31105e-05
R2123 1769 1770 1.712 0.8 13.696 37
I1770 0 1770 1.23684e-05
R2124 1770 0 0.1 49.28 49.28 37
*seg: 178
R2125 0 1771 0.1 49.28 49.28 37
R2126 1775 1785 6.16 0.8 49.28 37
I1771 0 1771 1.23684e-05
R2127 1771 1772 1.728 0.8 13.824 37
I1772 0 1772 1.33579e-05
R2128 1772 1773 1.712 0.8 13.696 37
I1773 0 1773 1.32342e-05
R2129 1773 1774 1.648 0.8 13.184 37
I1774 0 1774 1.28631e-05
R2130 1774 1775 1.696 0.8 13.568 37
I1775 0 1775 1.29868e-05
R2131 1775 1776 1.712 0.8 13.696 37
I1776 0 1776 1.27395e-05
R2132 1776 1777 1.744 0.8 13.952 37
I1777 0 1777 1.27395e-05
R2133 1777 1778 1.616 0.8 12.928 37
I1778 0 1778 1.32342e-05
R2134 1778 1779 1.648 0.8 13.184 37
I1779 0 1779 1.29868e-05
R2135 1779 1780 1.728 0.8 13.824 37
I1780 0 1780 1.23684e-05
R2136 1780 0 0.1 49.28 49.28 37
*seg: 179
R2137 0 1781 0.1 49.28 49.28 37
R2138 1785 1795 6.16 0.8 49.28 37
I1781 0 1781 1.32342e-05
R2139 1781 1782 1.712 0.8 13.696 37
I1782 0 1782 1.29868e-05
R2140 1782 1783 1.6 0.8 12.8 37
I1783 0 1783 1.27395e-05
R2141 1783 1784 1.616 0.8 12.928 37
I1784 0 1784 1.33579e-05
R2142 1784 1785 1.648 0.8 13.184 37
I1785 0 1785 1.31105e-05
R2143 1785 1786 1.712 0.8 13.696 37
I1786 0 1786 1.24921e-05
R2144 1786 1787 1.6 0.8 12.8 37
I1787 0 1787 1.23684e-05
R2145 1787 1788 1.664 0.8 13.312 37
I1788 0 1788 1.27395e-05
R2146 1788 1789 1.664 0.8 13.312 37
I1789 0 1789 1.34816e-05
R2147 1789 1790 1.728 0.8 13.824 37
I1790 0 1790 1.23684e-05
R2148 1790 0 0.1 49.28 49.28 37
*seg: 180
R2149 0 1791 0.1 49.28 49.28 37
R2150 1795 1805 6.16 0.8 49.28 37
I1791 0 1791 1.31105e-05
R2151 1791 1792 1.6 0.8 12.8 37
I1792 0 1792 1.27395e-05
R2152 1792 1793 1.648 0.8 13.184 37
I1793 0 1793 1.23684e-05
R2153 1793 1794 1.648 0.8 13.184 37
I1794 0 1794 1.23684e-05
R2154 1794 1795 1.6 0.8 12.8 37
I1795 0 1795 1.27395e-05
R2155 1795 1796 1.68 0.8 13.44 37
I1796 0 1796 1.29868e-05
R2156 1796 1797 1.616 0.8 12.928 37
I1797 0 1797 1.29868e-05
R2157 1797 1798 1.616 0.8 12.928 37
I1798 0 1798 1.24921e-05
R2158 1798 1799 1.712 0.8 13.696 37
I1799 0 1799 1.28631e-05
R2159 1799 1800 1.696 0.8 13.568 37
I1800 0 1800 1.23684e-05
R2160 1800 0 0.1 49.28 49.28 37
*seg: 181
R2161 0 1801 0.1 49.28 49.28 37
R2162 1805 1815 6.16 0.8 49.28 37
I1801 0 1801 1.27395e-05
R2163 1801 1802 1.648 0.8 13.184 37
I1802 0 1802 1.23684e-05
R2164 1802 1803 1.6 0.8 12.8 37
I1803 0 1803 1.31105e-05
R2165 1803 1804 1.648 0.8 13.184 37
I1804 0 1804 1.31105e-05
R2166 1804 1805 1.728 0.8 13.824 37
I1805 0 1805 1.24921e-05
R2167 1805 1806 1.68 0.8 13.44 37
I1806 0 1806 1.26158e-05
R2168 1806 1807 1.712 0.8 13.696 37
I1807 0 1807 1.23684e-05
R2169 1807 1808 1.696 0.8 13.568 37
I1808 0 1808 1.33579e-05
R2170 1808 1809 1.712 0.8 13.696 37
I1809 0 1809 1.34816e-05
R2171 1809 1810 1.712 0.8 13.696 37
I1810 0 1810 1.23684e-05
R2172 1810 0 0.1 49.28 49.28 37
*seg: 182
R2173 0 1811 0.1 49.28 49.28 37
R2174 1815 1825 6.16 0.8 49.28 37
I1811 0 1811 1.24921e-05
R2175 1811 1812 1.744 0.8 13.952 37
I1812 0 1812 1.28631e-05
R2176 1812 1813 1.712 0.8 13.696 37
I1813 0 1813 1.29868e-05
R2177 1813 1814 1.648 0.8 13.184 37
I1814 0 1814 1.28631e-05
R2178 1814 1815 1.616 0.8 12.928 37
I1815 0 1815 1.29868e-05
R2179 1815 1816 1.648 0.8 13.184 37
I1816 0 1816 1.28631e-05
R2180 1816 1817 1.6 0.8 12.8 37
I1817 0 1817 1.28631e-05
R2181 1817 1818 1.728 0.8 13.824 37
I1818 0 1818 1.23684e-05
R2182 1818 1819 1.616 0.8 12.928 37
I1819 0 1819 1.34816e-05
R2183 1819 1820 1.648 0.8 13.184 37
I1820 0 1820 1.23684e-05
R2184 1820 0 0.1 49.28 49.28 37
*seg: 183
R2185 0 1821 0.1 49.28 49.28 37
R2186 1825 1835 6.16 0.8 49.28 37
I1821 0 1821 1.23684e-05
R2187 1821 1822 1.632 0.8 13.056 37
I1822 0 1822 1.24921e-05
R2188 1822 1823 1.744 0.8 13.952 37
I1823 0 1823 1.32342e-05
R2189 1823 1824 1.664 0.8 13.312 37
I1824 0 1824 1.27395e-05
R2190 1824 1825 1.648 0.8 13.184 37
I1825 0 1825 1.32342e-05
R2191 1825 1826 1.6 0.8 12.8 37
I1826 0 1826 1.31105e-05
R2192 1826 1827 1.664 0.8 13.312 37
I1827 0 1827 1.33579e-05
R2193 1827 1828 1.68 0.8 13.44 37
I1828 0 1828 1.34816e-05
R2194 1828 1829 1.648 0.8 13.184 37
I1829 0 1829 1.24921e-05
R2195 1829 1830 1.6 0.8 12.8 37
I1830 0 1830 1.23684e-05
R2196 1830 0 0.1 49.28 49.28 37
*seg: 184
R2197 0 1831 0.1 49.28 49.28 37
R2198 1835 1845 6.16 0.8 49.28 37
I1831 0 1831 1.27395e-05
R2199 1831 1832 1.664 0.8 13.312 37
I1832 0 1832 1.32342e-05
R2200 1832 1833 1.728 0.8 13.824 37
I1833 0 1833 1.26158e-05
R2201 1833 1834 1.728 0.8 13.824 37
I1834 0 1834 1.28631e-05
R2202 1834 1835 1.664 0.8 13.312 37
I1835 0 1835 1.23684e-05
R2203 1835 1836 1.712 0.8 13.696 37
I1836 0 1836 1.28631e-05
R2204 1836 1837 1.68 0.8 13.44 37
I1837 0 1837 1.29868e-05
R2205 1837 1838 1.632 0.8 13.056 37
I1838 0 1838 1.24921e-05
R2206 1838 1839 1.728 0.8 13.824 37
I1839 0 1839 1.26158e-05
R2207 1839 1840 1.6 0.8 12.8 37
I1840 0 1840 1.23684e-05
R2208 1840 0 0.1 49.28 49.28 37
*seg: 185
R2209 0 1841 0.1 49.28 49.28 37
R2210 1845 1855 6.16 0.8 49.28 37
I1841 0 1841 1.34816e-05
R2211 1841 1842 1.696 0.8 13.568 37
I1842 0 1842 1.24921e-05
R2212 1842 1843 1.6 0.8 12.8 37
I1843 0 1843 1.26158e-05
R2213 1843 1844 1.696 0.8 13.568 37
I1844 0 1844 1.34816e-05
R2214 1844 1845 1.728 0.8 13.824 37
I1845 0 1845 1.26158e-05
R2215 1845 1846 1.728 0.8 13.824 37
I1846 0 1846 1.32342e-05
R2216 1846 1847 1.616 0.8 12.928 37
I1847 0 1847 1.27395e-05
R2217 1847 1848 1.6 0.8 12.8 37
I1848 0 1848 1.24921e-05
R2218 1848 1849 1.6 0.8 12.8 37
I1849 0 1849 1.28631e-05
R2219 1849 1850 1.744 0.8 13.952 37
I1850 0 1850 1.23684e-05
R2220 1850 0 0.1 49.28 49.28 37
*seg: 186
R2221 0 1851 0.1 49.28 49.28 37
R2222 1855 1865 6.16 0.8 49.28 37
I1851 0 1851 1.33579e-05
R2223 1851 1852 1.6 0.8 12.8 37
I1852 0 1852 1.27395e-05
R2224 1852 1853 1.744 0.8 13.952 37
I1853 0 1853 1.28631e-05
R2225 1853 1854 1.6 0.8 12.8 37
I1854 0 1854 1.27395e-05
R2226 1854 1855 1.696 0.8 13.568 37
I1855 0 1855 1.34816e-05
R2227 1855 1856 1.728 0.8 13.824 37
I1856 0 1856 1.29868e-05
R2228 1856 1857 1.712 0.8 13.696 37
I1857 0 1857 1.33579e-05
R2229 1857 1858 1.616 0.8 12.928 37
I1858 0 1858 1.34816e-05
R2230 1858 1859 1.728 0.8 13.824 37
I1859 0 1859 1.34816e-05
R2231 1859 1860 1.728 0.8 13.824 37
I1860 0 1860 1.23684e-05
R2232 1860 0 0.1 49.28 49.28 37
*seg: 187
R2233 0 1861 0.1 49.28 49.28 37
R2234 1865 1875 6.16 0.8 49.28 37
I1861 0 1861 1.23684e-05
R2235 1861 1862 1.632 0.8 13.056 37
I1862 0 1862 1.23684e-05
R2236 1862 1863 1.616 0.8 12.928 37
I1863 0 1863 1.29868e-05
R2237 1863 1864 1.744 0.8 13.952 37
I1864 0 1864 1.34816e-05
R2238 1864 1865 1.632 0.8 13.056 37
I1865 0 1865 1.23684e-05
R2239 1865 1866 1.68 0.8 13.44 37
I1866 0 1866 1.34816e-05
R2240 1866 1867 1.648 0.8 13.184 37
I1867 0 1867 1.34816e-05
R2241 1867 1868 1.696 0.8 13.568 37
I1868 0 1868 1.28631e-05
R2242 1868 1869 1.744 0.8 13.952 37
I1869 0 1869 1.31105e-05
R2243 1869 1870 1.664 0.8 13.312 37
I1870 0 1870 1.23684e-05
R2244 1870 0 0.1 49.28 49.28 37
*seg: 188
R2245 0 1871 0.1 49.28 49.28 37
R2246 1875 1885 6.16 0.8 49.28 37
I1871 0 1871 1.26158e-05
R2247 1871 1872 1.68 0.8 13.44 37
I1872 0 1872 1.23684e-05
R2248 1872 1873 1.744 0.8 13.952 37
I1873 0 1873 1.33579e-05
R2249 1873 1874 1.744 0.8 13.952 37
I1874 0 1874 1.26158e-05
R2250 1874 1875 1.6 0.8 12.8 37
I1875 0 1875 1.31105e-05
R2251 1875 1876 1.648 0.8 13.184 37
I1876 0 1876 1.23684e-05
R2252 1876 1877 1.712 0.8 13.696 37
I1877 0 1877 1.27395e-05
R2253 1877 1878 1.68 0.8 13.44 37
I1878 0 1878 1.24921e-05
R2254 1878 1879 1.712 0.8 13.696 37
I1879 0 1879 1.24921e-05
R2255 1879 1880 1.616 0.8 12.928 37
I1880 0 1880 1.23684e-05
R2256 1880 0 0.1 49.28 49.28 37
*seg: 189
R2257 0 1881 0.1 49.28 49.28 37
R2258 1885 1895 6.16 0.8 49.28 37
I1881 0 1881 1.24921e-05
R2259 1881 1882 1.68 0.8 13.44 37
I1882 0 1882 1.26158e-05
R2260 1882 1883 1.632 0.8 13.056 37
I1883 0 1883 1.34816e-05
R2261 1883 1884 1.664 0.8 13.312 37
I1884 0 1884 1.33579e-05
R2262 1884 1885 1.6 0.8 12.8 37
I1885 0 1885 1.24921e-05
R2263 1885 1886 1.6 0.8 12.8 37
I1886 0 1886 1.34816e-05
R2264 1886 1887 1.664 0.8 13.312 37
I1887 0 1887 1.33579e-05
R2265 1887 1888 1.68 0.8 13.44 37
I1888 0 1888 1.33579e-05
R2266 1888 1889 1.648 0.8 13.184 37
I1889 0 1889 1.33579e-05
R2267 1889 1890 1.648 0.8 13.184 37
I1890 0 1890 1.23684e-05
R2268 1890 0 0.1 49.28 49.28 37
*seg: 190
R2269 0 1891 0.1 49.28 49.28 37
R2270 1895 1905 6.16 0.8 49.28 37
I1891 0 1891 1.27395e-05
R2271 1891 1892 1.728 0.8 13.824 37
I1892 0 1892 1.23684e-05
R2272 1892 1893 1.68 0.8 13.44 37
I1893 0 1893 1.23684e-05
R2273 1893 1894 1.68 0.8 13.44 37
I1894 0 1894 1.26158e-05
R2274 1894 1895 1.664 0.8 13.312 37
I1895 0 1895 1.31105e-05
R2275 1895 1896 1.664 0.8 13.312 37
I1896 0 1896 1.32342e-05
R2276 1896 1897 1.728 0.8 13.824 37
I1897 0 1897 1.23684e-05
R2277 1897 1898 1.664 0.8 13.312 37
I1898 0 1898 1.31105e-05
R2278 1898 1899 1.712 0.8 13.696 37
I1899 0 1899 1.27395e-05
R2279 1899 1900 1.648 0.8 13.184 37
I1900 0 1900 1.23684e-05
R2280 1900 0 0.1 49.28 49.28 37
*seg: 191
R2281 0 1901 0.1 49.28 49.28 37
R2282 1905 1915 6.16 0.8 49.28 37
I1901 0 1901 1.27395e-05
R2283 1901 1902 1.6 0.8 12.8 37
I1902 0 1902 1.24921e-05
R2284 1902 1903 1.632 0.8 13.056 37
I1903 0 1903 1.31105e-05
R2285 1903 1904 1.664 0.8 13.312 37
I1904 0 1904 1.24921e-05
R2286 1904 1905 1.632 0.8 13.056 37
I1905 0 1905 1.31105e-05
R2287 1905 1906 1.648 0.8 13.184 37
I1906 0 1906 1.28631e-05
R2288 1906 1907 1.616 0.8 12.928 37
I1907 0 1907 1.27395e-05
R2289 1907 1908 1.616 0.8 12.928 37
I1908 0 1908 1.26158e-05
R2290 1908 1909 1.696 0.8 13.568 37
I1909 0 1909 1.27395e-05
R2291 1909 1910 1.616 0.8 12.928 37
I1910 0 1910 1.23684e-05
R2292 1910 0 0.1 49.28 49.28 37
*seg: 192
R2293 0 1911 0.1 49.28 49.28 37
R2294 1915 1925 6.16 0.8 49.28 37
I1911 0 1911 1.24921e-05
R2295 1911 1912 1.648 0.8 13.184 37
I1912 0 1912 1.34816e-05
R2296 1912 1913 1.632 0.8 13.056 37
I1913 0 1913 1.24921e-05
R2297 1913 1914 1.664 0.8 13.312 37
I1914 0 1914 1.29868e-05
R2298 1914 1915 1.616 0.8 12.928 37
I1915 0 1915 1.33579e-05
R2299 1915 1916 1.728 0.8 13.824 37
I1916 0 1916 1.28631e-05
R2300 1916 1917 1.712 0.8 13.696 37
I1917 0 1917 1.33579e-05
R2301 1917 1918 1.68 0.8 13.44 37
I1918 0 1918 1.31105e-05
R2302 1918 1919 1.6 0.8 12.8 37
I1919 0 1919 1.24921e-05
R2303 1919 1920 1.696 0.8 13.568 37
I1920 0 1920 1.23684e-05
R2304 1920 0 0.1 49.28 49.28 37
*seg: 193
R2305 0 1921 0.1 49.28 49.28 37
R2306 1925 1935 6.16 0.8 49.28 37
I1921 0 1921 1.28631e-05
R2307 1921 1922 1.648 0.8 13.184 37
I1922 0 1922 1.27395e-05
R2308 1922 1923 1.68 0.8 13.44 37
I1923 0 1923 1.31105e-05
R2309 1923 1924 1.712 0.8 13.696 37
I1924 0 1924 1.31105e-05
R2310 1924 1925 1.6 0.8 12.8 37
I1925 0 1925 1.27395e-05
R2311 1925 1926 1.728 0.8 13.824 37
I1926 0 1926 1.27395e-05
R2312 1926 1927 1.68 0.8 13.44 37
I1927 0 1927 1.33579e-05
R2313 1927 1928 1.664 0.8 13.312 37
I1928 0 1928 1.26158e-05
R2314 1928 1929 1.712 0.8 13.696 37
I1929 0 1929 1.33579e-05
R2315 1929 1930 1.6 0.8 12.8 37
I1930 0 1930 1.23684e-05
R2316 1930 0 0.1 49.28 49.28 37
*seg: 194
R2317 0 1931 0.1 49.28 49.28 37
R2318 1935 1945 6.16 0.8 49.28 37
I1931 0 1931 1.26158e-05
R2319 1931 1932 1.712 0.8 13.696 37
I1932 0 1932 1.32342e-05
R2320 1932 1933 1.6 0.8 12.8 37
I1933 0 1933 1.31105e-05
R2321 1933 1934 1.744 0.8 13.952 37
I1934 0 1934 1.24921e-05
R2322 1934 1935 1.664 0.8 13.312 37
I1935 0 1935 1.26158e-05
R2323 1935 1936 1.6 0.8 12.8 37
I1936 0 1936 1.26158e-05
R2324 1936 1937 1.648 0.8 13.184 37
I1937 0 1937 1.31105e-05
R2325 1937 1938 1.68 0.8 13.44 37
I1938 0 1938 1.26158e-05
R2326 1938 1939 1.696 0.8 13.568 37
I1939 0 1939 1.27395e-05
R2327 1939 1940 1.696 0.8 13.568 37
I1940 0 1940 1.23684e-05
R2328 1940 0 0.1 49.28 49.28 37
*seg: 195
R2329 0 1941 0.1 49.28 49.28 37
R2330 1945 1955 6.16 0.8 49.28 37
I1941 0 1941 1.28631e-05
R2331 1941 1942 1.728 0.8 13.824 37
I1942 0 1942 1.32342e-05
R2332 1942 1943 1.616 0.8 12.928 37
I1943 0 1943 1.31105e-05
R2333 1943 1944 1.616 0.8 12.928 37
I1944 0 1944 1.29868e-05
R2334 1944 1945 1.68 0.8 13.44 37
I1945 0 1945 1.33579e-05
R2335 1945 1946 1.744 0.8 13.952 37
I1946 0 1946 1.23684e-05
R2336 1946 1947 1.664 0.8 13.312 37
I1947 0 1947 1.34816e-05
R2337 1947 1948 1.696 0.8 13.568 37
I1948 0 1948 1.28631e-05
R2338 1948 1949 1.6 0.8 12.8 37
I1949 0 1949 1.34816e-05
R2339 1949 1950 1.728 0.8 13.824 37
I1950 0 1950 1.23684e-05
R2340 1950 0 0.1 49.28 49.28 37
*seg: 196
R2341 0 1951 0.1 49.28 49.28 37
R2342 1955 1965 6.16 0.8 49.28 37
I1951 0 1951 1.24921e-05
R2343 1951 1952 1.744 0.8 13.952 37
I1952 0 1952 1.27395e-05
R2344 1952 1953 1.744 0.8 13.952 37
I1953 0 1953 1.26158e-05
R2345 1953 1954 1.728 0.8 13.824 37
I1954 0 1954 1.24921e-05
R2346 1954 1955 1.632 0.8 13.056 37
I1955 0 1955 1.23684e-05
R2347 1955 1956 1.648 0.8 13.184 37
I1956 0 1956 1.29868e-05
R2348 1956 1957 1.728 0.8 13.824 37
I1957 0 1957 1.28631e-05
R2349 1957 1958 1.616 0.8 12.928 37
I1958 0 1958 1.23684e-05
R2350 1958 1959 1.744 0.8 13.952 37
I1959 0 1959 1.28631e-05
R2351 1959 1960 1.6 0.8 12.8 37
I1960 0 1960 1.23684e-05
R2352 1960 0 0.1 49.28 49.28 37
*seg: 197
R2353 0 1961 0.1 49.28 49.28 37
R2354 1965 1975 6.16 0.8 49.28 37
I1961 0 1961 1.33579e-05
R2355 1961 1962 1.712 0.8 13.696 37
I1962 0 1962 1.29868e-05
R2356 1962 1963 1.616 0.8 12.928 37
I1963 0 1963 1.27395e-05
R2357 1963 1964 1.632 0.8 13.056 37
I1964 0 1964 1.24921e-05
R2358 1964 1965 1.728 0.8 13.824 37
I1965 0 1965 1.33579e-05
R2359 1965 1966 1.616 0.8 12.928 37
I1966 0 1966 1.31105e-05
R2360 1966 1967 1.68 0.8 13.44 37
I1967 0 1967 1.28631e-05
R2361 1967 1968 1.648 0.8 13.184 37
I1968 0 1968 1.29868e-05
R2362 1968 1969 1.712 0.8 13.696 37
I1969 0 1969 1.32342e-05
R2363 1969 1970 1.712 0.8 13.696 37
I1970 0 1970 1.23684e-05
R2364 1970 0 0.1 49.28 49.28 37
*seg: 198
R2365 0 1971 0.1 49.28 49.28 37
R2366 1975 1985 6.16 0.8 49.28 37
I1971 0 1971 1.26158e-05
R2367 1971 1972 1.712 0.8 13.696 37
I1972 0 1972 1.28631e-05
R2368 1972 1973 1.696 0.8 13.568 37
I1973 0 1973 1.23684e-05
R2369 1973 1974 1.632 0.8 13.056 37
I1974 0 1974 1.27395e-05
R2370 1974 1975 1.632 0.8 13.056 37
I1975 0 1975 1.27395e-05
R2371 1975 1976 1.632 0.8 13.056 37
I1976 0 1976 1.33579e-05
R2372 1976 1977 1.712 0.8 13.696 37
I1977 0 1977 1.31105e-05
R2373 1977 1978 1.696 0.8 13.568 37
I1978 0 1978 1.27395e-05
R2374 1978 1979 1.712 0.8 13.696 37
I1979 0 1979 1.24921e-05
R2375 1979 1980 1.712 0.8 13.696 37
I1980 0 1980 1.23684e-05
R2376 1980 0 0.1 49.28 49.28 37
*seg: 199
R2377 0 1981 0.1 49.28 49.28 37
R2378 1985 1995 6.16 0.8 49.28 37
I1981 0 1981 1.32342e-05
R2379 1981 1982 1.616 0.8 12.928 37
I1982 0 1982 1.34816e-05
R2380 1982 1983 1.664 0.8 13.312 37
I1983 0 1983 1.26158e-05
R2381 1983 1984 1.696 0.8 13.568 37
I1984 0 1984 1.28631e-05
R2382 1984 1985 1.696 0.8 13.568 37
I1985 0 1985 1.26158e-05
R2383 1985 1986 1.6 0.8 12.8 37
I1986 0 1986 1.29868e-05
R2384 1986 1987 1.744 0.8 13.952 37
I1987 0 1987 1.26158e-05
R2385 1987 1988 1.616 0.8 12.928 37
I1988 0 1988 1.33579e-05
R2386 1988 1989 1.696 0.8 13.568 37
I1989 0 1989 1.26158e-05
R2387 1989 1990 1.616 0.8 12.928 37
I1990 0 1990 1.23684e-05
R2388 1990 0 0.1 49.28 49.28 37
*seg: 200
R2389 0 1991 0.1 49.28 49.28 37
R2390 1995 2005 6.16 0.8 49.28 37
I1991 0 1991 1.32342e-05
R2391 1991 1992 1.648 0.8 13.184 37
I1992 0 1992 1.28631e-05
R2392 1992 1993 1.616 0.8 12.928 37
I1993 0 1993 1.31105e-05
R2393 1993 1994 1.744 0.8 13.952 37
I1994 0 1994 1.24921e-05
R2394 1994 1995 1.712 0.8 13.696 37
I1995 0 1995 1.29868e-05
R2395 1995 1996 1.68 0.8 13.44 37
I1996 0 1996 1.27395e-05
R2396 1996 1997 1.648 0.8 13.184 37
I1997 0 1997 1.33579e-05
R2397 1997 1998 1.664 0.8 13.312 37
I1998 0 1998 1.26158e-05
R2398 1998 1999 1.696 0.8 13.568 37
I1999 0 1999 1.24921e-05
R2399 1999 2000 1.632 0.8 13.056 37
I2000 0 2000 1.23684e-05
R2400 2000 0 0.1 49.28 49.28 37
*seg: 201
R2401 0 2001 0.1 49.28 49.28 37
R2402 2005 2015 6.16 0.8 49.28 37
I2001 0 2001 1.24921e-05
R2403 2001 2002 1.6 0.8 12.8 37
I2002 0 2002 1.33579e-05
R2404 2002 2003 1.648 0.8 13.184 37
I2003 0 2003 1.28631e-05
R2405 2003 2004 1.632 0.8 13.056 37
I2004 0 2004 1.23684e-05
R2406 2004 2005 1.6 0.8 12.8 37
I2005 0 2005 1.28631e-05
R2407 2005 2006 1.728 0.8 13.824 37
I2006 0 2006 1.24921e-05
R2408 2006 2007 1.68 0.8 13.44 37
I2007 0 2007 1.34816e-05
R2409 2007 2008 1.696 0.8 13.568 37
I2008 0 2008 1.26158e-05
R2410 2008 2009 1.696 0.8 13.568 37
I2009 0 2009 1.33579e-05
R2411 2009 2010 1.696 0.8 13.568 37
I2010 0 2010 1.23684e-05
R2412 2010 0 0.1 49.28 49.28 37
*seg: 202
R2413 0 2011 0.1 49.28 49.28 37
R2414 2015 2025 6.16 0.8 49.28 37
I2011 0 2011 1.28631e-05
R2415 2011 2012 1.632 0.8 13.056 37
I2012 0 2012 1.29868e-05
R2416 2012 2013 1.728 0.8 13.824 37
I2013 0 2013 1.31105e-05
R2417 2013 2014 1.648 0.8 13.184 37
I2014 0 2014 1.31105e-05
R2418 2014 2015 1.728 0.8 13.824 37
I2015 0 2015 1.32342e-05
R2419 2015 2016 1.664 0.8 13.312 37
I2016 0 2016 1.29868e-05
R2420 2016 2017 1.616 0.8 12.928 37
I2017 0 2017 1.33579e-05
R2421 2017 2018 1.712 0.8 13.696 37
I2018 0 2018 1.32342e-05
R2422 2018 2019 1.728 0.8 13.824 37
I2019 0 2019 1.34816e-05
R2423 2019 2020 1.6 0.8 12.8 37
I2020 0 2020 1.23684e-05
R2424 2020 0 0.1 49.28 49.28 37
*seg: 203
R2425 0 2021 0.1 49.28 49.28 37
R2426 2025 2035 6.16 0.8 49.28 37
I2021 0 2021 1.26158e-05
R2427 2021 2022 1.728 0.8 13.824 37
I2022 0 2022 1.23684e-05
R2428 2022 2023 1.744 0.8 13.952 37
I2023 0 2023 1.24921e-05
R2429 2023 2024 1.744 0.8 13.952 37
I2024 0 2024 1.23684e-05
R2430 2024 2025 1.696 0.8 13.568 37
I2025 0 2025 1.27395e-05
R2431 2025 2026 1.664 0.8 13.312 37
I2026 0 2026 1.31105e-05
R2432 2026 2027 1.648 0.8 13.184 37
I2027 0 2027 1.27395e-05
R2433 2027 2028 1.68 0.8 13.44 37
I2028 0 2028 1.28631e-05
R2434 2028 2029 1.68 0.8 13.44 37
I2029 0 2029 1.23684e-05
R2435 2029 2030 1.632 0.8 13.056 37
I2030 0 2030 1.23684e-05
R2436 2030 0 0.1 49.28 49.28 37
*seg: 204
R2437 0 2031 0.1 49.28 49.28 37
R2438 2035 2045 6.16 0.8 49.28 37
I2031 0 2031 1.34816e-05
R2439 2031 2032 1.728 0.8 13.824 37
I2032 0 2032 1.26158e-05
R2440 2032 2033 1.712 0.8 13.696 37
I2033 0 2033 1.26158e-05
R2441 2033 2034 1.728 0.8 13.824 37
I2034 0 2034 1.26158e-05
R2442 2034 2035 1.744 0.8 13.952 37
I2035 0 2035 1.32342e-05
R2443 2035 2036 1.744 0.8 13.952 37
I2036 0 2036 1.32342e-05
R2444 2036 2037 1.744 0.8 13.952 37
I2037 0 2037 1.23684e-05
R2445 2037 2038 1.728 0.8 13.824 37
I2038 0 2038 1.23684e-05
R2446 2038 2039 1.616 0.8 12.928 37
I2039 0 2039 1.27395e-05
R2447 2039 2040 1.728 0.8 13.824 37
I2040 0 2040 1.23684e-05
R2448 2040 0 0.1 49.28 49.28 37
*seg: 205
R2449 0 2041 0.1 49.28 49.28 37
R2450 2045 2055 6.16 0.8 49.28 37
I2041 0 2041 1.28631e-05
R2451 2041 2042 1.6 0.8 12.8 37
I2042 0 2042 1.28631e-05
R2452 2042 2043 1.616 0.8 12.928 37
I2043 0 2043 1.28631e-05
R2453 2043 2044 1.6 0.8 12.8 37
I2044 0 2044 1.27395e-05
R2454 2044 2045 1.664 0.8 13.312 37
I2045 0 2045 1.32342e-05
R2455 2045 2046 1.68 0.8 13.44 37
I2046 0 2046 1.31105e-05
R2456 2046 2047 1.648 0.8 13.184 37
I2047 0 2047 1.28631e-05
R2457 2047 2048 1.728 0.8 13.824 37
I2048 0 2048 1.26158e-05
R2458 2048 2049 1.632 0.8 13.056 37
I2049 0 2049 1.29868e-05
R2459 2049 2050 1.616 0.8 12.928 37
I2050 0 2050 1.23684e-05
R2460 2050 0 0.1 49.28 49.28 37
*seg: 206
R2461 0 2051 0.1 49.28 49.28 37
R2462 2055 2065 6.16 0.8 49.28 37
I2051 0 2051 1.23684e-05
R2463 2051 2052 1.728 0.8 13.824 37
I2052 0 2052 1.27395e-05
R2464 2052 2053 1.632 0.8 13.056 37
I2053 0 2053 1.28631e-05
R2465 2053 2054 1.6 0.8 12.8 37
I2054 0 2054 1.28631e-05
R2466 2054 2055 1.696 0.8 13.568 37
I2055 0 2055 1.26158e-05
R2467 2055 2056 1.648 0.8 13.184 37
I2056 0 2056 1.29868e-05
R2468 2056 2057 1.696 0.8 13.568 37
I2057 0 2057 1.26158e-05
R2469 2057 2058 1.616 0.8 12.928 37
I2058 0 2058 1.27395e-05
R2470 2058 2059 1.728 0.8 13.824 37
I2059 0 2059 1.24921e-05
R2471 2059 2060 1.632 0.8 13.056 37
I2060 0 2060 1.23684e-05
R2472 2060 0 0.1 49.28 49.28 37
*seg: 207
R2473 0 2061 0.1 49.28 49.28 37
R2474 2065 2075 6.16 0.8 49.28 37
I2061 0 2061 1.24921e-05
R2475 2061 2062 1.616 0.8 12.928 37
I2062 0 2062 1.32342e-05
R2476 2062 2063 1.68 0.8 13.44 37
I2063 0 2063 1.33579e-05
R2477 2063 2064 1.648 0.8 13.184 37
I2064 0 2064 1.34816e-05
R2478 2064 2065 1.6 0.8 12.8 37
I2065 0 2065 1.31105e-05
R2479 2065 2066 1.648 0.8 13.184 37
I2066 0 2066 1.34816e-05
R2480 2066 2067 1.744 0.8 13.952 37
I2067 0 2067 1.29868e-05
R2481 2067 2068 1.616 0.8 12.928 37
I2068 0 2068 1.28631e-05
R2482 2068 2069 1.728 0.8 13.824 37
I2069 0 2069 1.27395e-05
R2483 2069 2070 1.648 0.8 13.184 37
I2070 0 2070 1.23684e-05
R2484 2070 0 0.1 49.28 49.28 37
*seg: 208
R2485 0 2071 0.1 49.28 49.28 37
R2486 2075 2085 6.16 0.8 49.28 37
I2071 0 2071 1.34816e-05
R2487 2071 2072 1.712 0.8 13.696 37
I2072 0 2072 1.31105e-05
R2488 2072 2073 1.632 0.8 13.056 37
I2073 0 2073 1.32342e-05
R2489 2073 2074 1.696 0.8 13.568 37
I2074 0 2074 1.29868e-05
R2490 2074 2075 1.632 0.8 13.056 37
I2075 0 2075 1.23684e-05
R2491 2075 2076 1.712 0.8 13.696 37
I2076 0 2076 1.26158e-05
R2492 2076 2077 1.68 0.8 13.44 37
I2077 0 2077 1.26158e-05
R2493 2077 2078 1.68 0.8 13.44 37
I2078 0 2078 1.23684e-05
R2494 2078 2079 1.632 0.8 13.056 37
I2079 0 2079 1.29868e-05
R2495 2079 2080 1.728 0.8 13.824 37
I2080 0 2080 1.23684e-05
R2496 2080 0 0.1 49.28 49.28 37
*seg: 209
R2497 0 2081 0.1 49.28 49.28 37
R2498 2085 2095 6.16 0.8 49.28 37
I2081 0 2081 1.32342e-05
R2499 2081 2082 1.696 0.8 13.568 37
I2082 0 2082 1.26158e-05
R2500 2082 2083 1.744 0.8 13.952 37
I2083 0 2083 1.28631e-05
R2501 2083 2084 1.664 0.8 13.312 37
I2084 0 2084 1.27395e-05
R2502 2084 2085 1.648 0.8 13.184 37
I2085 0 2085 1.23684e-05
R2503 2085 2086 1.696 0.8 13.568 37
I2086 0 2086 1.28631e-05
R2504 2086 2087 1.632 0.8 13.056 37
I2087 0 2087 1.32342e-05
R2505 2087 2088 1.632 0.8 13.056 37
I2088 0 2088 1.31105e-05
R2506 2088 2089 1.664 0.8 13.312 37
I2089 0 2089 1.32342e-05
R2507 2089 2090 1.696 0.8 13.568 37
I2090 0 2090 1.23684e-05
R2508 2090 0 0.1 49.28 49.28 37
*seg: 210
R2509 0 2091 0.1 49.28 49.28 37
R2510 2095 2105 6.16 0.8 49.28 37
I2091 0 2091 1.27395e-05
R2511 2091 2092 1.6 0.8 12.8 37
I2092 0 2092 1.32342e-05
R2512 2092 2093 1.616 0.8 12.928 37
I2093 0 2093 1.23684e-05
R2513 2093 2094 1.616 0.8 12.928 37
I2094 0 2094 1.32342e-05
R2514 2094 2095 1.728 0.8 13.824 37
I2095 0 2095 1.26158e-05
R2515 2095 2096 1.664 0.8 13.312 37
I2096 0 2096 1.29868e-05
R2516 2096 2097 1.728 0.8 13.824 37
I2097 0 2097 1.28631e-05
R2517 2097 2098 1.712 0.8 13.696 37
I2098 0 2098 1.24921e-05
R2518 2098 2099 1.648 0.8 13.184 37
I2099 0 2099 1.34816e-05
R2519 2099 2100 1.744 0.8 13.952 37
I2100 0 2100 1.23684e-05
R2520 2100 0 0.1 49.28 49.28 37
*seg: 211
R2521 0 2101 0.1 49.28 49.28 37
R2522 2105 2115 6.16 0.8 49.28 37
I2101 0 2101 1.23684e-05
R2523 2101 2102 1.632 0.8 13.056 37
I2102 0 2102 1.31105e-05
R2524 2102 2103 1.696 0.8 13.568 37
I2103 0 2103 1.34816e-05
R2525 2103 2104 1.68 0.8 13.44 37
I2104 0 2104 1.28631e-05
R2526 2104 2105 1.68 0.8 13.44 37
I2105 0 2105 1.32342e-05
R2527 2105 2106 1.632 0.8 13.056 37
I2106 0 2106 1.34816e-05
R2528 2106 2107 1.696 0.8 13.568 37
I2107 0 2107 1.33579e-05
R2529 2107 2108 1.6 0.8 12.8 37
I2108 0 2108 1.23684e-05
R2530 2108 2109 1.68 0.8 13.44 37
I2109 0 2109 1.32342e-05
R2531 2109 2110 1.6 0.8 12.8 37
I2110 0 2110 1.23684e-05
R2532 2110 0 0.1 49.28 49.28 37
*seg: 212
R2533 0 2111 0.1 49.28 49.28 37
R2534 2115 2125 6.16 0.8 49.28 37
I2111 0 2111 1.26158e-05
R2535 2111 2112 1.616 0.8 12.928 37
I2112 0 2112 1.24921e-05
R2536 2112 2113 1.616 0.8 12.928 37
I2113 0 2113 1.34816e-05
R2537 2113 2114 1.648 0.8 13.184 37
I2114 0 2114 1.29868e-05
R2538 2114 2115 1.712 0.8 13.696 37
I2115 0 2115 1.26158e-05
R2539 2115 2116 1.712 0.8 13.696 37
I2116 0 2116 1.29868e-05
R2540 2116 2117 1.712 0.8 13.696 37
I2117 0 2117 1.27395e-05
R2541 2117 2118 1.728 0.8 13.824 37
I2118 0 2118 1.31105e-05
R2542 2118 2119 1.664 0.8 13.312 37
I2119 0 2119 1.33579e-05
R2543 2119 2120 1.744 0.8 13.952 37
I2120 0 2120 1.23684e-05
R2544 2120 0 0.1 49.28 49.28 37
*seg: 213
R2545 0 2121 0.1 49.28 49.28 37
R2546 2125 2135 6.16 0.8 49.28 37
I2121 0 2121 1.34816e-05
R2547 2121 2122 1.6 0.8 12.8 37
I2122 0 2122 1.32342e-05
R2548 2122 2123 1.68 0.8 13.44 37
I2123 0 2123 1.32342e-05
R2549 2123 2124 1.648 0.8 13.184 37
I2124 0 2124 1.23684e-05
R2550 2124 2125 1.616 0.8 12.928 37
I2125 0 2125 1.29868e-05
R2551 2125 2126 1.648 0.8 13.184 37
I2126 0 2126 1.26158e-05
R2552 2126 2127 1.648 0.8 13.184 37
I2127 0 2127 1.32342e-05
R2553 2127 2128 1.696 0.8 13.568 37
I2128 0 2128 1.23684e-05
R2554 2128 2129 1.696 0.8 13.568 37
I2129 0 2129 1.34816e-05
R2555 2129 2130 1.696 0.8 13.568 37
I2130 0 2130 1.23684e-05
R2556 2130 0 0.1 49.28 49.28 37
*seg: 214
R2557 0 2131 0.1 49.28 49.28 37
R2558 2135 2145 6.16 0.8 49.28 37
I2131 0 2131 1.23684e-05
R2559 2131 2132 1.616 0.8 12.928 37
I2132 0 2132 1.24921e-05
R2560 2132 2133 1.696 0.8 13.568 37
I2133 0 2133 1.31105e-05
R2561 2133 2134 1.728 0.8 13.824 37
I2134 0 2134 1.24921e-05
R2562 2134 2135 1.712 0.8 13.696 37
I2135 0 2135 1.31105e-05
R2563 2135 2136 1.6 0.8 12.8 37
I2136 0 2136 1.31105e-05
R2564 2136 2137 1.744 0.8 13.952 37
I2137 0 2137 1.26158e-05
R2565 2137 2138 1.696 0.8 13.568 37
I2138 0 2138 1.32342e-05
R2566 2138 2139 1.728 0.8 13.824 37
I2139 0 2139 1.34816e-05
R2567 2139 2140 1.616 0.8 12.928 37
I2140 0 2140 1.23684e-05
R2568 2140 0 0.1 49.28 49.28 37
*seg: 215
R2569 0 2141 0.1 49.28 49.28 37
R2570 2145 2155 6.16 0.8 49.28 37
I2141 0 2141 1.28631e-05
R2571 2141 2142 1.68 0.8 13.44 37
I2142 0 2142 1.24921e-05
R2572 2142 2143 1.6 0.8 12.8 37
I2143 0 2143 1.28631e-05
R2573 2143 2144 1.696 0.8 13.568 37
I2144 0 2144 1.27395e-05
R2574 2144 2145 1.6 0.8 12.8 37
I2145 0 2145 1.23684e-05
R2575 2145 2146 1.728 0.8 13.824 37
I2146 0 2146 1.26158e-05
R2576 2146 2147 1.696 0.8 13.568 37
I2147 0 2147 1.32342e-05
R2577 2147 2148 1.68 0.8 13.44 37
I2148 0 2148 1.29868e-05
R2578 2148 2149 1.696 0.8 13.568 37
I2149 0 2149 1.24921e-05
R2579 2149 2150 1.68 0.8 13.44 37
I2150 0 2150 1.23684e-05
R2580 2150 0 0.1 49.28 49.28 37
*seg: 216
R2581 0 2151 0.1 49.28 49.28 37
R2582 2155 2165 6.16 0.8 49.28 37
I2151 0 2151 1.33579e-05
R2583 2151 2152 1.664 0.8 13.312 37
I2152 0 2152 1.29868e-05
R2584 2152 2153 1.616 0.8 12.928 37
I2153 0 2153 1.34816e-05
R2585 2153 2154 1.744 0.8 13.952 37
I2154 0 2154 1.24921e-05
R2586 2154 2155 1.712 0.8 13.696 37
I2155 0 2155 1.32342e-05
R2587 2155 2156 1.68 0.8 13.44 37
I2156 0 2156 1.32342e-05
R2588 2156 2157 1.648 0.8 13.184 37
I2157 0 2157 1.31105e-05
R2589 2157 2158 1.664 0.8 13.312 37
I2158 0 2158 1.31105e-05
R2590 2158 2159 1.712 0.8 13.696 37
I2159 0 2159 1.33579e-05
R2591 2159 2160 1.648 0.8 13.184 37
I2160 0 2160 1.23684e-05
R2592 2160 0 0.1 49.28 49.28 37
*seg: 217
R2593 0 2161 0.1 49.28 49.28 37
R2594 2165 2175 6.16 0.8 49.28 37
I2161 0 2161 1.29868e-05
R2595 2161 2162 1.632 0.8 13.056 37
I2162 0 2162 1.32342e-05
R2596 2162 2163 1.728 0.8 13.824 37
I2163 0 2163 1.23684e-05
R2597 2163 2164 1.68 0.8 13.44 37
I2164 0 2164 1.26158e-05
R2598 2164 2165 1.648 0.8 13.184 37
I2165 0 2165 1.34816e-05
R2599 2165 2166 1.712 0.8 13.696 37
I2166 0 2166 1.32342e-05
R2600 2166 2167 1.68 0.8 13.44 37
I2167 0 2167 1.27395e-05
R2601 2167 2168 1.744 0.8 13.952 37
I2168 0 2168 1.34816e-05
R2602 2168 2169 1.712 0.8 13.696 37
I2169 0 2169 1.28631e-05
R2603 2169 2170 1.696 0.8 13.568 37
I2170 0 2170 1.23684e-05
R2604 2170 0 0.1 49.28 49.28 37
*seg: 218
R2605 0 2171 0.1 49.28 49.28 37
R2606 2175 2185 6.16 0.8 49.28 37
I2171 0 2171 1.32342e-05
R2607 2171 2172 1.648 0.8 13.184 37
I2172 0 2172 1.28631e-05
R2608 2172 2173 1.68 0.8 13.44 37
I2173 0 2173 1.32342e-05
R2609 2173 2174 1.664 0.8 13.312 37
I2174 0 2174 1.24921e-05
R2610 2174 2175 1.68 0.8 13.44 37
I2175 0 2175 1.33579e-05
R2611 2175 2176 1.632 0.8 13.056 37
I2176 0 2176 1.27395e-05
R2612 2176 2177 1.712 0.8 13.696 37
I2177 0 2177 1.32342e-05
R2613 2177 2178 1.6 0.8 12.8 37
I2178 0 2178 1.24921e-05
R2614 2178 2179 1.696 0.8 13.568 37
I2179 0 2179 1.23684e-05
R2615 2179 2180 1.696 0.8 13.568 37
I2180 0 2180 1.23684e-05
R2616 2180 0 0.1 49.28 49.28 37
*seg: 219
R2617 0 2181 0.1 49.28 49.28 37
R2618 2185 2195 6.16 0.8 49.28 37
I2181 0 2181 1.32342e-05
R2619 2181 2182 1.6 0.8 12.8 37
I2182 0 2182 1.31105e-05
R2620 2182 2183 1.712 0.8 13.696 37
I2183 0 2183 1.27395e-05
R2621 2183 2184 1.6 0.8 12.8 37
I2184 0 2184 1.29868e-05
R2622 2184 2185 1.744 0.8 13.952 37
I2185 0 2185 1.26158e-05
R2623 2185 2186 1.728 0.8 13.824 37
I2186 0 2186 1.33579e-05
R2624 2186 2187 1.648 0.8 13.184 37
I2187 0 2187 1.27395e-05
R2625 2187 2188 1.728 0.8 13.824 37
I2188 0 2188 1.31105e-05
R2626 2188 2189 1.68 0.8 13.44 37
I2189 0 2189 1.28631e-05
R2627 2189 2190 1.744 0.8 13.952 37
I2190 0 2190 1.23684e-05
R2628 2190 0 0.1 49.28 49.28 37
*seg: 220
R2629 0 2191 0.1 49.28 49.28 37
R2630 2195 2205 6.16 0.8 49.28 37
I2191 0 2191 1.32342e-05
R2631 2191 2192 1.68 0.8 13.44 37
I2192 0 2192 1.31105e-05
R2632 2192 2193 1.616 0.8 12.928 37
I2193 0 2193 1.28631e-05
R2633 2193 2194 1.744 0.8 13.952 37
I2194 0 2194 1.32342e-05
R2634 2194 2195 1.664 0.8 13.312 37
I2195 0 2195 1.27395e-05
R2635 2195 2196 1.712 0.8 13.696 37
I2196 0 2196 1.28631e-05
R2636 2196 2197 1.712 0.8 13.696 37
I2197 0 2197 1.26158e-05
R2637 2197 2198 1.744 0.8 13.952 37
I2198 0 2198 1.31105e-05
R2638 2198 2199 1.696 0.8 13.568 37
I2199 0 2199 1.23684e-05
R2639 2199 2200 1.6 0.8 12.8 37
I2200 0 2200 1.23684e-05
R2640 2200 0 0.1 49.28 49.28 37
*seg: 221
R2641 0 2201 0.1 49.28 49.28 37
R2642 2205 2215 6.16 0.8 49.28 37
I2201 0 2201 1.33579e-05
R2643 2201 2202 1.632 0.8 13.056 37
I2202 0 2202 1.27395e-05
R2644 2202 2203 1.6 0.8 12.8 37
I2203 0 2203 1.33579e-05
R2645 2203 2204 1.728 0.8 13.824 37
I2204 0 2204 1.27395e-05
R2646 2204 2205 1.696 0.8 13.568 37
I2205 0 2205 1.29868e-05
R2647 2205 2206 1.6 0.8 12.8 37
I2206 0 2206 1.24921e-05
R2648 2206 2207 1.648 0.8 13.184 37
I2207 0 2207 1.27395e-05
R2649 2207 2208 1.68 0.8 13.44 37
I2208 0 2208 1.28631e-05
R2650 2208 2209 1.728 0.8 13.824 37
I2209 0 2209 1.33579e-05
R2651 2209 2210 1.664 0.8 13.312 37
I2210 0 2210 1.23684e-05
R2652 2210 0 0.1 49.28 49.28 37
*seg: 222
R2653 0 2211 0.1 49.28 49.28 37
R2654 2215 2225 6.16 0.8 49.28 37
I2211 0 2211 1.26158e-05
R2655 2211 2212 1.744 0.8 13.952 37
I2212 0 2212 1.29868e-05
R2656 2212 2213 1.728 0.8 13.824 37
I2213 0 2213 1.32342e-05
R2657 2213 2214 1.632 0.8 13.056 37
I2214 0 2214 1.26158e-05
R2658 2214 2215 1.6 0.8 12.8 37
I2215 0 2215 1.24921e-05
R2659 2215 2216 1.68 0.8 13.44 37
I2216 0 2216 1.27395e-05
R2660 2216 2217 1.6 0.8 12.8 37
I2217 0 2217 1.33579e-05
R2661 2217 2218 1.728 0.8 13.824 37
I2218 0 2218 1.32342e-05
R2662 2218 2219 1.68 0.8 13.44 37
I2219 0 2219 1.34816e-05
R2663 2219 2220 1.664 0.8 13.312 37
I2220 0 2220 1.23684e-05
R2664 2220 0 0.1 49.28 49.28 37
*seg: 223
R2665 0 2221 0.1 49.28 49.28 37
R2666 2225 2235 6.16 0.8 49.28 37
I2221 0 2221 1.24921e-05
R2667 2221 2222 1.616 0.8 12.928 37
I2222 0 2222 1.32342e-05
R2668 2222 2223 1.664 0.8 13.312 37
I2223 0 2223 1.31105e-05
R2669 2223 2224 1.664 0.8 13.312 37
I2224 0 2224 1.26158e-05
R2670 2224 2225 1.696 0.8 13.568 37
I2225 0 2225 1.24921e-05
R2671 2225 2226 1.728 0.8 13.824 37
I2226 0 2226 1.26158e-05
R2672 2226 2227 1.648 0.8 13.184 37
I2227 0 2227 1.24921e-05
R2673 2227 2228 1.696 0.8 13.568 37
I2228 0 2228 1.34816e-05
R2674 2228 2229 1.632 0.8 13.056 37
I2229 0 2229 1.26158e-05
R2675 2229 2230 1.664 0.8 13.312 37
I2230 0 2230 1.23684e-05
R2676 2230 0 0.1 49.28 49.28 37
*seg: 224
R2677 0 2231 0.1 49.28 49.28 37
R2678 2235 2245 6.16 0.8 49.28 37
I2231 0 2231 1.23684e-05
R2679 2231 2232 1.664 0.8 13.312 37
I2232 0 2232 1.27395e-05
R2680 2232 2233 1.712 0.8 13.696 37
I2233 0 2233 1.32342e-05
R2681 2233 2234 1.744 0.8 13.952 37
I2234 0 2234 1.23684e-05
R2682 2234 2235 1.6 0.8 12.8 37
I2235 0 2235 1.31105e-05
R2683 2235 2236 1.68 0.8 13.44 37
I2236 0 2236 1.23684e-05
R2684 2236 2237 1.696 0.8 13.568 37
I2237 0 2237 1.31105e-05
R2685 2237 2238 1.728 0.8 13.824 37
I2238 0 2238 1.29868e-05
R2686 2238 2239 1.6 0.8 12.8 37
I2239 0 2239 1.32342e-05
R2687 2239 2240 1.616 0.8 12.928 37
I2240 0 2240 1.23684e-05
R2688 2240 0 0.1 49.28 49.28 37
*seg: 225
R2689 0 2241 0.1 49.28 49.28 37
R2690 2245 2255 6.16 0.8 49.28 37
I2241 0 2241 1.28631e-05
R2691 2241 2242 1.728 0.8 13.824 37
I2242 0 2242 1.33579e-05
R2692 2242 2243 1.632 0.8 13.056 37
I2243 0 2243 1.29868e-05
R2693 2243 2244 1.68 0.8 13.44 37
I2244 0 2244 1.26158e-05
R2694 2244 2245 1.648 0.8 13.184 37
I2245 0 2245 1.28631e-05
R2695 2245 2246 1.712 0.8 13.696 37
I2246 0 2246 1.28631e-05
R2696 2246 2247 1.616 0.8 12.928 37
I2247 0 2247 1.26158e-05
R2697 2247 2248 1.728 0.8 13.824 37
I2248 0 2248 1.23684e-05
R2698 2248 2249 1.728 0.8 13.824 37
I2249 0 2249 1.32342e-05
R2699 2249 2250 1.648 0.8 13.184 37
I2250 0 2250 1.23684e-05
R2700 2250 0 0.1 49.28 49.28 37
*seg: 226
R2701 0 2251 0.1 49.28 49.28 37
R2702 2255 2265 6.16 0.8 49.28 37
I2251 0 2251 1.26158e-05
R2703 2251 2252 1.712 0.8 13.696 37
I2252 0 2252 1.28631e-05
R2704 2252 2253 1.648 0.8 13.184 37
I2253 0 2253 1.29868e-05
R2705 2253 2254 1.664 0.8 13.312 37
I2254 0 2254 1.32342e-05
R2706 2254 2255 1.616 0.8 12.928 37
I2255 0 2255 1.24921e-05
R2707 2255 2256 1.712 0.8 13.696 37
I2256 0 2256 1.29868e-05
R2708 2256 2257 1.616 0.8 12.928 37
I2257 0 2257 1.23684e-05
R2709 2257 2258 1.728 0.8 13.824 37
I2258 0 2258 1.27395e-05
R2710 2258 2259 1.664 0.8 13.312 37
I2259 0 2259 1.23684e-05
R2711 2259 2260 1.728 0.8 13.824 37
I2260 0 2260 1.23684e-05
R2712 2260 0 0.1 49.28 49.28 37
*seg: 227
R2713 0 2261 0.1 49.28 49.28 37
R2714 2265 2275 6.16 0.8 49.28 37
I2261 0 2261 1.24921e-05
R2715 2261 2262 1.6 0.8 12.8 37
I2262 0 2262 1.28631e-05
R2716 2262 2263 1.632 0.8 13.056 37
I2263 0 2263 1.26158e-05
R2717 2263 2264 1.696 0.8 13.568 37
I2264 0 2264 1.29868e-05
R2718 2264 2265 1.648 0.8 13.184 37
I2265 0 2265 1.32342e-05
R2719 2265 2266 1.664 0.8 13.312 37
I2266 0 2266 1.24921e-05
R2720 2266 2267 1.728 0.8 13.824 37
I2267 0 2267 1.27395e-05
R2721 2267 2268 1.68 0.8 13.44 37
I2268 0 2268 1.24921e-05
R2722 2268 2269 1.648 0.8 13.184 37
I2269 0 2269 1.24921e-05
R2723 2269 2270 1.616 0.8 12.928 37
I2270 0 2270 1.23684e-05
R2724 2270 0 0.1 49.28 49.28 37
*seg: 228
R2725 0 2271 0.1 49.28 49.28 37
R2726 2275 2285 6.16 0.8 49.28 37
I2271 0 2271 1.26158e-05
R2727 2271 2272 1.68 0.8 13.44 37
I2272 0 2272 1.28631e-05
R2728 2272 2273 1.696 0.8 13.568 37
I2273 0 2273 1.32342e-05
R2729 2273 2274 1.616 0.8 12.928 37
I2274 0 2274 1.32342e-05
R2730 2274 2275 1.696 0.8 13.568 37
I2275 0 2275 1.23684e-05
R2731 2275 2276 1.648 0.8 13.184 37
I2276 0 2276 1.27395e-05
R2732 2276 2277 1.712 0.8 13.696 37
I2277 0 2277 1.33579e-05
R2733 2277 2278 1.632 0.8 13.056 37
I2278 0 2278 1.34816e-05
R2734 2278 2279 1.648 0.8 13.184 37
I2279 0 2279 1.29868e-05
R2735 2279 2280 1.648 0.8 13.184 37
I2280 0 2280 1.23684e-05
R2736 2280 0 0.1 49.28 49.28 37
*seg: 229
R2737 0 2281 0.1 49.28 49.28 37
R2738 2285 2295 6.16 0.8 49.28 37
I2281 0 2281 1.27395e-05
R2739 2281 2282 1.68 0.8 13.44 37
I2282 0 2282 1.34816e-05
R2740 2282 2283 1.6 0.8 12.8 37
I2283 0 2283 1.24921e-05
R2741 2283 2284 1.632 0.8 13.056 37
I2284 0 2284 1.23684e-05
R2742 2284 2285 1.744 0.8 13.952 37
I2285 0 2285 1.28631e-05
R2743 2285 2286 1.664 0.8 13.312 37
I2286 0 2286 1.27395e-05
R2744 2286 2287 1.616 0.8 12.928 37
I2287 0 2287 1.28631e-05
R2745 2287 2288 1.6 0.8 12.8 37
I2288 0 2288 1.23684e-05
R2746 2288 2289 1.648 0.8 13.184 37
I2289 0 2289 1.27395e-05
R2747 2289 2290 1.68 0.8 13.44 37
I2290 0 2290 1.23684e-05
R2748 2290 0 0.1 49.28 49.28 37
*seg: 230
R2749 0 2291 0.1 49.28 49.28 37
R2750 2295 2305 6.16 0.8 49.28 37
I2291 0 2291 1.24921e-05
R2751 2291 2292 1.712 0.8 13.696 37
I2292 0 2292 1.29868e-05
R2752 2292 2293 1.68 0.8 13.44 37
I2293 0 2293 1.24921e-05
R2753 2293 2294 1.712 0.8 13.696 37
I2294 0 2294 1.31105e-05
R2754 2294 2295 1.68 0.8 13.44 37
I2295 0 2295 1.24921e-05
R2755 2295 2296 1.712 0.8 13.696 37
I2296 0 2296 1.26158e-05
R2756 2296 2297 1.712 0.8 13.696 37
I2297 0 2297 1.31105e-05
R2757 2297 2298 1.664 0.8 13.312 37
I2298 0 2298 1.32342e-05
R2758 2298 2299 1.712 0.8 13.696 37
I2299 0 2299 1.27395e-05
R2759 2299 2300 1.712 0.8 13.696 37
I2300 0 2300 1.23684e-05
R2760 2300 0 0.1 49.28 49.28 37
*seg: 231
R2761 0 2301 0.1 49.28 49.28 37
R2762 2305 2315 6.16 0.8 49.28 37
I2301 0 2301 1.24921e-05
R2763 2301 2302 1.696 0.8 13.568 37
I2302 0 2302 1.23684e-05
R2764 2302 2303 1.68 0.8 13.44 37
I2303 0 2303 1.34816e-05
R2765 2303 2304 1.712 0.8 13.696 37
I2304 0 2304 1.27395e-05
R2766 2304 2305 1.68 0.8 13.44 37
I2305 0 2305 1.27395e-05
R2767 2305 2306 1.744 0.8 13.952 37
I2306 0 2306 1.27395e-05
R2768 2306 2307 1.68 0.8 13.44 37
I2307 0 2307 1.27395e-05
R2769 2307 2308 1.744 0.8 13.952 37
I2308 0 2308 1.27395e-05
R2770 2308 2309 1.616 0.8 12.928 37
I2309 0 2309 1.32342e-05
R2771 2309 2310 1.616 0.8 12.928 37
I2310 0 2310 1.23684e-05
R2772 2310 0 0.1 49.28 49.28 37
*seg: 232
R2773 0 2311 0.1 49.28 49.28 37
R2774 2315 2325 6.16 0.8 49.28 37
I2311 0 2311 1.31105e-05
R2775 2311 2312 1.744 0.8 13.952 37
I2312 0 2312 1.23684e-05
R2776 2312 2313 1.6 0.8 12.8 37
I2313 0 2313 1.33579e-05
R2777 2313 2314 1.648 0.8 13.184 37
I2314 0 2314 1.23684e-05
R2778 2314 2315 1.728 0.8 13.824 37
I2315 0 2315 1.27395e-05
R2779 2315 2316 1.728 0.8 13.824 37
I2316 0 2316 1.26158e-05
R2780 2316 2317 1.744 0.8 13.952 37
I2317 0 2317 1.24921e-05
R2781 2317 2318 1.664 0.8 13.312 37
I2318 0 2318 1.28631e-05
R2782 2318 2319 1.648 0.8 13.184 37
I2319 0 2319 1.31105e-05
R2783 2319 2320 1.632 0.8 13.056 37
I2320 0 2320 1.23684e-05
R2784 2320 0 0.1 49.28 49.28 37
*seg: 233
R2785 0 2321 0.1 49.28 49.28 37
R2786 2325 2335 6.16 0.8 49.28 37
I2321 0 2321 1.26158e-05
R2787 2321 2322 1.616 0.8 12.928 37
I2322 0 2322 1.24921e-05
R2788 2322 2323 1.664 0.8 13.312 37
I2323 0 2323 1.33579e-05
R2789 2323 2324 1.712 0.8 13.696 37
I2324 0 2324 1.24921e-05
R2790 2324 2325 1.648 0.8 13.184 37
I2325 0 2325 1.29868e-05
R2791 2325 2326 1.6 0.8 12.8 37
I2326 0 2326 1.29868e-05
R2792 2326 2327 1.616 0.8 12.928 37
I2327 0 2327 1.32342e-05
R2793 2327 2328 1.728 0.8 13.824 37
I2328 0 2328 1.28631e-05
R2794 2328 2329 1.664 0.8 13.312 37
I2329 0 2329 1.27395e-05
R2795 2329 2330 1.696 0.8 13.568 37
I2330 0 2330 1.23684e-05
R2796 2330 0 0.1 49.28 49.28 37
*seg: 234
R2797 0 2331 0.1 49.28 49.28 37
R2798 2335 2345 6.16 0.8 49.28 37
I2331 0 2331 1.34816e-05
R2799 2331 2332 1.744 0.8 13.952 37
I2332 0 2332 1.28631e-05
R2800 2332 2333 1.616 0.8 12.928 37
I2333 0 2333 1.29868e-05
R2801 2333 2334 1.712 0.8 13.696 37
I2334 0 2334 1.26158e-05
R2802 2334 2335 1.728 0.8 13.824 37
I2335 0 2335 1.26158e-05
R2803 2335 2336 1.68 0.8 13.44 37
I2336 0 2336 1.23684e-05
R2804 2336 2337 1.712 0.8 13.696 37
I2337 0 2337 1.23684e-05
R2805 2337 2338 1.728 0.8 13.824 37
I2338 0 2338 1.27395e-05
R2806 2338 2339 1.712 0.8 13.696 37
I2339 0 2339 1.34816e-05
R2807 2339 2340 1.696 0.8 13.568 37
I2340 0 2340 1.23684e-05
R2808 2340 0 0.1 49.28 49.28 37
*seg: 235
R2809 0 2341 0.1 49.28 49.28 37
R2810 2345 2355 6.16 0.8 49.28 37
I2341 0 2341 1.33579e-05
R2811 2341 2342 1.664 0.8 13.312 37
I2342 0 2342 1.34816e-05
R2812 2342 2343 1.712 0.8 13.696 37
I2343 0 2343 1.24921e-05
R2813 2343 2344 1.648 0.8 13.184 37
I2344 0 2344 1.23684e-05
R2814 2344 2345 1.68 0.8 13.44 37
I2345 0 2345 1.28631e-05
R2815 2345 2346 1.664 0.8 13.312 37
I2346 0 2346 1.29868e-05
R2816 2346 2347 1.616 0.8 12.928 37
I2347 0 2347 1.24921e-05
R2817 2347 2348 1.664 0.8 13.312 37
I2348 0 2348 1.24921e-05
R2818 2348 2349 1.648 0.8 13.184 37
I2349 0 2349 1.31105e-05
R2819 2349 2350 1.744 0.8 13.952 37
I2350 0 2350 1.23684e-05
R2820 2350 0 0.1 49.28 49.28 37
*seg: 236
R2821 0 2351 0.1 49.28 49.28 37
R2822 2355 2365 6.16 0.8 49.28 37
I2351 0 2351 1.34816e-05
R2823 2351 2352 1.632 0.8 13.056 37
I2352 0 2352 1.31105e-05
R2824 2352 2353 1.616 0.8 12.928 37
I2353 0 2353 1.27395e-05
R2825 2353 2354 1.632 0.8 13.056 37
I2354 0 2354 1.24921e-05
R2826 2354 2355 1.744 0.8 13.952 37
I2355 0 2355 1.33579e-05
R2827 2355 2356 1.712 0.8 13.696 37
I2356 0 2356 1.32342e-05
R2828 2356 2357 1.632 0.8 13.056 37
I2357 0 2357 1.31105e-05
R2829 2357 2358 1.664 0.8 13.312 37
I2358 0 2358 1.34816e-05
R2830 2358 2359 1.712 0.8 13.696 37
I2359 0 2359 1.23684e-05
R2831 2359 2360 1.696 0.8 13.568 37
I2360 0 2360 1.23684e-05
R2832 2360 0 0.1 49.28 49.28 37
*seg: 237
R2833 0 2361 0.1 49.28 49.28 37
R2834 2365 2375 6.16 0.8 49.28 37
I2361 0 2361 1.24921e-05
R2835 2361 2362 1.6 0.8 12.8 37
I2362 0 2362 1.24921e-05
R2836 2362 2363 1.616 0.8 12.928 37
I2363 0 2363 1.27395e-05
R2837 2363 2364 1.68 0.8 13.44 37
I2364 0 2364 1.26158e-05
R2838 2364 2365 1.728 0.8 13.824 37
I2365 0 2365 1.34816e-05
R2839 2365 2366 1.616 0.8 12.928 37
I2366 0 2366 1.24921e-05
R2840 2366 2367 1.696 0.8 13.568 37
I2367 0 2367 1.23684e-05
R2841 2367 2368 1.648 0.8 13.184 37
I2368 0 2368 1.24921e-05
R2842 2368 2369 1.712 0.8 13.696 37
I2369 0 2369 1.32342e-05
R2843 2369 2370 1.744 0.8 13.952 37
I2370 0 2370 1.23684e-05
R2844 2370 0 0.1 49.28 49.28 37
*seg: 238
R2845 0 2371 0.1 49.28 49.28 37
R2846 2375 2385 6.16 0.8 49.28 37
I2371 0 2371 1.28631e-05
R2847 2371 2372 1.616 0.8 12.928 37
I2372 0 2372 1.29868e-05
R2848 2372 2373 1.616 0.8 12.928 37
I2373 0 2373 1.26158e-05
R2849 2373 2374 1.728 0.8 13.824 37
I2374 0 2374 1.28631e-05
R2850 2374 2375 1.632 0.8 13.056 37
I2375 0 2375 1.27395e-05
R2851 2375 2376 1.648 0.8 13.184 37
I2376 0 2376 1.34816e-05
R2852 2376 2377 1.6 0.8 12.8 37
I2377 0 2377 1.27395e-05
R2853 2377 2378 1.68 0.8 13.44 37
I2378 0 2378 1.33579e-05
R2854 2378 2379 1.696 0.8 13.568 37
I2379 0 2379 1.27395e-05
R2855 2379 2380 1.744 0.8 13.952 37
I2380 0 2380 1.23684e-05
R2856 2380 0 0.1 49.28 49.28 37
*seg: 239
R2857 0 2381 0.1 49.28 49.28 37
R2858 2385 2395 6.16 0.8 49.28 37
I2381 0 2381 1.34816e-05
R2859 2381 2382 1.632 0.8 13.056 37
I2382 0 2382 1.26158e-05
R2860 2382 2383 1.696 0.8 13.568 37
I2383 0 2383 1.26158e-05
R2861 2383 2384 1.728 0.8 13.824 37
I2384 0 2384 1.24921e-05
R2862 2384 2385 1.6 0.8 12.8 37
I2385 0 2385 1.34816e-05
R2863 2385 2386 1.6 0.8 12.8 37
I2386 0 2386 1.24921e-05
R2864 2386 2387 1.616 0.8 12.928 37
I2387 0 2387 1.34816e-05
R2865 2387 2388 1.744 0.8 13.952 37
I2388 0 2388 1.31105e-05
R2866 2388 2389 1.664 0.8 13.312 37
I2389 0 2389 1.26158e-05
R2867 2389 2390 1.664 0.8 13.312 37
I2390 0 2390 1.23684e-05
R2868 2390 0 0.1 49.28 49.28 37
*seg: 240
R2869 0 2391 0.1 49.28 49.28 37
R2870 2395 2405 6.16 0.8 49.28 37
I2391 0 2391 1.33579e-05
R2871 2391 2392 1.68 0.8 13.44 37
I2392 0 2392 1.23684e-05
R2872 2392 2393 1.664 0.8 13.312 37
I2393 0 2393 1.26158e-05
R2873 2393 2394 1.648 0.8 13.184 37
I2394 0 2394 1.27395e-05
R2874 2394 2395 1.696 0.8 13.568 37
I2395 0 2395 1.28631e-05
R2875 2395 2396 1.664 0.8 13.312 37
I2396 0 2396 1.28631e-05
R2876 2396 2397 1.632 0.8 13.056 37
I2397 0 2397 1.28631e-05
R2877 2397 2398 1.616 0.8 12.928 37
I2398 0 2398 1.26158e-05
R2878 2398 2399 1.616 0.8 12.928 37
I2399 0 2399 1.27395e-05
R2879 2399 2400 1.696 0.8 13.568 37
I2400 0 2400 1.23684e-05
R2880 2400 0 0.1 49.28 49.28 37
*seg: 241
R2881 0 2401 0.1 49.28 49.28 37
R2882 2405 2415 6.16 0.8 49.28 37
I2401 0 2401 1.29868e-05
R2883 2401 2402 1.728 0.8 13.824 37
I2402 0 2402 1.28631e-05
R2884 2402 2403 1.712 0.8 13.696 37
I2403 0 2403 1.32342e-05
R2885 2403 2404 1.616 0.8 12.928 37
I2404 0 2404 1.24921e-05
R2886 2404 2405 1.728 0.8 13.824 37
I2405 0 2405 1.26158e-05
R2887 2405 2406 1.712 0.8 13.696 37
I2406 0 2406 1.26158e-05
R2888 2406 2407 1.632 0.8 13.056 37
I2407 0 2407 1.34816e-05
R2889 2407 2408 1.632 0.8 13.056 37
I2408 0 2408 1.28631e-05
R2890 2408 2409 1.68 0.8 13.44 37
I2409 0 2409 1.23684e-05
R2891 2409 2410 1.728 0.8 13.824 37
I2410 0 2410 1.23684e-05
R2892 2410 0 0.1 49.28 49.28 37
*seg: 242
R2893 0 2411 0.1 49.28 49.28 37
R2894 2415 2425 6.16 0.8 49.28 37
I2411 0 2411 1.23684e-05
R2895 2411 2412 1.6 0.8 12.8 37
I2412 0 2412 1.31105e-05
R2896 2412 2413 1.712 0.8 13.696 37
I2413 0 2413 1.24921e-05
R2897 2413 2414 1.728 0.8 13.824 37
I2414 0 2414 1.27395e-05
R2898 2414 2415 1.648 0.8 13.184 37
I2415 0 2415 1.28631e-05
R2899 2415 2416 1.728 0.8 13.824 37
I2416 0 2416 1.31105e-05
R2900 2416 2417 1.712 0.8 13.696 37
I2417 0 2417 1.26158e-05
R2901 2417 2418 1.728 0.8 13.824 37
I2418 0 2418 1.33579e-05
R2902 2418 2419 1.744 0.8 13.952 37
I2419 0 2419 1.26158e-05
R2903 2419 2420 1.616 0.8 12.928 37
I2420 0 2420 1.23684e-05
R2904 2420 0 0.1 49.28 49.28 37
*seg: 243
R2905 0 2421 0.1 49.28 49.28 37
R2906 2425 2435 6.16 0.8 49.28 37
I2421 0 2421 1.33579e-05
R2907 2421 2422 1.744 0.8 13.952 37
I2422 0 2422 1.29868e-05
R2908 2422 2423 1.648 0.8 13.184 37
I2423 0 2423 1.24921e-05
R2909 2423 2424 1.728 0.8 13.824 37
I2424 0 2424 1.33579e-05
R2910 2424 2425 1.744 0.8 13.952 37
I2425 0 2425 1.34816e-05
R2911 2425 2426 1.616 0.8 12.928 37
I2426 0 2426 1.32342e-05
R2912 2426 2427 1.68 0.8 13.44 37
I2427 0 2427 1.23684e-05
R2913 2427 2428 1.696 0.8 13.568 37
I2428 0 2428 1.23684e-05
R2914 2428 2429 1.664 0.8 13.312 37
I2429 0 2429 1.31105e-05
R2915 2429 2430 1.664 0.8 13.312 37
I2430 0 2430 1.23684e-05
R2916 2430 0 0.1 49.28 49.28 37
*seg: 244
R2917 0 2431 0.1 49.28 49.28 37
R2918 2435 2445 6.16 0.8 49.28 37
I2431 0 2431 1.31105e-05
R2919 2431 2432 1.616 0.8 12.928 37
I2432 0 2432 1.33579e-05
R2920 2432 2433 1.632 0.8 13.056 37
I2433 0 2433 1.29868e-05
R2921 2433 2434 1.632 0.8 13.056 37
I2434 0 2434 1.23684e-05
R2922 2434 2435 1.632 0.8 13.056 37
I2435 0 2435 1.23684e-05
R2923 2435 2436 1.648 0.8 13.184 37
I2436 0 2436 1.28631e-05
R2924 2436 2437 1.648 0.8 13.184 37
I2437 0 2437 1.31105e-05
R2925 2437 2438 1.696 0.8 13.568 37
I2438 0 2438 1.32342e-05
R2926 2438 2439 1.6 0.8 12.8 37
I2439 0 2439 1.34816e-05
R2927 2439 2440 1.664 0.8 13.312 37
I2440 0 2440 1.23684e-05
R2928 2440 0 0.1 49.28 49.28 37
*seg: 245
R2929 0 2441 0.1 49.28 49.28 37
R2930 2445 2455 6.16 0.8 49.28 37
I2441 0 2441 1.23684e-05
R2931 2441 2442 1.664 0.8 13.312 37
I2442 0 2442 1.28631e-05
R2932 2442 2443 1.696 0.8 13.568 37
I2443 0 2443 1.26158e-05
R2933 2443 2444 1.632 0.8 13.056 37
I2444 0 2444 1.28631e-05
R2934 2444 2445 1.744 0.8 13.952 37
I2445 0 2445 1.24921e-05
R2935 2445 2446 1.744 0.8 13.952 37
I2446 0 2446 1.33579e-05
R2936 2446 2447 1.616 0.8 12.928 37
I2447 0 2447 1.27395e-05
R2937 2447 2448 1.664 0.8 13.312 37
I2448 0 2448 1.24921e-05
R2938 2448 2449 1.616 0.8 12.928 37
I2449 0 2449 1.29868e-05
R2939 2449 2450 1.664 0.8 13.312 37
I2450 0 2450 1.23684e-05
R2940 2450 0 0.1 49.28 49.28 37
*seg: 246
R2941 0 2451 0.1 49.28 49.28 37
R2942 2455 2465 6.16 0.8 49.28 37
I2451 0 2451 1.34816e-05
R2943 2451 2452 1.744 0.8 13.952 37
I2452 0 2452 1.28631e-05
R2944 2452 2453 1.648 0.8 13.184 37
I2453 0 2453 1.32342e-05
R2945 2453 2454 1.744 0.8 13.952 37
I2454 0 2454 1.34816e-05
R2946 2454 2455 1.616 0.8 12.928 37
I2455 0 2455 1.32342e-05
R2947 2455 2456 1.696 0.8 13.568 37
I2456 0 2456 1.33579e-05
R2948 2456 2457 1.68 0.8 13.44 37
I2457 0 2457 1.32342e-05
R2949 2457 2458 1.616 0.8 12.928 37
I2458 0 2458 1.27395e-05
R2950 2458 2459 1.68 0.8 13.44 37
I2459 0 2459 1.34816e-05
R2951 2459 2460 1.728 0.8 13.824 37
I2460 0 2460 1.23684e-05
R2952 2460 0 0.1 49.28 49.28 37
*seg: 247
R2953 0 2461 0.1 49.28 49.28 37
R2954 2465 2475 6.16 0.8 49.28 37
I2461 0 2461 1.23684e-05
R2955 2461 2462 1.744 0.8 13.952 37
I2462 0 2462 1.26158e-05
R2956 2462 2463 1.68 0.8 13.44 37
I2463 0 2463 1.24921e-05
R2957 2463 2464 1.664 0.8 13.312 37
I2464 0 2464 1.29868e-05
R2958 2464 2465 1.664 0.8 13.312 37
I2465 0 2465 1.24921e-05
R2959 2465 2466 1.696 0.8 13.568 37
I2466 0 2466 1.31105e-05
R2960 2466 2467 1.632 0.8 13.056 37
I2467 0 2467 1.32342e-05
R2961 2467 2468 1.6 0.8 12.8 37
I2468 0 2468 1.23684e-05
R2962 2468 2469 1.616 0.8 12.928 37
I2469 0 2469 1.33579e-05
R2963 2469 2470 1.68 0.8 13.44 37
I2470 0 2470 1.23684e-05
R2964 2470 0 0.1 49.28 49.28 37
*seg: 248
R2965 0 2471 0.1 49.28 49.28 37
R2966 2475 2485 6.16 0.8 49.28 37
I2471 0 2471 1.31105e-05
R2967 2471 2472 1.728 0.8 13.824 37
I2472 0 2472 1.32342e-05
R2968 2472 2473 1.648 0.8 13.184 37
I2473 0 2473 1.24921e-05
R2969 2473 2474 1.744 0.8 13.952 37
I2474 0 2474 1.34816e-05
R2970 2474 2475 1.6 0.8 12.8 37
I2475 0 2475 1.34816e-05
R2971 2475 2476 1.664 0.8 13.312 37
I2476 0 2476 1.29868e-05
R2972 2476 2477 1.664 0.8 13.312 37
I2477 0 2477 1.28631e-05
R2973 2477 2478 1.616 0.8 12.928 37
I2478 0 2478 1.28631e-05
R2974 2478 2479 1.744 0.8 13.952 37
I2479 0 2479 1.34816e-05
R2975 2479 2480 1.744 0.8 13.952 37
I2480 0 2480 1.23684e-05
R2976 2480 0 0.1 49.28 49.28 37
*seg: 249
R2977 0 2481 0.1 49.28 49.28 37
R2978 2485 2495 6.16 0.8 49.28 37
I2481 0 2481 1.33579e-05
R2979 2481 2482 1.744 0.8 13.952 37
I2482 0 2482 1.23684e-05
R2980 2482 2483 1.728 0.8 13.824 37
I2483 0 2483 1.23684e-05
R2981 2483 2484 1.712 0.8 13.696 37
I2484 0 2484 1.34816e-05
R2982 2484 2485 1.696 0.8 13.568 37
I2485 0 2485 1.33579e-05
R2983 2485 2486 1.664 0.8 13.312 37
I2486 0 2486 1.28631e-05
R2984 2486 2487 1.696 0.8 13.568 37
I2487 0 2487 1.32342e-05
R2985 2487 2488 1.616 0.8 12.928 37
I2488 0 2488 1.23684e-05
R2986 2488 2489 1.664 0.8 13.312 37
I2489 0 2489 1.33579e-05
R2987 2489 2490 1.728 0.8 13.824 37
I2490 0 2490 1.23684e-05
R2988 2490 0 0.1 49.28 49.28 37
*seg: 250
R2989 0 2491 0.1 49.28 49.28 37
R2990 2495 2505 6.16 0.8 49.28 37
I2491 0 2491 1.27395e-05
R2991 2491 2492 1.6 0.8 12.8 37
I2492 0 2492 1.29868e-05
R2992 2492 2493 1.6 0.8 12.8 37
I2493 0 2493 1.27395e-05
R2993 2493 2494 1.68 0.8 13.44 37
I2494 0 2494 1.26158e-05
R2994 2494 2495 1.664 0.8 13.312 37
I2495 0 2495 1.28631e-05
R2995 2495 2496 1.744 0.8 13.952 37
I2496 0 2496 1.33579e-05
R2996 2496 2497 1.664 0.8 13.312 37
I2497 0 2497 1.23684e-05
R2997 2497 2498 1.648 0.8 13.184 37
I2498 0 2498 1.29868e-05
R2998 2498 2499 1.744 0.8 13.952 37
I2499 0 2499 1.34816e-05
R2999 2499 2500 1.616 0.8 12.928 37
I2500 0 2500 1.23684e-05
R3000 2500 0 0.1 49.28 49.28 37
*seg: 251
R3001 0 2501 0.1 49.28 49.28 37
R3002 2505 2515 6.16 0.8 49.28 37
I2501 0 2501 1.27395e-05
R3003 2501 2502 1.712 0.8 13.696 37
I2502 0 2502 1.28631e-05
R3004 2502 2503 1.68 0.8 13.44 37
I2503 0 2503 1.33579e-05
R3005 2503 2504 1.68 0.8 13.44 37
I2504 0 2504 1.29868e-05
R3006 2504 2505 1.728 0.8 13.824 37
I2505 0 2505 1.32342e-05
R3007 2505 2506 1.696 0.8 13.568 37
I2506 0 2506 1.34816e-05
R3008 2506 2507 1.712 0.8 13.696 37
I2507 0 2507 1.32342e-05
R3009 2507 2508 1.68 0.8 13.44 37
I2508 0 2508 1.34816e-05
R3010 2508 2509 1.712 0.8 13.696 37
I2509 0 2509 1.29868e-05
R3011 2509 2510 1.68 0.8 13.44 37
I2510 0 2510 1.23684e-05
R3012 2510 0 0.1 49.28 49.28 37
*seg: 252
R3013 0 2511 0.1 49.28 49.28 37
R3014 2515 2525 6.16 0.8 49.28 37
I2511 0 2511 1.34816e-05
R3015 2511 2512 1.616 0.8 12.928 37
I2512 0 2512 1.23684e-05
R3016 2512 2513 1.712 0.8 13.696 37
I2513 0 2513 1.24921e-05
R3017 2513 2514 1.616 0.8 12.928 37
I2514 0 2514 1.23684e-05
R3018 2514 2515 1.68 0.8 13.44 37
I2515 0 2515 1.23684e-05
R3019 2515 2516 1.744 0.8 13.952 37
I2516 0 2516 1.28631e-05
R3020 2516 2517 1.728 0.8 13.824 37
I2517 0 2517 1.24921e-05
R3021 2517 2518 1.696 0.8 13.568 37
I2518 0 2518 1.27395e-05
R3022 2518 2519 1.648 0.8 13.184 37
I2519 0 2519 1.29868e-05
R3023 2519 2520 1.68 0.8 13.44 37
I2520 0 2520 1.23684e-05
R3024 2520 0 0.1 49.28 49.28 37
*seg: 253
R3025 0 2521 0.1 49.28 49.28 37
R3026 2525 2535 6.16 0.8 49.28 37
I2521 0 2521 1.23684e-05
R3027 2521 2522 1.632 0.8 13.056 37
I2522 0 2522 1.27395e-05
R3028 2522 2523 1.712 0.8 13.696 37
I2523 0 2523 1.29868e-05
R3029 2523 2524 1.712 0.8 13.696 37
I2524 0 2524 1.24921e-05
R3030 2524 2525 1.6 0.8 12.8 37
I2525 0 2525 1.27395e-05
R3031 2525 2526 1.68 0.8 13.44 37
I2526 0 2526 1.28631e-05
R3032 2526 2527 1.632 0.8 13.056 37
I2527 0 2527 1.29868e-05
R3033 2527 2528 1.648 0.8 13.184 37
I2528 0 2528 1.24921e-05
R3034 2528 2529 1.744 0.8 13.952 37
I2529 0 2529 1.28631e-05
R3035 2529 2530 1.68 0.8 13.44 37
I2530 0 2530 1.23684e-05
R3036 2530 0 0.1 49.28 49.28 37
*seg: 254
R3037 0 2531 0.1 49.28 49.28 37
R3038 2535 2545 6.16 0.8 49.28 37
I2531 0 2531 1.34816e-05
R3039 2531 2532 1.664 0.8 13.312 37
I2532 0 2532 1.34816e-05
R3040 2532 2533 1.648 0.8 13.184 37
I2533 0 2533 1.32342e-05
R3041 2533 2534 1.712 0.8 13.696 37
I2534 0 2534 1.24921e-05
R3042 2534 2535 1.712 0.8 13.696 37
I2535 0 2535 1.33579e-05
R3043 2535 2536 1.616 0.8 12.928 37
I2536 0 2536 1.28631e-05
R3044 2536 2537 1.648 0.8 13.184 37
I2537 0 2537 1.32342e-05
R3045 2537 2538 1.616 0.8 12.928 37
I2538 0 2538 1.23684e-05
R3046 2538 2539 1.6 0.8 12.8 37
I2539 0 2539 1.34816e-05
R3047 2539 2540 1.6 0.8 12.8 37
I2540 0 2540 1.23684e-05
R3048 2540 0 0.1 49.28 49.28 37
*seg: 255
R3049 0 2541 0.1 49.28 49.28 37
R3050 2545 2555 6.16 0.8 49.28 37
I2541 0 2541 1.27395e-05
R3051 2541 2542 1.712 0.8 13.696 37
I2542 0 2542 1.24921e-05
R3052 2542 2543 1.648 0.8 13.184 37
I2543 0 2543 1.24921e-05
R3053 2543 2544 1.68 0.8 13.44 37
I2544 0 2544 1.27395e-05
R3054 2544 2545 1.616 0.8 12.928 37
I2545 0 2545 1.34816e-05
R3055 2545 2546 1.728 0.8 13.824 37
I2546 0 2546 1.27395e-05
R3056 2546 2547 1.744 0.8 13.952 37
I2547 0 2547 1.31105e-05
R3057 2547 2548 1.616 0.8 12.928 37
I2548 0 2548 1.33579e-05
R3058 2548 2549 1.696 0.8 13.568 37
I2549 0 2549 1.32342e-05
R3059 2549 2550 1.712 0.8 13.696 37
I2550 0 2550 1.23684e-05
R3060 2550 0 0.1 49.28 49.28 37
*seg: 256
R3061 0 2551 0.1 49.28 49.28 37
R3062 2555 2565 6.16 0.8 49.28 37
I2551 0 2551 1.29868e-05
R3063 2551 2552 1.728 0.8 13.824 37
I2552 0 2552 1.27395e-05
R3064 2552 2553 1.696 0.8 13.568 37
I2553 0 2553 1.34816e-05
R3065 2553 2554 1.6 0.8 12.8 37
I2554 0 2554 1.33579e-05
R3066 2554 2555 1.68 0.8 13.44 37
I2555 0 2555 1.29868e-05
R3067 2555 2556 1.744 0.8 13.952 37
I2556 0 2556 1.33579e-05
R3068 2556 2557 1.664 0.8 13.312 37
I2557 0 2557 1.23684e-05
R3069 2557 2558 1.696 0.8 13.568 37
I2558 0 2558 1.24921e-05
R3070 2558 2559 1.632 0.8 13.056 37
I2559 0 2559 1.31105e-05
R3071 2559 2560 1.712 0.8 13.696 37
I2560 0 2560 1.23684e-05
R3072 2560 0 0.1 49.28 49.28 37
*seg: 257
R3073 0 2561 0.1 49.28 49.28 37
R3074 2565 2575 6.16 0.8 49.28 37
I2561 0 2561 1.33579e-05
R3075 2561 2562 1.68 0.8 13.44 37
I2562 0 2562 1.26158e-05
R3076 2562 2563 1.728 0.8 13.824 37
I2563 0 2563 1.28631e-05
R3077 2563 2564 1.648 0.8 13.184 37
I2564 0 2564 1.31105e-05
R3078 2564 2565 1.728 0.8 13.824 37
I2565 0 2565 1.32342e-05
R3079 2565 2566 1.744 0.8 13.952 37
I2566 0 2566 1.26158e-05
R3080 2566 2567 1.6 0.8 12.8 37
I2567 0 2567 1.34816e-05
R3081 2567 2568 1.632 0.8 13.056 37
I2568 0 2568 1.32342e-05
R3082 2568 2569 1.632 0.8 13.056 37
I2569 0 2569 1.24921e-05
R3083 2569 2570 1.696 0.8 13.568 37
I2570 0 2570 1.23684e-05
R3084 2570 0 0.1 49.28 49.28 37
*seg: 258
R3085 0 2571 0.1 49.28 49.28 37
R3086 2575 2585 6.16 0.8 49.28 37
I2571 0 2571 1.34816e-05
R3087 2571 2572 1.712 0.8 13.696 37
I2572 0 2572 1.31105e-05
R3088 2572 2573 1.632 0.8 13.056 37
I2573 0 2573 1.23684e-05
R3089 2573 2574 1.712 0.8 13.696 37
I2574 0 2574 1.27395e-05
R3090 2574 2575 1.744 0.8 13.952 37
I2575 0 2575 1.34816e-05
R3091 2575 2576 1.68 0.8 13.44 37
I2576 0 2576 1.31105e-05
R3092 2576 2577 1.744 0.8 13.952 37
I2577 0 2577 1.29868e-05
R3093 2577 2578 1.744 0.8 13.952 37
I2578 0 2578 1.24921e-05
R3094 2578 2579 1.728 0.8 13.824 37
I2579 0 2579 1.28631e-05
R3095 2579 2580 1.648 0.8 13.184 37
I2580 0 2580 1.23684e-05
R3096 2580 0 0.1 49.28 49.28 37
*seg: 259
R3097 0 2581 0.1 49.28 49.28 37
R3098 2585 2595 6.16 0.8 49.28 37
I2581 0 2581 1.28631e-05
R3099 2581 2582 1.6 0.8 12.8 37
I2582 0 2582 1.32342e-05
R3100 2582 2583 1.728 0.8 13.824 37
I2583 0 2583 1.34816e-05
R3101 2583 2584 1.728 0.8 13.824 37
I2584 0 2584 1.27395e-05
R3102 2584 2585 1.632 0.8 13.056 37
I2585 0 2585 1.32342e-05
R3103 2585 2586 1.712 0.8 13.696 37
I2586 0 2586 1.23684e-05
R3104 2586 2587 1.68 0.8 13.44 37
I2587 0 2587 1.32342e-05
R3105 2587 2588 1.632 0.8 13.056 37
I2588 0 2588 1.23684e-05
R3106 2588 2589 1.632 0.8 13.056 37
I2589 0 2589 1.28631e-05
R3107 2589 2590 1.68 0.8 13.44 37
I2590 0 2590 1.23684e-05
R3108 2590 0 0.1 49.28 49.28 37
*seg: 260
R3109 0 2591 0.1 49.28 49.28 37
R3110 2595 2605 6.16 0.8 49.28 37
I2591 0 2591 1.33579e-05
R3111 2591 2592 1.68 0.8 13.44 37
I2592 0 2592 1.34816e-05
R3112 2592 2593 1.728 0.8 13.824 37
I2593 0 2593 1.26158e-05
R3113 2593 2594 1.6 0.8 12.8 37
I2594 0 2594 1.28631e-05
R3114 2594 2595 1.616 0.8 12.928 37
I2595 0 2595 1.23684e-05
R3115 2595 2596 1.648 0.8 13.184 37
I2596 0 2596 1.26158e-05
R3116 2596 2597 1.632 0.8 13.056 37
I2597 0 2597 1.28631e-05
R3117 2597 2598 1.728 0.8 13.824 37
I2598 0 2598 1.32342e-05
R3118 2598 2599 1.648 0.8 13.184 37
I2599 0 2599 1.29868e-05
R3119 2599 2600 1.744 0.8 13.952 37
I2600 0 2600 1.23684e-05
R3120 2600 0 0.1 49.28 49.28 37
*seg: 261
R3121 0 2601 0.1 49.28 49.28 37
R3122 2605 2615 6.16 0.8 49.28 37
I2601 0 2601 1.26158e-05
R3123 2601 2602 1.696 0.8 13.568 37
I2602 0 2602 1.24921e-05
R3124 2602 2603 1.728 0.8 13.824 37
I2603 0 2603 1.27395e-05
R3125 2603 2604 1.616 0.8 12.928 37
I2604 0 2604 1.33579e-05
R3126 2604 2605 1.744 0.8 13.952 37
I2605 0 2605 1.27395e-05
R3127 2605 2606 1.648 0.8 13.184 37
I2606 0 2606 1.24921e-05
R3128 2606 2607 1.632 0.8 13.056 37
I2607 0 2607 1.28631e-05
R3129 2607 2608 1.648 0.8 13.184 37
I2608 0 2608 1.34816e-05
R3130 2608 2609 1.712 0.8 13.696 37
I2609 0 2609 1.33579e-05
R3131 2609 2610 1.728 0.8 13.824 37
I2610 0 2610 1.23684e-05
R3132 2610 0 0.1 49.28 49.28 37
*seg: 262
R3133 0 2611 0.1 49.28 49.28 37
R3134 2615 2625 6.16 0.8 49.28 37
I2611 0 2611 1.24921e-05
R3135 2611 2612 1.648 0.8 13.184 37
I2612 0 2612 1.31105e-05
R3136 2612 2613 1.648 0.8 13.184 37
I2613 0 2613 1.34816e-05
R3137 2613 2614 1.744 0.8 13.952 37
I2614 0 2614 1.27395e-05
R3138 2614 2615 1.664 0.8 13.312 37
I2615 0 2615 1.28631e-05
R3139 2615 2616 1.744 0.8 13.952 37
I2616 0 2616 1.27395e-05
R3140 2616 2617 1.696 0.8 13.568 37
I2617 0 2617 1.33579e-05
R3141 2617 2618 1.712 0.8 13.696 37
I2618 0 2618 1.24921e-05
R3142 2618 2619 1.616 0.8 12.928 37
I2619 0 2619 1.23684e-05
R3143 2619 2620 1.728 0.8 13.824 37
I2620 0 2620 1.23684e-05
R3144 2620 0 0.1 49.28 49.28 37
*seg: 263
R3145 0 2621 0.1 49.28 49.28 37
R3146 2625 2635 6.16 0.8 49.28 37
I2621 0 2621 1.31105e-05
R3147 2621 2622 1.6 0.8 12.8 37
I2622 0 2622 1.28631e-05
R3148 2622 2623 1.632 0.8 13.056 37
I2623 0 2623 1.32342e-05
R3149 2623 2624 1.6 0.8 12.8 37
I2624 0 2624 1.29868e-05
R3150 2624 2625 1.712 0.8 13.696 37
I2625 0 2625 1.34816e-05
R3151 2625 2626 1.68 0.8 13.44 37
I2626 0 2626 1.23684e-05
R3152 2626 2627 1.744 0.8 13.952 37
I2627 0 2627 1.24921e-05
R3153 2627 2628 1.632 0.8 13.056 37
I2628 0 2628 1.24921e-05
R3154 2628 2629 1.664 0.8 13.312 37
I2629 0 2629 1.33579e-05
R3155 2629 2630 1.664 0.8 13.312 37
I2630 0 2630 1.23684e-05
R3156 2630 0 0.1 49.28 49.28 37
*seg: 264
R3157 0 2631 0.1 49.28 49.28 37
R3158 2635 2645 6.16 0.8 49.28 37
I2631 0 2631 1.26158e-05
R3159 2631 2632 1.616 0.8 12.928 37
I2632 0 2632 1.33579e-05
R3160 2632 2633 1.6 0.8 12.8 37
I2633 0 2633 1.34816e-05
R3161 2633 2634 1.712 0.8 13.696 37
I2634 0 2634 1.24921e-05
R3162 2634 2635 1.728 0.8 13.824 37
I2635 0 2635 1.28631e-05
R3163 2635 2636 1.6 0.8 12.8 37
I2636 0 2636 1.33579e-05
R3164 2636 2637 1.744 0.8 13.952 37
I2637 0 2637 1.23684e-05
R3165 2637 2638 1.696 0.8 13.568 37
I2638 0 2638 1.31105e-05
R3166 2638 2639 1.648 0.8 13.184 37
I2639 0 2639 1.27395e-05
R3167 2639 2640 1.696 0.8 13.568 37
I2640 0 2640 1.23684e-05
R3168 2640 0 0.1 49.28 49.28 37
*seg: 265
R3169 0 2641 0.1 49.28 49.28 37
R3170 2645 2655 6.16 0.8 49.28 37
I2641 0 2641 1.34816e-05
R3171 2641 2642 1.712 0.8 13.696 37
I2642 0 2642 1.26158e-05
R3172 2642 2643 1.696 0.8 13.568 37
I2643 0 2643 1.24921e-05
R3173 2643 2644 1.68 0.8 13.44 37
I2644 0 2644 1.33579e-05
R3174 2644 2645 1.744 0.8 13.952 37
I2645 0 2645 1.27395e-05
R3175 2645 2646 1.632 0.8 13.056 37
I2646 0 2646 1.29868e-05
R3176 2646 2647 1.616 0.8 12.928 37
I2647 0 2647 1.23684e-05
R3177 2647 2648 1.712 0.8 13.696 37
I2648 0 2648 1.29868e-05
R3178 2648 2649 1.744 0.8 13.952 37
I2649 0 2649 1.31105e-05
R3179 2649 2650 1.712 0.8 13.696 37
I2650 0 2650 1.23684e-05
R3180 2650 0 0.1 49.28 49.28 37
*seg: 266
R3181 0 2651 0.1 49.28 49.28 37
R3182 2655 2665 6.16 0.8 49.28 37
I2651 0 2651 1.28631e-05
R3183 2651 2652 1.632 0.8 13.056 37
I2652 0 2652 1.34816e-05
R3184 2652 2653 1.696 0.8 13.568 37
I2653 0 2653 1.33579e-05
R3185 2653 2654 1.696 0.8 13.568 37
I2654 0 2654 1.31105e-05
R3186 2654 2655 1.664 0.8 13.312 37
I2655 0 2655 1.33579e-05
R3187 2655 2656 1.696 0.8 13.568 37
I2656 0 2656 1.34816e-05
R3188 2656 2657 1.632 0.8 13.056 37
I2657 0 2657 1.32342e-05
R3189 2657 2658 1.616 0.8 12.928 37
I2658 0 2658 1.31105e-05
R3190 2658 2659 1.68 0.8 13.44 37
I2659 0 2659 1.28631e-05
R3191 2659 2660 1.6 0.8 12.8 37
I2660 0 2660 1.23684e-05
R3192 2660 0 0.1 49.28 49.28 37
*seg: 267
R3193 0 2661 0.1 49.28 49.28 37
R3194 2665 2675 6.16 0.8 49.28 37
I2661 0 2661 1.33579e-05
R3195 2661 2662 1.648 0.8 13.184 37
I2662 0 2662 1.33579e-05
R3196 2662 2663 1.728 0.8 13.824 37
I2663 0 2663 1.31105e-05
R3197 2663 2664 1.744 0.8 13.952 37
I2664 0 2664 1.29868e-05
R3198 2664 2665 1.696 0.8 13.568 37
I2665 0 2665 1.29868e-05
R3199 2665 2666 1.744 0.8 13.952 37
I2666 0 2666 1.33579e-05
R3200 2666 2667 1.664 0.8 13.312 37
I2667 0 2667 1.29868e-05
R3201 2667 2668 1.664 0.8 13.312 37
I2668 0 2668 1.34816e-05
R3202 2668 2669 1.728 0.8 13.824 37
I2669 0 2669 1.34816e-05
R3203 2669 2670 1.68 0.8 13.44 37
I2670 0 2670 1.23684e-05
R3204 2670 0 0.1 49.28 49.28 37
*seg: 268
R3205 0 2671 0.1 49.28 49.28 37
R3206 2675 2685 6.16 0.8 49.28 37
I2671 0 2671 1.34816e-05
R3207 2671 2672 1.696 0.8 13.568 37
I2672 0 2672 1.34816e-05
R3208 2672 2673 1.712 0.8 13.696 37
I2673 0 2673 1.34816e-05
R3209 2673 2674 1.696 0.8 13.568 37
I2674 0 2674 1.28631e-05
R3210 2674 2675 1.744 0.8 13.952 37
I2675 0 2675 1.34816e-05
R3211 2675 2676 1.632 0.8 13.056 37
I2676 0 2676 1.32342e-05
R3212 2676 2677 1.696 0.8 13.568 37
I2677 0 2677 1.32342e-05
R3213 2677 2678 1.648 0.8 13.184 37
I2678 0 2678 1.32342e-05
R3214 2678 2679 1.68 0.8 13.44 37
I2679 0 2679 1.26158e-05
R3215 2679 2680 1.648 0.8 13.184 37
I2680 0 2680 1.23684e-05
R3216 2680 0 0.1 49.28 49.28 37
*seg: 269
R3217 0 2681 0.1 49.28 49.28 37
R3218 2685 2695 6.16 0.8 49.28 37
I2681 0 2681 1.31105e-05
R3219 2681 2682 1.664 0.8 13.312 37
I2682 0 2682 1.28631e-05
R3220 2682 2683 1.696 0.8 13.568 37
I2683 0 2683 1.34816e-05
R3221 2683 2684 1.696 0.8 13.568 37
I2684 0 2684 1.34816e-05
R3222 2684 2685 1.696 0.8 13.568 37
I2685 0 2685 1.32342e-05
R3223 2685 2686 1.696 0.8 13.568 37
I2686 0 2686 1.29868e-05
R3224 2686 2687 1.616 0.8 12.928 37
I2687 0 2687 1.33579e-05
R3225 2687 2688 1.664 0.8 13.312 37
I2688 0 2688 1.29868e-05
R3226 2688 2689 1.6 0.8 12.8 37
I2689 0 2689 1.29868e-05
R3227 2689 2690 1.616 0.8 12.928 37
I2690 0 2690 1.23684e-05
R3228 2690 0 0.1 49.28 49.28 37
*seg: 270
R3229 0 2691 0.1 49.28 49.28 37
R3230 2695 2705 6.16 0.8 49.28 37
I2691 0 2691 1.23684e-05
R3231 2691 2692 1.6 0.8 12.8 37
I2692 0 2692 1.29868e-05
R3232 2692 2693 1.68 0.8 13.44 37
I2693 0 2693 1.28631e-05
R3233 2693 2694 1.744 0.8 13.952 37
I2694 0 2694 1.23684e-05
R3234 2694 2695 1.68 0.8 13.44 37
I2695 0 2695 1.34816e-05
R3235 2695 2696 1.648 0.8 13.184 37
I2696 0 2696 1.24921e-05
R3236 2696 2697 1.664 0.8 13.312 37
I2697 0 2697 1.26158e-05
R3237 2697 2698 1.664 0.8 13.312 37
I2698 0 2698 1.32342e-05
R3238 2698 2699 1.632 0.8 13.056 37
I2699 0 2699 1.32342e-05
R3239 2699 2700 1.744 0.8 13.952 37
I2700 0 2700 1.23684e-05
R3240 2700 0 0.1 49.28 49.28 37
*seg: 271
R3241 0 2701 0.1 49.28 49.28 37
R3242 2705 2715 6.16 0.8 49.28 37
I2701 0 2701 1.28631e-05
R3243 2701 2702 1.68 0.8 13.44 37
I2702 0 2702 1.31105e-05
R3244 2702 2703 1.68 0.8 13.44 37
I2703 0 2703 1.32342e-05
R3245 2703 2704 1.728 0.8 13.824 37
I2704 0 2704 1.26158e-05
R3246 2704 2705 1.616 0.8 12.928 37
I2705 0 2705 1.27395e-05
R3247 2705 2706 1.712 0.8 13.696 37
I2706 0 2706 1.34816e-05
R3248 2706 2707 1.616 0.8 12.928 37
I2707 0 2707 1.27395e-05
R3249 2707 2708 1.632 0.8 13.056 37
I2708 0 2708 1.27395e-05
R3250 2708 2709 1.68 0.8 13.44 37
I2709 0 2709 1.33579e-05
R3251 2709 2710 1.648 0.8 13.184 37
I2710 0 2710 1.23684e-05
R3252 2710 0 0.1 49.28 49.28 37
*seg: 272
R3253 0 2711 0.1 49.28 49.28 37
R3254 2715 2725 6.16 0.8 49.28 37
I2711 0 2711 1.26158e-05
R3255 2711 2712 1.616 0.8 12.928 37
I2712 0 2712 1.32342e-05
R3256 2712 2713 1.728 0.8 13.824 37
I2713 0 2713 1.23684e-05
R3257 2713 2714 1.6 0.8 12.8 37
I2714 0 2714 1.33579e-05
R3258 2714 2715 1.728 0.8 13.824 37
I2715 0 2715 1.31105e-05
R3259 2715 2716 1.696 0.8 13.568 37
I2716 0 2716 1.32342e-05
R3260 2716 2717 1.632 0.8 13.056 37
I2717 0 2717 1.23684e-05
R3261 2717 2718 1.6 0.8 12.8 37
I2718 0 2718 1.24921e-05
R3262 2718 2719 1.728 0.8 13.824 37
I2719 0 2719 1.29868e-05
R3263 2719 2720 1.6 0.8 12.8 37
I2720 0 2720 1.23684e-05
R3264 2720 0 0.1 49.28 49.28 37
*seg: 273
R3265 0 2721 0.1 49.28 49.28 37
R3266 2725 2735 6.16 0.8 49.28 37
I2721 0 2721 1.26158e-05
R3267 2721 2722 1.632 0.8 13.056 37
I2722 0 2722 1.24921e-05
R3268 2722 2723 1.6 0.8 12.8 37
I2723 0 2723 1.23684e-05
R3269 2723 2724 1.664 0.8 13.312 37
I2724 0 2724 1.33579e-05
R3270 2724 2725 1.6 0.8 12.8 37
I2725 0 2725 1.27395e-05
R3271 2725 2726 1.648 0.8 13.184 37
I2726 0 2726 1.31105e-05
R3272 2726 2727 1.616 0.8 12.928 37
I2727 0 2727 1.31105e-05
R3273 2727 2728 1.68 0.8 13.44 37
I2728 0 2728 1.31105e-05
R3274 2728 2729 1.744 0.8 13.952 37
I2729 0 2729 1.31105e-05
R3275 2729 2730 1.632 0.8 13.056 37
I2730 0 2730 1.23684e-05
R3276 2730 0 0.1 49.28 49.28 37
*seg: 274
R3277 0 2731 0.1 49.28 49.28 37
R3278 2735 2745 6.16 0.8 49.28 37
I2731 0 2731 1.31105e-05
R3279 2731 2732 1.632 0.8 13.056 37
I2732 0 2732 1.23684e-05
R3280 2732 2733 1.68 0.8 13.44 37
I2733 0 2733 1.34816e-05
R3281 2733 2734 1.712 0.8 13.696 37
I2734 0 2734 1.33579e-05
R3282 2734 2735 1.664 0.8 13.312 37
I2735 0 2735 1.26158e-05
R3283 2735 2736 1.6 0.8 12.8 37
I2736 0 2736 1.31105e-05
R3284 2736 2737 1.728 0.8 13.824 37
I2737 0 2737 1.27395e-05
R3285 2737 2738 1.68 0.8 13.44 37
I2738 0 2738 1.28631e-05
R3286 2738 2739 1.68 0.8 13.44 37
I2739 0 2739 1.27395e-05
R3287 2739 2740 1.632 0.8 13.056 37
I2740 0 2740 1.23684e-05
R3288 2740 0 0.1 49.28 49.28 37
*seg: 275
R3289 0 2741 0.1 49.28 49.28 37
R3290 2745 2755 6.16 0.8 49.28 37
I2741 0 2741 1.24921e-05
R3291 2741 2742 1.6 0.8 12.8 37
I2742 0 2742 1.33579e-05
R3292 2742 2743 1.68 0.8 13.44 37
I2743 0 2743 1.24921e-05
R3293 2743 2744 1.696 0.8 13.568 37
I2744 0 2744 1.33579e-05
R3294 2744 2745 1.712 0.8 13.696 37
I2745 0 2745 1.24921e-05
R3295 2745 2746 1.648 0.8 13.184 37
I2746 0 2746 1.34816e-05
R3296 2746 2747 1.68 0.8 13.44 37
I2747 0 2747 1.23684e-05
R3297 2747 2748 1.728 0.8 13.824 37
I2748 0 2748 1.29868e-05
R3298 2748 2749 1.6 0.8 12.8 37
I2749 0 2749 1.34816e-05
R3299 2749 2750 1.68 0.8 13.44 37
I2750 0 2750 1.23684e-05
R3300 2750 0 0.1 49.28 49.28 37
*seg: 276
R3301 0 2751 0.1 49.28 49.28 37
R3302 2755 2765 6.16 0.8 49.28 37
I2751 0 2751 1.33579e-05
R3303 2751 2752 1.648 0.8 13.184 37
I2752 0 2752 1.33579e-05
R3304 2752 2753 1.68 0.8 13.44 37
I2753 0 2753 1.33579e-05
R3305 2753 2754 1.744 0.8 13.952 37
I2754 0 2754 1.29868e-05
R3306 2754 2755 1.68 0.8 13.44 37
I2755 0 2755 1.32342e-05
R3307 2755 2756 1.6 0.8 12.8 37
I2756 0 2756 1.34816e-05
R3308 2756 2757 1.6 0.8 12.8 37
I2757 0 2757 1.28631e-05
R3309 2757 2758 1.632 0.8 13.056 37
I2758 0 2758 1.29868e-05
R3310 2758 2759 1.68 0.8 13.44 37
I2759 0 2759 1.26158e-05
R3311 2759 2760 1.696 0.8 13.568 37
I2760 0 2760 1.23684e-05
R3312 2760 0 0.1 49.28 49.28 37
*seg: 277
R3313 0 2761 0.1 49.28 49.28 37
R3314 2765 2775 6.16 0.8 49.28 37
I2761 0 2761 1.34816e-05
R3315 2761 2762 1.712 0.8 13.696 37
I2762 0 2762 1.31105e-05
R3316 2762 2763 1.6 0.8 12.8 37
I2763 0 2763 1.28631e-05
R3317 2763 2764 1.696 0.8 13.568 37
I2764 0 2764 1.34816e-05
R3318 2764 2765 1.616 0.8 12.928 37
I2765 0 2765 1.23684e-05
R3319 2765 2766 1.6 0.8 12.8 37
I2766 0 2766 1.27395e-05
R3320 2766 2767 1.744 0.8 13.952 37
I2767 0 2767 1.32342e-05
R3321 2767 2768 1.616 0.8 12.928 37
I2768 0 2768 1.31105e-05
R3322 2768 2769 1.632 0.8 13.056 37
I2769 0 2769 1.29868e-05
R3323 2769 2770 1.68 0.8 13.44 37
I2770 0 2770 1.23684e-05
R3324 2770 0 0.1 49.28 49.28 37
*seg: 278
R3325 0 2771 0.1 49.28 49.28 37
R3326 2775 2785 6.16 0.8 49.28 37
I2771 0 2771 1.26158e-05
R3327 2771 2772 1.68 0.8 13.44 37
I2772 0 2772 1.32342e-05
R3328 2772 2773 1.712 0.8 13.696 37
I2773 0 2773 1.28631e-05
R3329 2773 2774 1.616 0.8 12.928 37
I2774 0 2774 1.33579e-05
R3330 2774 2775 1.6 0.8 12.8 37
I2775 0 2775 1.34816e-05
R3331 2775 2776 1.648 0.8 13.184 37
I2776 0 2776 1.33579e-05
R3332 2776 2777 1.6 0.8 12.8 37
I2777 0 2777 1.24921e-05
R3333 2777 2778 1.616 0.8 12.928 37
I2778 0 2778 1.26158e-05
R3334 2778 2779 1.696 0.8 13.568 37
I2779 0 2779 1.27395e-05
R3335 2779 2780 1.68 0.8 13.44 37
I2780 0 2780 1.23684e-05
R3336 2780 0 0.1 49.28 49.28 37
*seg: 279
R3337 0 2781 0.1 49.28 49.28 37
R3338 2785 2795 6.16 0.8 49.28 37
I2781 0 2781 1.24921e-05
R3339 2781 2782 1.664 0.8 13.312 37
I2782 0 2782 1.24921e-05
R3340 2782 2783 1.6 0.8 12.8 37
I2783 0 2783 1.31105e-05
R3341 2783 2784 1.712 0.8 13.696 37
I2784 0 2784 1.33579e-05
R3342 2784 2785 1.712 0.8 13.696 37
I2785 0 2785 1.27395e-05
R3343 2785 2786 1.648 0.8 13.184 37
I2786 0 2786 1.23684e-05
R3344 2786 2787 1.632 0.8 13.056 37
I2787 0 2787 1.29868e-05
R3345 2787 2788 1.68 0.8 13.44 37
I2788 0 2788 1.29868e-05
R3346 2788 2789 1.632 0.8 13.056 37
I2789 0 2789 1.23684e-05
R3347 2789 2790 1.664 0.8 13.312 37
I2790 0 2790 1.23684e-05
R3348 2790 0 0.1 49.28 49.28 37
*seg: 280
R3349 0 2791 0.1 49.28 49.28 37
R3350 2795 2805 6.16 0.8 49.28 37
I2791 0 2791 1.23684e-05
R3351 2791 2792 1.648 0.8 13.184 37
I2792 0 2792 1.29868e-05
R3352 2792 2793 1.616 0.8 12.928 37
I2793 0 2793 1.28631e-05
R3353 2793 2794 1.68 0.8 13.44 37
I2794 0 2794 1.28631e-05
R3354 2794 2795 1.632 0.8 13.056 37
I2795 0 2795 1.27395e-05
R3355 2795 2796 1.664 0.8 13.312 37
I2796 0 2796 1.27395e-05
R3356 2796 2797 1.648 0.8 13.184 37
I2797 0 2797 1.27395e-05
R3357 2797 2798 1.648 0.8 13.184 37
I2798 0 2798 1.23684e-05
R3358 2798 2799 1.632 0.8 13.056 37
I2799 0 2799 1.32342e-05
R3359 2799 2800 1.712 0.8 13.696 37
I2800 0 2800 1.23684e-05
R3360 2800 0 0.1 49.28 49.28 37
*seg: 281
R3361 0 2801 0.1 49.28 49.28 37
R3362 2805 2815 6.16 0.8 49.28 37
I2801 0 2801 1.28631e-05
R3363 2801 2802 1.616 0.8 12.928 37
I2802 0 2802 1.28631e-05
R3364 2802 2803 1.616 0.8 12.928 37
I2803 0 2803 1.31105e-05
R3365 2803 2804 1.664 0.8 13.312 37
I2804 0 2804 1.26158e-05
R3366 2804 2805 1.6 0.8 12.8 37
I2805 0 2805 1.31105e-05
R3367 2805 2806 1.616 0.8 12.928 37
I2806 0 2806 1.33579e-05
R3368 2806 2807 1.6 0.8 12.8 37
I2807 0 2807 1.27395e-05
R3369 2807 2808 1.616 0.8 12.928 37
I2808 0 2808 1.23684e-05
R3370 2808 2809 1.632 0.8 13.056 37
I2809 0 2809 1.33579e-05
R3371 2809 2810 1.712 0.8 13.696 37
I2810 0 2810 1.23684e-05
R3372 2810 0 0.1 49.28 49.28 37
*seg: 282
R3373 0 2811 0.1 49.28 49.28 37
R3374 2815 2825 6.16 0.8 49.28 37
I2811 0 2811 1.26158e-05
R3375 2811 2812 1.648 0.8 13.184 37
I2812 0 2812 1.26158e-05
R3376 2812 2813 1.6 0.8 12.8 37
I2813 0 2813 1.32342e-05
R3377 2813 2814 1.728 0.8 13.824 37
I2814 0 2814 1.23684e-05
R3378 2814 2815 1.744 0.8 13.952 37
I2815 0 2815 1.29868e-05
R3379 2815 2816 1.664 0.8 13.312 37
I2816 0 2816 1.23684e-05
R3380 2816 2817 1.712 0.8 13.696 37
I2817 0 2817 1.23684e-05
R3381 2817 2818 1.696 0.8 13.568 37
I2818 0 2818 1.28631e-05
R3382 2818 2819 1.648 0.8 13.184 37
I2819 0 2819 1.24921e-05
R3383 2819 2820 1.616 0.8 12.928 37
I2820 0 2820 1.23684e-05
R3384 2820 0 0.1 49.28 49.28 37
*seg: 283
R3385 0 2821 0.1 49.28 49.28 37
R3386 2825 2835 6.16 0.8 49.28 37
I2821 0 2821 1.31105e-05
R3387 2821 2822 1.632 0.8 13.056 37
I2822 0 2822 1.33579e-05
R3388 2822 2823 1.6 0.8 12.8 37
I2823 0 2823 1.34816e-05
R3389 2823 2824 1.632 0.8 13.056 37
I2824 0 2824 1.34816e-05
R3390 2824 2825 1.696 0.8 13.568 37
I2825 0 2825 1.31105e-05
R3391 2825 2826 1.632 0.8 13.056 37
I2826 0 2826 1.23684e-05
R3392 2826 2827 1.728 0.8 13.824 37
I2827 0 2827 1.29868e-05
R3393 2827 2828 1.632 0.8 13.056 37
I2828 0 2828 1.26158e-05
R3394 2828 2829 1.648 0.8 13.184 37
I2829 0 2829 1.28631e-05
R3395 2829 2830 1.68 0.8 13.44 37
I2830 0 2830 1.23684e-05
R3396 2830 0 0.1 49.28 49.28 37
*seg: 284
R3397 0 2831 0.1 49.28 49.28 37
R3398 2835 2845 6.16 0.8 49.28 37
I2831 0 2831 1.28631e-05
R3399 2831 2832 1.68 0.8 13.44 37
I2832 0 2832 1.27395e-05
R3400 2832 2833 1.728 0.8 13.824 37
I2833 0 2833 1.33579e-05
R3401 2833 2834 1.712 0.8 13.696 37
I2834 0 2834 1.34816e-05
R3402 2834 2835 1.6 0.8 12.8 37
I2835 0 2835 1.34816e-05
R3403 2835 2836 1.664 0.8 13.312 37
I2836 0 2836 1.34816e-05
R3404 2836 2837 1.648 0.8 13.184 37
I2837 0 2837 1.28631e-05
R3405 2837 2838 1.712 0.8 13.696 37
I2838 0 2838 1.32342e-05
R3406 2838 2839 1.632 0.8 13.056 37
I2839 0 2839 1.26158e-05
R3407 2839 2840 1.648 0.8 13.184 37
I2840 0 2840 1.23684e-05
R3408 2840 0 0.1 49.28 49.28 37
*seg: 285
R3409 0 2841 0.1 49.28 49.28 37
R3410 2845 2855 6.16 0.8 49.28 37
I2841 0 2841 1.34816e-05
R3411 2841 2842 1.744 0.8 13.952 37
I2842 0 2842 1.23684e-05
R3412 2842 2843 1.6 0.8 12.8 37
I2843 0 2843 1.24921e-05
R3413 2843 2844 1.744 0.8 13.952 37
I2844 0 2844 1.28631e-05
R3414 2844 2845 1.728 0.8 13.824 37
I2845 0 2845 1.32342e-05
R3415 2845 2846 1.632 0.8 13.056 37
I2846 0 2846 1.31105e-05
R3416 2846 2847 1.744 0.8 13.952 37
I2847 0 2847 1.28631e-05
R3417 2847 2848 1.712 0.8 13.696 37
I2848 0 2848 1.26158e-05
R3418 2848 2849 1.712 0.8 13.696 37
I2849 0 2849 1.29868e-05
R3419 2849 2850 1.632 0.8 13.056 37
I2850 0 2850 1.23684e-05
R3420 2850 0 0.1 49.28 49.28 37
*seg: 286
R3421 0 2851 0.1 49.28 49.28 37
R3422 2855 2865 6.16 0.8 49.28 37
I2851 0 2851 1.33579e-05
R3423 2851 2852 1.648 0.8 13.184 37
I2852 0 2852 1.33579e-05
R3424 2852 2853 1.664 0.8 13.312 37
I2853 0 2853 1.33579e-05
R3425 2853 2854 1.712 0.8 13.696 37
I2854 0 2854 1.29868e-05
R3426 2854 2855 1.664 0.8 13.312 37
I2855 0 2855 1.26158e-05
R3427 2855 2856 1.616 0.8 12.928 37
I2856 0 2856 1.31105e-05
R3428 2856 2857 1.712 0.8 13.696 37
I2857 0 2857 1.33579e-05
R3429 2857 2858 1.6 0.8 12.8 37
I2858 0 2858 1.33579e-05
R3430 2858 2859 1.616 0.8 12.928 37
I2859 0 2859 1.33579e-05
R3431 2859 2860 1.616 0.8 12.928 37
I2860 0 2860 1.23684e-05
R3432 2860 0 0.1 49.28 49.28 37
*seg: 287
R3433 0 2861 0.1 49.28 49.28 37
R3434 2865 2875 6.16 0.8 49.28 37
I2861 0 2861 1.27395e-05
R3435 2861 2862 1.632 0.8 13.056 37
I2862 0 2862 1.33579e-05
R3436 2862 2863 1.664 0.8 13.312 37
I2863 0 2863 1.24921e-05
R3437 2863 2864 1.632 0.8 13.056 37
I2864 0 2864 1.24921e-05
R3438 2864 2865 1.744 0.8 13.952 37
I2865 0 2865 1.34816e-05
R3439 2865 2866 1.616 0.8 12.928 37
I2866 0 2866 1.34816e-05
R3440 2866 2867 1.712 0.8 13.696 37
I2867 0 2867 1.31105e-05
R3441 2867 2868 1.616 0.8 12.928 37
I2868 0 2868 1.23684e-05
R3442 2868 2869 1.728 0.8 13.824 37
I2869 0 2869 1.27395e-05
R3443 2869 2870 1.6 0.8 12.8 37
I2870 0 2870 1.23684e-05
R3444 2870 0 0.1 49.28 49.28 37
*seg: 288
R3445 0 2871 0.1 49.28 49.28 37
R3446 2875 2885 6.16 0.8 49.28 37
I2871 0 2871 1.23684e-05
R3447 2871 2872 1.68 0.8 13.44 37
I2872 0 2872 1.33579e-05
R3448 2872 2873 1.712 0.8 13.696 37
I2873 0 2873 1.34816e-05
R3449 2873 2874 1.68 0.8 13.44 37
I2874 0 2874 1.29868e-05
R3450 2874 2875 1.728 0.8 13.824 37
I2875 0 2875 1.32342e-05
R3451 2875 2876 1.68 0.8 13.44 37
I2876 0 2876 1.33579e-05
R3452 2876 2877 1.712 0.8 13.696 37
I2877 0 2877 1.28631e-05
R3453 2877 2878 1.648 0.8 13.184 37
I2878 0 2878 1.31105e-05
R3454 2878 2879 1.696 0.8 13.568 37
I2879 0 2879 1.29868e-05
R3455 2879 2880 1.696 0.8 13.568 37
I2880 0 2880 1.23684e-05
R3456 2880 0 0.1 49.28 49.28 37
*seg: 289
R3457 0 2881 0.1 49.28 49.28 37
R3458 2885 2895 6.16 0.8 49.28 37
I2881 0 2881 1.32342e-05
R3459 2881 2882 1.696 0.8 13.568 37
I2882 0 2882 1.33579e-05
R3460 2882 2883 1.6 0.8 12.8 37
I2883 0 2883 1.29868e-05
R3461 2883 2884 1.68 0.8 13.44 37
I2884 0 2884 1.26158e-05
R3462 2884 2885 1.648 0.8 13.184 37
I2885 0 2885 1.28631e-05
R3463 2885 2886 1.696 0.8 13.568 37
I2886 0 2886 1.28631e-05
R3464 2886 2887 1.744 0.8 13.952 37
I2887 0 2887 1.26158e-05
R3465 2887 2888 1.712 0.8 13.696 37
I2888 0 2888 1.29868e-05
R3466 2888 2889 1.696 0.8 13.568 37
I2889 0 2889 1.34816e-05
R3467 2889 2890 1.68 0.8 13.44 37
I2890 0 2890 1.23684e-05
R3468 2890 0 0.1 49.28 49.28 37
*seg: 290
R3469 0 2891 0.1 49.28 49.28 37
R3470 2895 2905 6.16 0.8 49.28 37
I2891 0 2891 1.28631e-05
R3471 2891 2892 1.632 0.8 13.056 37
I2892 0 2892 1.23684e-05
R3472 2892 2893 1.664 0.8 13.312 37
I2893 0 2893 1.28631e-05
R3473 2893 2894 1.632 0.8 13.056 37
I2894 0 2894 1.28631e-05
R3474 2894 2895 1.712 0.8 13.696 37
I2895 0 2895 1.32342e-05
R3475 2895 2896 1.68 0.8 13.44 37
I2896 0 2896 1.31105e-05
R3476 2896 2897 1.648 0.8 13.184 37
I2897 0 2897 1.24921e-05
R3477 2897 2898 1.6 0.8 12.8 37
I2898 0 2898 1.32342e-05
R3478 2898 2899 1.712 0.8 13.696 37
I2899 0 2899 1.27395e-05
R3479 2899 2900 1.632 0.8 13.056 37
I2900 0 2900 1.23684e-05
R3480 2900 0 0.1 49.28 49.28 37
*seg: 291
R3481 0 2901 0.1 49.28 49.28 37
R3482 2905 2915 6.16 0.8 49.28 37
I2901 0 2901 1.34816e-05
R3483 2901 2902 1.6 0.8 12.8 37
I2902 0 2902 1.26158e-05
R3484 2902 2903 1.68 0.8 13.44 37
I2903 0 2903 1.23684e-05
R3485 2903 2904 1.6 0.8 12.8 37
I2904 0 2904 1.28631e-05
R3486 2904 2905 1.664 0.8 13.312 37
I2905 0 2905 1.33579e-05
R3487 2905 2906 1.616 0.8 12.928 37
I2906 0 2906 1.31105e-05
R3488 2906 2907 1.6 0.8 12.8 37
I2907 0 2907 1.28631e-05
R3489 2907 2908 1.68 0.8 13.44 37
I2908 0 2908 1.26158e-05
R3490 2908 2909 1.728 0.8 13.824 37
I2909 0 2909 1.23684e-05
R3491 2909 2910 1.664 0.8 13.312 37
I2910 0 2910 1.23684e-05
R3492 2910 0 0.1 49.28 49.28 37
*seg: 292
R3493 0 2911 0.1 49.28 49.28 37
R3494 2915 2925 6.16 0.8 49.28 37
I2911 0 2911 1.24921e-05
R3495 2911 2912 1.712 0.8 13.696 37
I2912 0 2912 1.26158e-05
R3496 2912 2913 1.632 0.8 13.056 37
I2913 0 2913 1.28631e-05
R3497 2913 2914 1.616 0.8 12.928 37
I2914 0 2914 1.33579e-05
R3498 2914 2915 1.648 0.8 13.184 37
I2915 0 2915 1.23684e-05
R3499 2915 2916 1.6 0.8 12.8 37
I2916 0 2916 1.32342e-05
R3500 2916 2917 1.664 0.8 13.312 37
I2917 0 2917 1.34816e-05
R3501 2917 2918 1.664 0.8 13.312 37
I2918 0 2918 1.32342e-05
R3502 2918 2919 1.728 0.8 13.824 37
I2919 0 2919 1.26158e-05
R3503 2919 2920 1.616 0.8 12.928 37
I2920 0 2920 1.23684e-05
R3504 2920 0 0.1 49.28 49.28 37
*seg: 293
R3505 0 2921 0.1 49.28 49.28 37
R3506 2925 2935 6.16 0.8 49.28 37
I2921 0 2921 1.26158e-05
R3507 2921 2922 1.696 0.8 13.568 37
I2922 0 2922 1.32342e-05
R3508 2922 2923 1.648 0.8 13.184 37
I2923 0 2923 1.32342e-05
R3509 2923 2924 1.712 0.8 13.696 37
I2924 0 2924 1.33579e-05
R3510 2924 2925 1.712 0.8 13.696 37
I2925 0 2925 1.31105e-05
R3511 2925 2926 1.68 0.8 13.44 37
I2926 0 2926 1.27395e-05
R3512 2926 2927 1.664 0.8 13.312 37
I2927 0 2927 1.34816e-05
R3513 2927 2928 1.68 0.8 13.44 37
I2928 0 2928 1.26158e-05
R3514 2928 2929 1.664 0.8 13.312 37
I2929 0 2929 1.28631e-05
R3515 2929 2930 1.728 0.8 13.824 37
I2930 0 2930 1.23684e-05
R3516 2930 0 0.1 49.28 49.28 37
*seg: 294
R3517 0 2931 0.1 49.28 49.28 37
R3518 2935 2945 6.16 0.8 49.28 37
I2931 0 2931 1.29868e-05
R3519 2931 2932 1.68 0.8 13.44 37
I2932 0 2932 1.34816e-05
R3520 2932 2933 1.6 0.8 12.8 37
I2933 0 2933 1.27395e-05
R3521 2933 2934 1.6 0.8 12.8 37
I2934 0 2934 1.31105e-05
R3522 2934 2935 1.6 0.8 12.8 37
I2935 0 2935 1.34816e-05
R3523 2935 2936 1.712 0.8 13.696 37
I2936 0 2936 1.34816e-05
R3524 2936 2937 1.664 0.8 13.312 37
I2937 0 2937 1.31105e-05
R3525 2937 2938 1.664 0.8 13.312 37
I2938 0 2938 1.28631e-05
R3526 2938 2939 1.712 0.8 13.696 37
I2939 0 2939 1.29868e-05
R3527 2939 2940 1.616 0.8 12.928 37
I2940 0 2940 1.23684e-05
R3528 2940 0 0.1 49.28 49.28 37
*seg: 295
R3529 0 2941 0.1 49.28 49.28 37
R3530 2945 2955 6.16 0.8 49.28 37
I2941 0 2941 1.24921e-05
R3531 2941 2942 1.648 0.8 13.184 37
I2942 0 2942 1.34816e-05
R3532 2942 2943 1.616 0.8 12.928 37
I2943 0 2943 1.26158e-05
R3533 2943 2944 1.664 0.8 13.312 37
I2944 0 2944 1.28631e-05
R3534 2944 2945 1.744 0.8 13.952 37
I2945 0 2945 1.29868e-05
R3535 2945 2946 1.744 0.8 13.952 37
I2946 0 2946 1.29868e-05
R3536 2946 2947 1.632 0.8 13.056 37
I2947 0 2947 1.31105e-05
R3537 2947 2948 1.744 0.8 13.952 37
I2948 0 2948 1.23684e-05
R3538 2948 2949 1.664 0.8 13.312 37
I2949 0 2949 1.23684e-05
R3539 2949 2950 1.712 0.8 13.696 37
I2950 0 2950 1.23684e-05
R3540 2950 0 0.1 49.28 49.28 37
*seg: 296
R3541 0 2951 0.1 49.28 49.28 37
R3542 2955 2965 6.16 0.8 49.28 37
I2951 0 2951 1.29868e-05
R3543 2951 2952 1.696 0.8 13.568 37
I2952 0 2952 1.23684e-05
R3544 2952 2953 1.6 0.8 12.8 37
I2953 0 2953 1.29868e-05
R3545 2953 2954 1.744 0.8 13.952 37
I2954 0 2954 1.23684e-05
R3546 2954 2955 1.648 0.8 13.184 37
I2955 0 2955 1.24921e-05
R3547 2955 2956 1.728 0.8 13.824 37
I2956 0 2956 1.34816e-05
R3548 2956 2957 1.68 0.8 13.44 37
I2957 0 2957 1.23684e-05
R3549 2957 2958 1.664 0.8 13.312 37
I2958 0 2958 1.24921e-05
R3550 2958 2959 1.712 0.8 13.696 37
I2959 0 2959 1.26158e-05
R3551 2959 2960 1.632 0.8 13.056 37
I2960 0 2960 1.23684e-05
R3552 2960 0 0.1 49.28 49.28 37
*seg: 297
R3553 0 2961 0.1 49.28 49.28 37
R3554 2965 2975 6.16 0.8 49.28 37
I2961 0 2961 1.27395e-05
R3555 2961 2962 1.664 0.8 13.312 37
I2962 0 2962 1.34816e-05
R3556 2962 2963 1.744 0.8 13.952 37
I2963 0 2963 1.29868e-05
R3557 2963 2964 1.648 0.8 13.184 37
I2964 0 2964 1.29868e-05
R3558 2964 2965 1.6 0.8 12.8 37
I2965 0 2965 1.32342e-05
R3559 2965 2966 1.664 0.8 13.312 37
I2966 0 2966 1.23684e-05
R3560 2966 2967 1.6 0.8 12.8 37
I2967 0 2967 1.31105e-05
R3561 2967 2968 1.696 0.8 13.568 37
I2968 0 2968 1.23684e-05
R3562 2968 2969 1.616 0.8 12.928 37
I2969 0 2969 1.24921e-05
R3563 2969 2970 1.648 0.8 13.184 37
I2970 0 2970 1.23684e-05
R3564 2970 0 0.1 49.28 49.28 37
*seg: 298
R3565 0 2971 0.1 49.28 49.28 37
R3566 2975 2985 6.16 0.8 49.28 37
I2971 0 2971 1.23684e-05
R3567 2971 2972 1.696 0.8 13.568 37
I2972 0 2972 1.28631e-05
R3568 2972 2973 1.68 0.8 13.44 37
I2973 0 2973 1.28631e-05
R3569 2973 2974 1.712 0.8 13.696 37
I2974 0 2974 1.31105e-05
R3570 2974 2975 1.696 0.8 13.568 37
I2975 0 2975 1.23684e-05
R3571 2975 2976 1.744 0.8 13.952 37
I2976 0 2976 1.34816e-05
R3572 2976 2977 1.664 0.8 13.312 37
I2977 0 2977 1.23684e-05
R3573 2977 2978 1.68 0.8 13.44 37
I2978 0 2978 1.34816e-05
R3574 2978 2979 1.744 0.8 13.952 37
I2979 0 2979 1.29868e-05
R3575 2979 2980 1.632 0.8 13.056 37
I2980 0 2980 1.23684e-05
R3576 2980 0 0.1 49.28 49.28 37
*seg: 299
R3577 0 2981 0.1 49.28 49.28 37
R3578 2985 2995 6.16 0.8 49.28 37
I2981 0 2981 1.26158e-05
R3579 2981 2982 1.744 0.8 13.952 37
I2982 0 2982 1.28631e-05
R3580 2982 2983 1.632 0.8 13.056 37
I2983 0 2983 1.23684e-05
R3581 2983 2984 1.6 0.8 12.8 37
I2984 0 2984 1.33579e-05
R3582 2984 2985 1.664 0.8 13.312 37
I2985 0 2985 1.26158e-05
R3583 2985 2986 1.728 0.8 13.824 37
I2986 0 2986 1.32342e-05
R3584 2986 2987 1.68 0.8 13.44 37
I2987 0 2987 1.31105e-05
R3585 2987 2988 1.632 0.8 13.056 37
I2988 0 2988 1.33579e-05
R3586 2988 2989 1.632 0.8 13.056 37
I2989 0 2989 1.29868e-05
R3587 2989 2990 1.68 0.8 13.44 37
I2990 0 2990 1.23684e-05
R3588 2990 0 0.1 49.28 49.28 37
*seg: 300
R3589 0 2991 0.1 49.28 49.28 37
R3590 2995 3005 6.16 0.8 49.28 37
I2991 0 2991 1.27395e-05
R3591 2991 2992 1.632 0.8 13.056 37
I2992 0 2992 1.27395e-05
R3592 2992 2993 1.648 0.8 13.184 37
I2993 0 2993 1.31105e-05
R3593 2993 2994 1.632 0.8 13.056 37
I2994 0 2994 1.27395e-05
R3594 2994 2995 1.616 0.8 12.928 37
I2995 0 2995 1.34816e-05
R3595 2995 2996 1.664 0.8 13.312 37
I2996 0 2996 1.31105e-05
R3596 2996 2997 1.6 0.8 12.8 37
I2997 0 2997 1.27395e-05
R3597 2997 2998 1.728 0.8 13.824 37
I2998 0 2998 1.31105e-05
R3598 2998 2999 1.648 0.8 13.184 37
I2999 0 2999 1.23684e-05
R3599 2999 3000 1.648 0.8 13.184 37
I3000 0 3000 1.23684e-05
R3600 3000 0 0.1 49.28 49.28 37
*seg: 301
R3601 0 3001 0.1 49.28 49.28 37
R3602 3005 3015 6.16 0.8 49.28 37
I3001 0 3001 1.29868e-05
R3603 3001 3002 1.616 0.8 12.928 37
I3002 0 3002 1.23684e-05
R3604 3002 3003 1.616 0.8 12.928 37
I3003 0 3003 1.24921e-05
R3605 3003 3004 1.744 0.8 13.952 37
I3004 0 3004 1.27395e-05
R3606 3004 3005 1.6 0.8 12.8 37
I3005 0 3005 1.23684e-05
R3607 3005 3006 1.6 0.8 12.8 37
I3006 0 3006 1.33579e-05
R3608 3006 3007 1.712 0.8 13.696 37
I3007 0 3007 1.31105e-05
R3609 3007 3008 1.744 0.8 13.952 37
I3008 0 3008 1.24921e-05
R3610 3008 3009 1.712 0.8 13.696 37
I3009 0 3009 1.26158e-05
R3611 3009 3010 1.728 0.8 13.824 37
I3010 0 3010 1.23684e-05
R3612 3010 0 0.1 49.28 49.28 37
*seg: 302
R3613 0 3011 0.1 49.28 49.28 37
R3614 3015 3025 6.16 0.8 49.28 37
I3011 0 3011 1.32342e-05
R3615 3011 3012 1.632 0.8 13.056 37
I3012 0 3012 1.26158e-05
R3616 3012 3013 1.696 0.8 13.568 37
I3013 0 3013 1.28631e-05
R3617 3013 3014 1.712 0.8 13.696 37
I3014 0 3014 1.26158e-05
R3618 3014 3015 1.696 0.8 13.568 37
I3015 0 3015 1.27395e-05
R3619 3015 3016 1.648 0.8 13.184 37
I3016 0 3016 1.27395e-05
R3620 3016 3017 1.728 0.8 13.824 37
I3017 0 3017 1.31105e-05
R3621 3017 3018 1.616 0.8 12.928 37
I3018 0 3018 1.33579e-05
R3622 3018 3019 1.712 0.8 13.696 37
I3019 0 3019 1.24921e-05
R3623 3019 3020 1.616 0.8 12.928 37
I3020 0 3020 1.23684e-05
R3624 3020 0 0.1 49.28 49.28 37
*seg: 303
R3625 0 3021 0.1 49.28 49.28 37
R3626 3025 3035 6.16 0.8 49.28 37
I3021 0 3021 1.31105e-05
R3627 3021 3022 1.6 0.8 12.8 37
I3022 0 3022 1.31105e-05
R3628 3022 3023 1.664 0.8 13.312 37
I3023 0 3023 1.32342e-05
R3629 3023 3024 1.712 0.8 13.696 37
I3024 0 3024 1.29868e-05
R3630 3024 3025 1.616 0.8 12.928 37
I3025 0 3025 1.29868e-05
R3631 3025 3026 1.728 0.8 13.824 37
I3026 0 3026 1.33579e-05
R3632 3026 3027 1.664 0.8 13.312 37
I3027 0 3027 1.29868e-05
R3633 3027 3028 1.664 0.8 13.312 37
I3028 0 3028 1.24921e-05
R3634 3028 3029 1.712 0.8 13.696 37
I3029 0 3029 1.32342e-05
R3635 3029 3030 1.712 0.8 13.696 37
I3030 0 3030 1.23684e-05
R3636 3030 0 0.1 49.28 49.28 37
*seg: 304
R3637 0 3031 0.1 49.28 49.28 37
R3638 3035 3045 6.16 0.8 49.28 37
I3031 0 3031 1.26158e-05
R3639 3031 3032 1.696 0.8 13.568 37
I3032 0 3032 1.33579e-05
R3640 3032 3033 1.696 0.8 13.568 37
I3033 0 3033 1.28631e-05
R3641 3033 3034 1.648 0.8 13.184 37
I3034 0 3034 1.34816e-05
R3642 3034 3035 1.744 0.8 13.952 37
I3035 0 3035 1.27395e-05
R3643 3035 3036 1.728 0.8 13.824 37
I3036 0 3036 1.29868e-05
R3644 3036 3037 1.712 0.8 13.696 37
I3037 0 3037 1.33579e-05
R3645 3037 3038 1.648 0.8 13.184 37
I3038 0 3038 1.23684e-05
R3646 3038 3039 1.664 0.8 13.312 37
I3039 0 3039 1.23684e-05
R3647 3039 3040 1.68 0.8 13.44 37
I3040 0 3040 1.23684e-05
R3648 3040 0 0.1 49.28 49.28 37
*seg: 305
R3649 0 3041 0.1 49.28 49.28 37
R3650 3045 3055 6.16 0.8 49.28 37
I3041 0 3041 1.27395e-05
R3651 3041 3042 1.728 0.8 13.824 37
I3042 0 3042 1.32342e-05
R3652 3042 3043 1.696 0.8 13.568 37
I3043 0 3043 1.31105e-05
R3653 3043 3044 1.664 0.8 13.312 37
I3044 0 3044 1.27395e-05
R3654 3044 3045 1.744 0.8 13.952 37
I3045 0 3045 1.26158e-05
R3655 3045 3046 1.6 0.8 12.8 37
I3046 0 3046 1.32342e-05
R3656 3046 3047 1.744 0.8 13.952 37
I3047 0 3047 1.31105e-05
R3657 3047 3048 1.712 0.8 13.696 37
I3048 0 3048 1.27395e-05
R3658 3048 3049 1.648 0.8 13.184 37
I3049 0 3049 1.24921e-05
R3659 3049 3050 1.712 0.8 13.696 37
I3050 0 3050 1.23684e-05
R3660 3050 0 0.1 49.28 49.28 37
*seg: 306
R3661 0 3051 0.1 49.28 49.28 37
R3662 3055 3065 6.16 0.8 49.28 37
I3051 0 3051 1.24921e-05
R3663 3051 3052 1.664 0.8 13.312 37
I3052 0 3052 1.33579e-05
R3664 3052 3053 1.664 0.8 13.312 37
I3053 0 3053 1.24921e-05
R3665 3053 3054 1.728 0.8 13.824 37
I3054 0 3054 1.34816e-05
R3666 3054 3055 1.648 0.8 13.184 37
I3055 0 3055 1.34816e-05
R3667 3055 3056 1.728 0.8 13.824 37
I3056 0 3056 1.27395e-05
R3668 3056 3057 1.696 0.8 13.568 37
I3057 0 3057 1.31105e-05
R3669 3057 3058 1.68 0.8 13.44 37
I3058 0 3058 1.32342e-05
R3670 3058 3059 1.712 0.8 13.696 37
I3059 0 3059 1.32342e-05
R3671 3059 3060 1.616 0.8 12.928 37
I3060 0 3060 1.23684e-05
R3672 3060 0 0.1 49.28 49.28 37
*seg: 307
R3673 0 3061 0.1 49.28 49.28 37
R3674 3065 3075 6.16 0.8 49.28 37
I3061 0 3061 1.31105e-05
R3675 3061 3062 1.696 0.8 13.568 37
I3062 0 3062 1.32342e-05
R3676 3062 3063 1.696 0.8 13.568 37
I3063 0 3063 1.33579e-05
R3677 3063 3064 1.68 0.8 13.44 37
I3064 0 3064 1.31105e-05
R3678 3064 3065 1.728 0.8 13.824 37
I3065 0 3065 1.34816e-05
R3679 3065 3066 1.728 0.8 13.824 37
I3066 0 3066 1.27395e-05
R3680 3066 3067 1.664 0.8 13.312 37
I3067 0 3067 1.28631e-05
R3681 3067 3068 1.68 0.8 13.44 37
I3068 0 3068 1.23684e-05
R3682 3068 3069 1.648 0.8 13.184 37
I3069 0 3069 1.32342e-05
R3683 3069 3070 1.68 0.8 13.44 37
I3070 0 3070 1.23684e-05
R3684 3070 0 0.1 49.28 49.28 37
*seg: 308
R3685 0 3071 0.1 49.28 49.28 37
R3686 3075 3085 6.16 0.8 49.28 37
I3071 0 3071 1.33579e-05
R3687 3071 3072 1.68 0.8 13.44 37
I3072 0 3072 1.32342e-05
R3688 3072 3073 1.664 0.8 13.312 37
I3073 0 3073 1.29868e-05
R3689 3073 3074 1.648 0.8 13.184 37
I3074 0 3074 1.27395e-05
R3690 3074 3075 1.744 0.8 13.952 37
I3075 0 3075 1.27395e-05
R3691 3075 3076 1.664 0.8 13.312 37
I3076 0 3076 1.27395e-05
R3692 3076 3077 1.632 0.8 13.056 37
I3077 0 3077 1.32342e-05
R3693 3077 3078 1.664 0.8 13.312 37
I3078 0 3078 1.28631e-05
R3694 3078 3079 1.68 0.8 13.44 37
I3079 0 3079 1.23684e-05
R3695 3079 3080 1.664 0.8 13.312 37
I3080 0 3080 1.23684e-05
R3696 3080 0 0.1 49.28 49.28 37
*seg: 309
R3697 0 3081 0.1 49.28 49.28 37
R3698 3085 3095 6.16 0.8 49.28 37
I3081 0 3081 1.28631e-05
R3699 3081 3082 1.664 0.8 13.312 37
I3082 0 3082 1.28631e-05
R3700 3082 3083 1.728 0.8 13.824 37
I3083 0 3083 1.26158e-05
R3701 3083 3084 1.712 0.8 13.696 37
I3084 0 3084 1.27395e-05
R3702 3084 3085 1.712 0.8 13.696 37
I3085 0 3085 1.34816e-05
R3703 3085 3086 1.664 0.8 13.312 37
I3086 0 3086 1.23684e-05
R3704 3086 3087 1.632 0.8 13.056 37
I3087 0 3087 1.27395e-05
R3705 3087 3088 1.68 0.8 13.44 37
I3088 0 3088 1.29868e-05
R3706 3088 3089 1.728 0.8 13.824 37
I3089 0 3089 1.32342e-05
R3707 3089 3090 1.6 0.8 12.8 37
I3090 0 3090 1.23684e-05
R3708 3090 0 0.1 49.28 49.28 37
*seg: 310
R3709 0 3091 0.1 49.28 49.28 37
R3710 3095 3105 6.16 0.8 49.28 37
I3091 0 3091 1.33579e-05
R3711 3091 3092 1.616 0.8 12.928 37
I3092 0 3092 1.31105e-05
R3712 3092 3093 1.632 0.8 13.056 37
I3093 0 3093 1.28631e-05
R3713 3093 3094 1.664 0.8 13.312 37
I3094 0 3094 1.24921e-05
R3714 3094 3095 1.728 0.8 13.824 37
I3095 0 3095 1.26158e-05
R3715 3095 3096 1.648 0.8 13.184 37
I3096 0 3096 1.31105e-05
R3716 3096 3097 1.728 0.8 13.824 37
I3097 0 3097 1.26158e-05
R3717 3097 3098 1.6 0.8 12.8 37
I3098 0 3098 1.26158e-05
R3718 3098 3099 1.616 0.8 12.928 37
I3099 0 3099 1.31105e-05
R3719 3099 3100 1.696 0.8 13.568 37
I3100 0 3100 1.23684e-05
R3720 3100 0 0.1 49.28 49.28 37
*seg: 311
R3721 0 3101 0.1 49.28 49.28 37
R3722 3105 3115 6.16 0.8 49.28 37
I3101 0 3101 1.24921e-05
R3723 3101 3102 1.712 0.8 13.696 37
I3102 0 3102 1.26158e-05
R3724 3102 3103 1.68 0.8 13.44 37
I3103 0 3103 1.27395e-05
R3725 3103 3104 1.648 0.8 13.184 37
I3104 0 3104 1.29868e-05
R3726 3104 3105 1.648 0.8 13.184 37
I3105 0 3105 1.23684e-05
R3727 3105 3106 1.664 0.8 13.312 37
I3106 0 3106 1.23684e-05
R3728 3106 3107 1.616 0.8 12.928 37
I3107 0 3107 1.24921e-05
R3729 3107 3108 1.68 0.8 13.44 37
I3108 0 3108 1.32342e-05
R3730 3108 3109 1.664 0.8 13.312 37
I3109 0 3109 1.32342e-05
R3731 3109 3110 1.664 0.8 13.312 37
I3110 0 3110 1.23684e-05
R3732 3110 0 0.1 49.28 49.28 37
*seg: 312
R3733 0 3111 0.1 49.28 49.28 37
R3734 3115 3125 6.16 0.8 49.28 37
I3111 0 3111 1.33579e-05
R3735 3111 3112 1.6 0.8 12.8 37
I3112 0 3112 1.32342e-05
R3736 3112 3113 1.6 0.8 12.8 37
I3113 0 3113 1.34816e-05
R3737 3113 3114 1.6 0.8 12.8 37
I3114 0 3114 1.31105e-05
R3738 3114 3115 1.696 0.8 13.568 37
I3115 0 3115 1.23684e-05
R3739 3115 3116 1.632 0.8 13.056 37
I3116 0 3116 1.31105e-05
R3740 3116 3117 1.616 0.8 12.928 37
I3117 0 3117 1.31105e-05
R3741 3117 3118 1.648 0.8 13.184 37
I3118 0 3118 1.26158e-05
R3742 3118 3119 1.648 0.8 13.184 37
I3119 0 3119 1.29868e-05
R3743 3119 3120 1.728 0.8 13.824 37
I3120 0 3120 1.23684e-05
R3744 3120 0 0.1 49.28 49.28 37
*seg: 313
R3745 0 3121 0.1 49.28 49.28 37
R3746 3125 3135 6.16 0.8 49.28 37
I3121 0 3121 1.23684e-05
R3747 3121 3122 1.664 0.8 13.312 37
I3122 0 3122 1.23684e-05
R3748 3122 3123 1.664 0.8 13.312 37
I3123 0 3123 1.33579e-05
R3749 3123 3124 1.648 0.8 13.184 37
I3124 0 3124 1.29868e-05
R3750 3124 3125 1.68 0.8 13.44 37
I3125 0 3125 1.24921e-05
R3751 3125 3126 1.728 0.8 13.824 37
I3126 0 3126 1.27395e-05
R3752 3126 3127 1.68 0.8 13.44 37
I3127 0 3127 1.29868e-05
R3753 3127 3128 1.68 0.8 13.44 37
I3128 0 3128 1.32342e-05
R3754 3128 3129 1.632 0.8 13.056 37
I3129 0 3129 1.28631e-05
R3755 3129 3130 1.6 0.8 12.8 37
I3130 0 3130 1.23684e-05
R3756 3130 0 0.1 49.28 49.28 37
*seg: 314
R3757 0 3131 0.1 49.28 49.28 37
R3758 3135 3145 6.16 0.8 49.28 37
I3131 0 3131 1.26158e-05
R3759 3131 3132 1.648 0.8 13.184 37
I3132 0 3132 1.33579e-05
R3760 3132 3133 1.696 0.8 13.568 37
I3133 0 3133 1.29868e-05
R3761 3133 3134 1.712 0.8 13.696 37
I3134 0 3134 1.28631e-05
R3762 3134 3135 1.728 0.8 13.824 37
I3135 0 3135 1.29868e-05
R3763 3135 3136 1.744 0.8 13.952 37
I3136 0 3136 1.32342e-05
R3764 3136 3137 1.728 0.8 13.824 37
I3137 0 3137 1.32342e-05
R3765 3137 3138 1.696 0.8 13.568 37
I3138 0 3138 1.28631e-05
R3766 3138 3139 1.728 0.8 13.824 37
I3139 0 3139 1.28631e-05
R3767 3139 3140 1.648 0.8 13.184 37
I3140 0 3140 1.23684e-05
R3768 3140 0 0.1 49.28 49.28 37
*seg: 315
R3769 0 3141 0.1 49.28 49.28 37
R3770 3145 3155 6.16 0.8 49.28 37
I3141 0 3141 1.31105e-05
R3771 3141 3142 1.744 0.8 13.952 37
I3142 0 3142 1.28631e-05
R3772 3142 3143 1.712 0.8 13.696 37
I3143 0 3143 1.29868e-05
R3773 3143 3144 1.728 0.8 13.824 37
I3144 0 3144 1.28631e-05
R3774 3144 3145 1.632 0.8 13.056 37
I3145 0 3145 1.28631e-05
R3775 3145 3146 1.6 0.8 12.8 37
I3146 0 3146 1.34816e-05
R3776 3146 3147 1.648 0.8 13.184 37
I3147 0 3147 1.29868e-05
R3777 3147 3148 1.744 0.8 13.952 37
I3148 0 3148 1.28631e-05
R3778 3148 3149 1.696 0.8 13.568 37
I3149 0 3149 1.23684e-05
R3779 3149 3150 1.712 0.8 13.696 37
I3150 0 3150 1.23684e-05
R3780 3150 0 0.1 49.28 49.28 37
*seg: 316
R3781 0 3151 0.1 49.28 49.28 37
R3782 3155 3165 6.16 0.8 49.28 37
I3151 0 3151 1.28631e-05
R3783 3151 3152 1.712 0.8 13.696 37
I3152 0 3152 1.29868e-05
R3784 3152 3153 1.728 0.8 13.824 37
I3153 0 3153 1.28631e-05
R3785 3153 3154 1.648 0.8 13.184 37
I3154 0 3154 1.34816e-05
R3786 3154 3155 1.712 0.8 13.696 37
I3155 0 3155 1.26158e-05
R3787 3155 3156 1.712 0.8 13.696 37
I3156 0 3156 1.31105e-05
R3788 3156 3157 1.6 0.8 12.8 37
I3157 0 3157 1.34816e-05
R3789 3157 3158 1.632 0.8 13.056 37
I3158 0 3158 1.31105e-05
R3790 3158 3159 1.744 0.8 13.952 37
I3159 0 3159 1.23684e-05
R3791 3159 3160 1.712 0.8 13.696 37
I3160 0 3160 1.23684e-05
R3792 3160 0 0.1 49.28 49.28 37
*seg: 317
R3793 0 3161 0.1 49.28 49.28 37
R3794 3165 3175 6.16 0.8 49.28 37
I3161 0 3161 1.33579e-05
R3795 3161 3162 1.648 0.8 13.184 37
I3162 0 3162 1.34816e-05
R3796 3162 3163 1.744 0.8 13.952 37
I3163 0 3163 1.28631e-05
R3797 3163 3164 1.664 0.8 13.312 37
I3164 0 3164 1.27395e-05
R3798 3164 3165 1.6 0.8 12.8 37
I3165 0 3165 1.33579e-05
R3799 3165 3166 1.68 0.8 13.44 37
I3166 0 3166 1.26158e-05
R3800 3166 3167 1.648 0.8 13.184 37
I3167 0 3167 1.23684e-05
R3801 3167 3168 1.648 0.8 13.184 37
I3168 0 3168 1.28631e-05
R3802 3168 3169 1.664 0.8 13.312 37
I3169 0 3169 1.23684e-05
R3803 3169 3170 1.632 0.8 13.056 37
I3170 0 3170 1.23684e-05
R3804 3170 0 0.1 49.28 49.28 37
*seg: 318
R3805 0 3171 0.1 49.28 49.28 37
R3806 3175 3185 6.16 0.8 49.28 37
I3171 0 3171 1.32342e-05
R3807 3171 3172 1.712 0.8 13.696 37
I3172 0 3172 1.24921e-05
R3808 3172 3173 1.712 0.8 13.696 37
I3173 0 3173 1.28631e-05
R3809 3173 3174 1.744 0.8 13.952 37
I3174 0 3174 1.33579e-05
R3810 3174 3175 1.712 0.8 13.696 37
I3175 0 3175 1.33579e-05
R3811 3175 3176 1.68 0.8 13.44 37
I3176 0 3176 1.31105e-05
R3812 3176 3177 1.696 0.8 13.568 37
I3177 0 3177 1.31105e-05
R3813 3177 3178 1.68 0.8 13.44 37
I3178 0 3178 1.24921e-05
R3814 3178 3179 1.712 0.8 13.696 37
I3179 0 3179 1.34816e-05
R3815 3179 3180 1.696 0.8 13.568 37
I3180 0 3180 1.23684e-05
R3816 3180 0 0.1 49.28 49.28 37
*seg: 319
R3817 0 3181 0.1 49.28 49.28 37
R3818 3185 3195 6.16 0.8 49.28 37
I3181 0 3181 1.24921e-05
R3819 3181 3182 1.6 0.8 12.8 37
I3182 0 3182 1.23684e-05
R3820 3182 3183 1.68 0.8 13.44 37
I3183 0 3183 1.29868e-05
R3821 3183 3184 1.712 0.8 13.696 37
I3184 0 3184 1.33579e-05
R3822 3184 3185 1.632 0.8 13.056 37
I3185 0 3185 1.31105e-05
R3823 3185 3186 1.616 0.8 12.928 37
I3186 0 3186 1.29868e-05
R3824 3186 3187 1.632 0.8 13.056 37
I3187 0 3187 1.27395e-05
R3825 3187 3188 1.712 0.8 13.696 37
I3188 0 3188 1.24921e-05
R3826 3188 3189 1.68 0.8 13.44 37
I3189 0 3189 1.33579e-05
R3827 3189 3190 1.728 0.8 13.824 37
I3190 0 3190 1.23684e-05
R3828 3190 0 0.1 49.28 49.28 37
*seg: 320
R3829 0 3191 0.1 49.28 49.28 37
R3830 3195 3205 6.16 0.8 49.28 37
I3191 0 3191 1.23684e-05
R3831 3191 3192 1.632 0.8 13.056 37
I3192 0 3192 1.33579e-05
R3832 3192 3193 1.632 0.8 13.056 37
I3193 0 3193 1.23684e-05
R3833 3193 3194 1.68 0.8 13.44 37
I3194 0 3194 1.34816e-05
R3834 3194 3195 1.68 0.8 13.44 37
I3195 0 3195 1.31105e-05
R3835 3195 3196 1.744 0.8 13.952 37
I3196 0 3196 1.28631e-05
R3836 3196 3197 1.68 0.8 13.44 37
I3197 0 3197 1.26158e-05
R3837 3197 3198 1.68 0.8 13.44 37
I3198 0 3198 1.23684e-05
R3838 3198 3199 1.616 0.8 12.928 37
I3199 0 3199 1.23684e-05
R3839 3199 3200 1.664 0.8 13.312 37
I3200 0 3200 1.23684e-05
R3840 3200 0 0.1 49.28 49.28 37
*seg: 321
R3841 0 3201 0.1 49.28 49.28 37
R3842 3205 3215 6.16 0.8 49.28 37
I3201 0 3201 1.26158e-05
R3843 3201 3202 1.712 0.8 13.696 37
I3202 0 3202 1.29868e-05
R3844 3202 3203 1.632 0.8 13.056 37
I3203 0 3203 1.31105e-05
R3845 3203 3204 1.6 0.8 12.8 37
I3204 0 3204 1.29868e-05
R3846 3204 3205 1.744 0.8 13.952 37
I3205 0 3205 1.31105e-05
R3847 3205 3206 1.6 0.8 12.8 37
I3206 0 3206 1.24921e-05
R3848 3206 3207 1.744 0.8 13.952 37
I3207 0 3207 1.33579e-05
R3849 3207 3208 1.616 0.8 12.928 37
I3208 0 3208 1.34816e-05
R3850 3208 3209 1.6 0.8 12.8 37
I3209 0 3209 1.28631e-05
R3851 3209 3210 1.744 0.8 13.952 37
I3210 0 3210 1.23684e-05
R3852 3210 0 0.1 49.28 49.28 37
*seg: 322
R3853 0 3211 0.1 49.28 49.28 37
R3854 3215 3225 6.16 0.8 49.28 37
I3211 0 3211 1.34816e-05
R3855 3211 3212 1.696 0.8 13.568 37
I3212 0 3212 1.32342e-05
R3856 3212 3213 1.712 0.8 13.696 37
I3213 0 3213 1.24921e-05
R3857 3213 3214 1.648 0.8 13.184 37
I3214 0 3214 1.29868e-05
R3858 3214 3215 1.712 0.8 13.696 37
I3215 0 3215 1.28631e-05
R3859 3215 3216 1.664 0.8 13.312 37
I3216 0 3216 1.34816e-05
R3860 3216 3217 1.664 0.8 13.312 37
I3217 0 3217 1.31105e-05
R3861 3217 3218 1.6 0.8 12.8 37
I3218 0 3218 1.33579e-05
R3862 3218 3219 1.696 0.8 13.568 37
I3219 0 3219 1.31105e-05
R3863 3219 3220 1.744 0.8 13.952 37
I3220 0 3220 1.23684e-05
R3864 3220 0 0.1 49.28 49.28 37
*seg: 323
R3865 0 3221 0.1 49.28 49.28 37
R3866 3225 3235 6.16 0.8 49.28 37
I3221 0 3221 1.26158e-05
R3867 3221 3222 1.648 0.8 13.184 37
I3222 0 3222 1.24921e-05
R3868 3222 3223 1.648 0.8 13.184 37
I3223 0 3223 1.27395e-05
R3869 3223 3224 1.632 0.8 13.056 37
I3224 0 3224 1.32342e-05
R3870 3224 3225 1.648 0.8 13.184 37
I3225 0 3225 1.23684e-05
R3871 3225 3226 1.696 0.8 13.568 37
I3226 0 3226 1.32342e-05
R3872 3226 3227 1.744 0.8 13.952 37
I3227 0 3227 1.32342e-05
R3873 3227 3228 1.744 0.8 13.952 37
I3228 0 3228 1.27395e-05
R3874 3228 3229 1.616 0.8 12.928 37
I3229 0 3229 1.33579e-05
R3875 3229 3230 1.6 0.8 12.8 37
I3230 0 3230 1.23684e-05
R3876 3230 0 0.1 49.28 49.28 37
*seg: 324
R3877 0 3231 0.1 49.28 49.28 37
R3878 3235 3245 6.16 0.8 49.28 37
I3231 0 3231 1.26158e-05
R3879 3231 3232 1.664 0.8 13.312 37
I3232 0 3232 1.32342e-05
R3880 3232 3233 1.696 0.8 13.568 37
I3233 0 3233 1.27395e-05
R3881 3233 3234 1.648 0.8 13.184 37
I3234 0 3234 1.23684e-05
R3882 3234 3235 1.728 0.8 13.824 37
I3235 0 3235 1.27395e-05
R3883 3235 3236 1.68 0.8 13.44 37
I3236 0 3236 1.32342e-05
R3884 3236 3237 1.616 0.8 12.928 37
I3237 0 3237 1.32342e-05
R3885 3237 3238 1.728 0.8 13.824 37
I3238 0 3238 1.28631e-05
R3886 3238 3239 1.712 0.8 13.696 37
I3239 0 3239 1.31105e-05
R3887 3239 3240 1.712 0.8 13.696 37
I3240 0 3240 1.23684e-05
R3888 3240 0 0.1 49.28 49.28 37
*seg: 325
R3889 0 3241 0.1 49.28 49.28 37
R3890 3245 3255 6.16 0.8 49.28 37
I3241 0 3241 1.32342e-05
R3891 3241 3242 1.712 0.8 13.696 37
I3242 0 3242 1.32342e-05
R3892 3242 3243 1.68 0.8 13.44 37
I3243 0 3243 1.28631e-05
R3893 3243 3244 1.744 0.8 13.952 37
I3244 0 3244 1.32342e-05
R3894 3244 3245 1.712 0.8 13.696 37
I3245 0 3245 1.26158e-05
R3895 3245 3246 1.616 0.8 12.928 37
I3246 0 3246 1.26158e-05
R3896 3246 3247 1.68 0.8 13.44 37
I3247 0 3247 1.24921e-05
R3897 3247 3248 1.712 0.8 13.696 37
I3248 0 3248 1.27395e-05
R3898 3248 3249 1.616 0.8 12.928 37
I3249 0 3249 1.33579e-05
R3899 3249 3250 1.616 0.8 12.928 37
I3250 0 3250 1.23684e-05
R3900 3250 0 0.1 49.28 49.28 37
*seg: 326
R3901 0 3251 0.1 49.28 49.28 37
R3902 3255 3265 6.16 0.8 49.28 37
I3251 0 3251 1.23684e-05
R3903 3251 3252 1.632 0.8 13.056 37
I3252 0 3252 1.31105e-05
R3904 3252 3253 1.744 0.8 13.952 37
I3253 0 3253 1.29868e-05
R3905 3253 3254 1.728 0.8 13.824 37
I3254 0 3254 1.32342e-05
R3906 3254 3255 1.696 0.8 13.568 37
I3255 0 3255 1.31105e-05
R3907 3255 3256 1.664 0.8 13.312 37
I3256 0 3256 1.34816e-05
R3908 3256 3257 1.648 0.8 13.184 37
I3257 0 3257 1.24921e-05
R3909 3257 3258 1.744 0.8 13.952 37
I3258 0 3258 1.31105e-05
R3910 3258 3259 1.712 0.8 13.696 37
I3259 0 3259 1.28631e-05
R3911 3259 3260 1.6 0.8 12.8 37
I3260 0 3260 1.23684e-05
R3912 3260 0 0.1 49.28 49.28 37
*seg: 327
R3913 0 3261 0.1 49.28 49.28 37
R3914 3265 3275 6.16 0.8 49.28 37
I3261 0 3261 1.33579e-05
R3915 3261 3262 1.744 0.8 13.952 37
I3262 0 3262 1.26158e-05
R3916 3262 3263 1.648 0.8 13.184 37
I3263 0 3263 1.24921e-05
R3917 3263 3264 1.664 0.8 13.312 37
I3264 0 3264 1.23684e-05
R3918 3264 3265 1.728 0.8 13.824 37
I3265 0 3265 1.32342e-05
R3919 3265 3266 1.616 0.8 12.928 37
I3266 0 3266 1.29868e-05
R3920 3266 3267 1.664 0.8 13.312 37
I3267 0 3267 1.26158e-05
R3921 3267 3268 1.712 0.8 13.696 37
I3268 0 3268 1.24921e-05
R3922 3268 3269 1.712 0.8 13.696 37
I3269 0 3269 1.34816e-05
R3923 3269 3270 1.696 0.8 13.568 37
I3270 0 3270 1.23684e-05
R3924 3270 0 0.1 49.28 49.28 37
*seg: 328
R3925 0 3271 0.1 49.28 49.28 37
R3926 3275 3285 6.16 0.8 49.28 37
I3271 0 3271 1.34816e-05
R3927 3271 3272 1.68 0.8 13.44 37
I3272 0 3272 1.32342e-05
R3928 3272 3273 1.6 0.8 12.8 37
I3273 0 3273 1.23684e-05
R3929 3273 3274 1.6 0.8 12.8 37
I3274 0 3274 1.23684e-05
R3930 3274 3275 1.632 0.8 13.056 37
I3275 0 3275 1.26158e-05
R3931 3275 3276 1.664 0.8 13.312 37
I3276 0 3276 1.23684e-05
R3932 3276 3277 1.744 0.8 13.952 37
I3277 0 3277 1.29868e-05
R3933 3277 3278 1.696 0.8 13.568 37
I3278 0 3278 1.29868e-05
R3934 3278 3279 1.712 0.8 13.696 37
I3279 0 3279 1.28631e-05
R3935 3279 3280 1.712 0.8 13.696 37
I3280 0 3280 1.23684e-05
R3936 3280 0 0.1 49.28 49.28 37
*seg: 329
R3937 0 3281 0.1 49.28 49.28 37
R3938 3285 3295 6.16 0.8 49.28 37
I3281 0 3281 1.28631e-05
R3939 3281 3282 1.632 0.8 13.056 37
I3282 0 3282 1.24921e-05
R3940 3282 3283 1.728 0.8 13.824 37
I3283 0 3283 1.31105e-05
R3941 3283 3284 1.712 0.8 13.696 37
I3284 0 3284 1.33579e-05
R3942 3284 3285 1.6 0.8 12.8 37
I3285 0 3285 1.23684e-05
R3943 3285 3286 1.68 0.8 13.44 37
I3286 0 3286 1.26158e-05
R3944 3286 3287 1.648 0.8 13.184 37
I3287 0 3287 1.26158e-05
R3945 3287 3288 1.616 0.8 12.928 37
I3288 0 3288 1.28631e-05
R3946 3288 3289 1.616 0.8 12.928 37
I3289 0 3289 1.33579e-05
R3947 3289 3290 1.648 0.8 13.184 37
I3290 0 3290 1.23684e-05
R3948 3290 0 0.1 49.28 49.28 37
*seg: 330
R3949 0 3291 0.1 49.28 49.28 37
R3950 3295 3305 6.16 0.8 49.28 37
I3291 0 3291 1.31105e-05
R3951 3291 3292 1.648 0.8 13.184 37
I3292 0 3292 1.34816e-05
R3952 3292 3293 1.632 0.8 13.056 37
I3293 0 3293 1.27395e-05
R3953 3293 3294 1.616 0.8 12.928 37
I3294 0 3294 1.33579e-05
R3954 3294 3295 1.648 0.8 13.184 37
I3295 0 3295 1.34816e-05
R3955 3295 3296 1.6 0.8 12.8 37
I3296 0 3296 1.29868e-05
R3956 3296 3297 1.712 0.8 13.696 37
I3297 0 3297 1.31105e-05
R3957 3297 3298 1.6 0.8 12.8 37
I3298 0 3298 1.32342e-05
R3958 3298 3299 1.648 0.8 13.184 37
I3299 0 3299 1.32342e-05
R3959 3299 3300 1.664 0.8 13.312 37
I3300 0 3300 1.23684e-05
R3960 3300 0 0.1 49.28 49.28 37
*seg: 331
R3961 0 3301 0.1 49.28 49.28 37
R3962 3305 3315 6.16 0.8 49.28 37
I3301 0 3301 1.33579e-05
R3963 3301 3302 1.632 0.8 13.056 37
I3302 0 3302 1.27395e-05
R3964 3302 3303 1.616 0.8 12.928 37
I3303 0 3303 1.31105e-05
R3965 3303 3304 1.696 0.8 13.568 37
I3304 0 3304 1.23684e-05
R3966 3304 3305 1.6 0.8 12.8 37
I3305 0 3305 1.33579e-05
R3967 3305 3306 1.648 0.8 13.184 37
I3306 0 3306 1.31105e-05
R3968 3306 3307 1.728 0.8 13.824 37
I3307 0 3307 1.26158e-05
R3969 3307 3308 1.6 0.8 12.8 37
I3308 0 3308 1.34816e-05
R3970 3308 3309 1.616 0.8 12.928 37
I3309 0 3309 1.31105e-05
R3971 3309 3310 1.696 0.8 13.568 37
I3310 0 3310 1.23684e-05
R3972 3310 0 0.1 49.28 49.28 37
*seg: 332
R3973 0 3311 0.1 49.28 49.28 37
R3974 3315 3325 6.16 0.8 49.28 37
I3311 0 3311 1.23684e-05
R3975 3311 3312 1.728 0.8 13.824 37
I3312 0 3312 1.32342e-05
R3976 3312 3313 1.664 0.8 13.312 37
I3313 0 3313 1.34816e-05
R3977 3313 3314 1.744 0.8 13.952 37
I3314 0 3314 1.31105e-05
R3978 3314 3315 1.616 0.8 12.928 37
I3315 0 3315 1.32342e-05
R3979 3315 3316 1.616 0.8 12.928 37
I3316 0 3316 1.32342e-05
R3980 3316 3317 1.744 0.8 13.952 37
I3317 0 3317 1.31105e-05
R3981 3317 3318 1.616 0.8 12.928 37
I3318 0 3318 1.29868e-05
R3982 3318 3319 1.712 0.8 13.696 37
I3319 0 3319 1.27395e-05
R3983 3319 3320 1.712 0.8 13.696 37
I3320 0 3320 1.23684e-05
R3984 3320 0 0.1 49.28 49.28 37
*seg: 333
R3985 0 3321 0.1 49.28 49.28 37
R3986 3325 3335 6.16 0.8 49.28 37
I3321 0 3321 1.24921e-05
R3987 3321 3322 1.648 0.8 13.184 37
I3322 0 3322 1.24921e-05
R3988 3322 3323 1.6 0.8 12.8 37
I3323 0 3323 1.26158e-05
R3989 3323 3324 1.696 0.8 13.568 37
I3324 0 3324 1.28631e-05
R3990 3324 3325 1.632 0.8 13.056 37
I3325 0 3325 1.29868e-05
R3991 3325 3326 1.68 0.8 13.44 37
I3326 0 3326 1.23684e-05
R3992 3326 3327 1.744 0.8 13.952 37
I3327 0 3327 1.33579e-05
R3993 3327 3328 1.728 0.8 13.824 37
I3328 0 3328 1.34816e-05
R3994 3328 3329 1.68 0.8 13.44 37
I3329 0 3329 1.24921e-05
R3995 3329 3330 1.712 0.8 13.696 37
I3330 0 3330 1.23684e-05
R3996 3330 0 0.1 49.28 49.28 37
*seg: 334
R3997 0 3331 0.1 49.28 49.28 37
R3998 3335 3345 6.16 0.8 49.28 37
I3331 0 3331 1.34816e-05
R3999 3331 3332 1.744 0.8 13.952 37
I3332 0 3332 1.28631e-05
R4000 3332 3333 1.6 0.8 12.8 37
I3333 0 3333 1.24921e-05
R4001 3333 3334 1.648 0.8 13.184 37
I3334 0 3334 1.24921e-05
R4002 3334 3335 1.632 0.8 13.056 37
I3335 0 3335 1.33579e-05
R4003 3335 3336 1.648 0.8 13.184 37
I3336 0 3336 1.24921e-05
R4004 3336 3337 1.616 0.8 12.928 37
I3337 0 3337 1.26158e-05
R4005 3337 3338 1.696 0.8 13.568 37
I3338 0 3338 1.34816e-05
R4006 3338 3339 1.728 0.8 13.824 37
I3339 0 3339 1.26158e-05
R4007 3339 3340 1.616 0.8 12.928 37
I3340 0 3340 1.23684e-05
R4008 3340 0 0.1 49.28 49.28 37
*seg: 335
R4009 0 3341 0.1 49.28 49.28 37
R4010 3345 3355 6.16 0.8 49.28 37
I3341 0 3341 1.31105e-05
R4011 3341 3342 1.728 0.8 13.824 37
I3342 0 3342 1.24921e-05
R4012 3342 3343 1.712 0.8 13.696 37
I3343 0 3343 1.28631e-05
R4013 3343 3344 1.648 0.8 13.184 37
I3344 0 3344 1.34816e-05
R4014 3344 3345 1.696 0.8 13.568 37
I3345 0 3345 1.29868e-05
R4015 3345 3346 1.6 0.8 12.8 37
I3346 0 3346 1.28631e-05
R4016 3346 3347 1.616 0.8 12.928 37
I3347 0 3347 1.33579e-05
R4017 3347 3348 1.68 0.8 13.44 37
I3348 0 3348 1.27395e-05
R4018 3348 3349 1.696 0.8 13.568 37
I3349 0 3349 1.23684e-05
R4019 3349 3350 1.728 0.8 13.824 37
I3350 0 3350 1.23684e-05
R4020 3350 0 0.1 49.28 49.28 37
*seg: 336
R4021 0 3351 0.1 49.28 49.28 37
R4022 3355 3365 6.16 0.8 49.28 37
I3351 0 3351 1.23684e-05
R4023 3351 3352 1.648 0.8 13.184 37
I3352 0 3352 1.27395e-05
R4024 3352 3353 1.616 0.8 12.928 37
I3353 0 3353 1.23684e-05
R4025 3353 3354 1.744 0.8 13.952 37
I3354 0 3354 1.29868e-05
R4026 3354 3355 1.664 0.8 13.312 37
I3355 0 3355 1.32342e-05
R4027 3355 3356 1.696 0.8 13.568 37
I3356 0 3356 1.31105e-05
R4028 3356 3357 1.632 0.8 13.056 37
I3357 0 3357 1.33579e-05
R4029 3357 3358 1.712 0.8 13.696 37
I3358 0 3358 1.23684e-05
R4030 3358 3359 1.744 0.8 13.952 37
I3359 0 3359 1.29868e-05
R4031 3359 3360 1.616 0.8 12.928 37
I3360 0 3360 1.23684e-05
R4032 3360 0 0.1 49.28 49.28 37
*seg: 337
R4033 0 3361 0.1 49.28 49.28 37
R4034 3365 3375 6.16 0.8 49.28 37
I3361 0 3361 1.32342e-05
R4035 3361 3362 1.712 0.8 13.696 37
I3362 0 3362 1.33579e-05
R4036 3362 3363 1.728 0.8 13.824 37
I3363 0 3363 1.34816e-05
R4037 3363 3364 1.744 0.8 13.952 37
I3364 0 3364 1.26158e-05
R4038 3364 3365 1.648 0.8 13.184 37
I3365 0 3365 1.34816e-05
R4039 3365 3366 1.744 0.8 13.952 37
I3366 0 3366 1.26158e-05
R4040 3366 3367 1.68 0.8 13.44 37
I3367 0 3367 1.29868e-05
R4041 3367 3368 1.696 0.8 13.568 37
I3368 0 3368 1.27395e-05
R4042 3368 3369 1.616 0.8 12.928 37
I3369 0 3369 1.27395e-05
R4043 3369 3370 1.712 0.8 13.696 37
I3370 0 3370 1.23684e-05
R4044 3370 0 0.1 49.28 49.28 37
*seg: 338
R4045 0 3371 0.1 49.28 49.28 37
R4046 3375 3385 6.16 0.8 49.28 37
I3371 0 3371 1.24921e-05
R4047 3371 3372 1.744 0.8 13.952 37
I3372 0 3372 1.26158e-05
R4048 3372 3373 1.648 0.8 13.184 37
I3373 0 3373 1.28631e-05
R4049 3373 3374 1.632 0.8 13.056 37
I3374 0 3374 1.27395e-05
R4050 3374 3375 1.6 0.8 12.8 37
I3375 0 3375 1.29868e-05
R4051 3375 3376 1.728 0.8 13.824 37
I3376 0 3376 1.33579e-05
R4052 3376 3377 1.728 0.8 13.824 37
I3377 0 3377 1.26158e-05
R4053 3377 3378 1.712 0.8 13.696 37
I3378 0 3378 1.23684e-05
R4054 3378 3379 1.664 0.8 13.312 37
I3379 0 3379 1.31105e-05
R4055 3379 3380 1.696 0.8 13.568 37
I3380 0 3380 1.23684e-05
R4056 3380 0 0.1 49.28 49.28 37
*seg: 339
R4057 0 3381 0.1 49.28 49.28 37
R4058 3385 3395 6.16 0.8 49.28 37
I3381 0 3381 1.28631e-05
R4059 3381 3382 1.664 0.8 13.312 37
I3382 0 3382 1.28631e-05
R4060 3382 3383 1.68 0.8 13.44 37
I3383 0 3383 1.31105e-05
R4061 3383 3384 1.744 0.8 13.952 37
I3384 0 3384 1.24921e-05
R4062 3384 3385 1.712 0.8 13.696 37
I3385 0 3385 1.29868e-05
R4063 3385 3386 1.712 0.8 13.696 37
I3386 0 3386 1.34816e-05
R4064 3386 3387 1.664 0.8 13.312 37
I3387 0 3387 1.34816e-05
R4065 3387 3388 1.664 0.8 13.312 37
I3388 0 3388 1.33579e-05
R4066 3388 3389 1.744 0.8 13.952 37
I3389 0 3389 1.31105e-05
R4067 3389 3390 1.696 0.8 13.568 37
I3390 0 3390 1.23684e-05
R4068 3390 0 0.1 49.28 49.28 37
*seg: 340
R4069 0 3391 0.1 49.28 49.28 37
R4070 3395 3405 6.16 0.8 49.28 37
I3391 0 3391 1.28631e-05
R4071 3391 3392 1.664 0.8 13.312 37
I3392 0 3392 1.33579e-05
R4072 3392 3393 1.648 0.8 13.184 37
I3393 0 3393 1.33579e-05
R4073 3393 3394 1.696 0.8 13.568 37
I3394 0 3394 1.28631e-05
R4074 3394 3395 1.712 0.8 13.696 37
I3395 0 3395 1.29868e-05
R4075 3395 3396 1.744 0.8 13.952 37
I3396 0 3396 1.27395e-05
R4076 3396 3397 1.712 0.8 13.696 37
I3397 0 3397 1.26158e-05
R4077 3397 3398 1.696 0.8 13.568 37
I3398 0 3398 1.27395e-05
R4078 3398 3399 1.712 0.8 13.696 37
I3399 0 3399 1.32342e-05
R4079 3399 3400 1.728 0.8 13.824 37
I3400 0 3400 1.23684e-05
R4080 3400 0 0.1 49.28 49.28 37
*seg: 341
R4081 0 3401 0.1 49.28 49.28 37
R4082 3405 3415 6.16 0.8 49.28 37
I3401 0 3401 1.27395e-05
R4083 3401 3402 1.696 0.8 13.568 37
I3402 0 3402 1.26158e-05
R4084 3402 3403 1.696 0.8 13.568 37
I3403 0 3403 1.31105e-05
R4085 3403 3404 1.696 0.8 13.568 37
I3404 0 3404 1.24921e-05
R4086 3404 3405 1.728 0.8 13.824 37
I3405 0 3405 1.23684e-05
R4087 3405 3406 1.616 0.8 12.928 37
I3406 0 3406 1.24921e-05
R4088 3406 3407 1.648 0.8 13.184 37
I3407 0 3407 1.34816e-05
R4089 3407 3408 1.696 0.8 13.568 37
I3408 0 3408 1.26158e-05
R4090 3408 3409 1.68 0.8 13.44 37
I3409 0 3409 1.34816e-05
R4091 3409 3410 1.632 0.8 13.056 37
I3410 0 3410 1.23684e-05
R4092 3410 0 0.1 49.28 49.28 37
*seg: 342
R4093 0 3411 0.1 49.28 49.28 37
R4094 3415 3425 6.16 0.8 49.28 37
I3411 0 3411 1.26158e-05
R4095 3411 3412 1.6 0.8 12.8 37
I3412 0 3412 1.28631e-05
R4096 3412 3413 1.664 0.8 13.312 37
I3413 0 3413 1.27395e-05
R4097 3413 3414 1.664 0.8 13.312 37
I3414 0 3414 1.32342e-05
R4098 3414 3415 1.744 0.8 13.952 37
I3415 0 3415 1.33579e-05
R4099 3415 3416 1.664 0.8 13.312 37
I3416 0 3416 1.34816e-05
R4100 3416 3417 1.696 0.8 13.568 37
I3417 0 3417 1.29868e-05
R4101 3417 3418 1.6 0.8 12.8 37
I3418 0 3418 1.33579e-05
R4102 3418 3419 1.632 0.8 13.056 37
I3419 0 3419 1.28631e-05
R4103 3419 3420 1.712 0.8 13.696 37
I3420 0 3420 1.23684e-05
R4104 3420 0 0.1 49.28 49.28 37
*seg: 343
R4105 0 3421 0.1 49.28 49.28 37
R4106 3425 3435 6.16 0.8 49.28 37
I3421 0 3421 1.31105e-05
R4107 3421 3422 1.632 0.8 13.056 37
I3422 0 3422 1.24921e-05
R4108 3422 3423 1.6 0.8 12.8 37
I3423 0 3423 1.23684e-05
R4109 3423 3424 1.728 0.8 13.824 37
I3424 0 3424 1.24921e-05
R4110 3424 3425 1.616 0.8 12.928 37
I3425 0 3425 1.31105e-05
R4111 3425 3426 1.68 0.8 13.44 37
I3426 0 3426 1.26158e-05
R4112 3426 3427 1.6 0.8 12.8 37
I3427 0 3427 1.32342e-05
R4113 3427 3428 1.664 0.8 13.312 37
I3428 0 3428 1.23684e-05
R4114 3428 3429 1.632 0.8 13.056 37
I3429 0 3429 1.23684e-05
R4115 3429 3430 1.616 0.8 12.928 37
I3430 0 3430 1.23684e-05
R4116 3430 0 0.1 49.28 49.28 37
*seg: 344
R4117 0 3431 0.1 49.28 49.28 37
R4118 3435 3445 6.16 0.8 49.28 37
I3431 0 3431 1.32342e-05
R4119 3431 3432 1.616 0.8 12.928 37
I3432 0 3432 1.29868e-05
R4120 3432 3433 1.744 0.8 13.952 37
I3433 0 3433 1.27395e-05
R4121 3433 3434 1.696 0.8 13.568 37
I3434 0 3434 1.31105e-05
R4122 3434 3435 1.6 0.8 12.8 37
I3435 0 3435 1.34816e-05
R4123 3435 3436 1.648 0.8 13.184 37
I3436 0 3436 1.33579e-05
R4124 3436 3437 1.728 0.8 13.824 37
I3437 0 3437 1.28631e-05
R4125 3437 3438 1.696 0.8 13.568 37
I3438 0 3438 1.31105e-05
R4126 3438 3439 1.728 0.8 13.824 37
I3439 0 3439 1.26158e-05
R4127 3439 3440 1.728 0.8 13.824 37
I3440 0 3440 1.23684e-05
R4128 3440 0 0.1 49.28 49.28 37
*seg: 345
R4129 0 3441 0.1 49.28 49.28 37
R4130 3445 3455 6.16 0.8 49.28 37
I3441 0 3441 1.32342e-05
R4131 3441 3442 1.616 0.8 12.928 37
I3442 0 3442 1.28631e-05
R4132 3442 3443 1.68 0.8 13.44 37
I3443 0 3443 1.32342e-05
R4133 3443 3444 1.664 0.8 13.312 37
I3444 0 3444 1.32342e-05
R4134 3444 3445 1.648 0.8 13.184 37
I3445 0 3445 1.23684e-05
R4135 3445 3446 1.728 0.8 13.824 37
I3446 0 3446 1.33579e-05
R4136 3446 3447 1.728 0.8 13.824 37
I3447 0 3447 1.29868e-05
R4137 3447 3448 1.744 0.8 13.952 37
I3448 0 3448 1.29868e-05
R4138 3448 3449 1.632 0.8 13.056 37
I3449 0 3449 1.27395e-05
R4139 3449 3450 1.712 0.8 13.696 37
I3450 0 3450 1.23684e-05
R4140 3450 0 0.1 49.28 49.28 37
*seg: 346
R4141 0 3451 0.1 49.28 49.28 37
R4142 3455 3465 6.16 0.8 49.28 37
I3451 0 3451 1.31105e-05
R4143 3451 3452 1.616 0.8 12.928 37
I3452 0 3452 1.31105e-05
R4144 3452 3453 1.744 0.8 13.952 37
I3453 0 3453 1.27395e-05
R4145 3453 3454 1.712 0.8 13.696 37
I3454 0 3454 1.33579e-05
R4146 3454 3455 1.632 0.8 13.056 37
I3455 0 3455 1.23684e-05
R4147 3455 3456 1.616 0.8 12.928 37
I3456 0 3456 1.33579e-05
R4148 3456 3457 1.648 0.8 13.184 37
I3457 0 3457 1.34816e-05
R4149 3457 3458 1.616 0.8 12.928 37
I3458 0 3458 1.26158e-05
R4150 3458 3459 1.728 0.8 13.824 37
I3459 0 3459 1.29868e-05
R4151 3459 3460 1.712 0.8 13.696 37
I3460 0 3460 1.23684e-05
R4152 3460 0 0.1 49.28 49.28 37
*seg: 347
R4153 0 3461 0.1 49.28 49.28 37
R4154 3465 3475 6.16 0.8 49.28 37
I3461 0 3461 1.33579e-05
R4155 3461 3462 1.696 0.8 13.568 37
I3462 0 3462 1.33579e-05
R4156 3462 3463 1.728 0.8 13.824 37
I3463 0 3463 1.23684e-05
R4157 3463 3464 1.728 0.8 13.824 37
I3464 0 3464 1.26158e-05
R4158 3464 3465 1.728 0.8 13.824 37
I3465 0 3465 1.23684e-05
R4159 3465 3466 1.696 0.8 13.568 37
I3466 0 3466 1.32342e-05
R4160 3466 3467 1.712 0.8 13.696 37
I3467 0 3467 1.32342e-05
R4161 3467 3468 1.632 0.8 13.056 37
I3468 0 3468 1.29868e-05
R4162 3468 3469 1.712 0.8 13.696 37
I3469 0 3469 1.34816e-05
R4163 3469 3470 1.664 0.8 13.312 37
I3470 0 3470 1.23684e-05
R4164 3470 0 0.1 49.28 49.28 37
*seg: 348
R4165 0 3471 0.1 49.28 49.28 37
R4166 3475 3485 6.16 0.8 49.28 37
I3471 0 3471 1.24921e-05
R4167 3471 3472 1.664 0.8 13.312 37
I3472 0 3472 1.31105e-05
R4168 3472 3473 1.616 0.8 12.928 37
I3473 0 3473 1.29868e-05
R4169 3473 3474 1.728 0.8 13.824 37
I3474 0 3474 1.33579e-05
R4170 3474 3475 1.648 0.8 13.184 37
I3475 0 3475 1.23684e-05
R4171 3475 3476 1.616 0.8 12.928 37
I3476 0 3476 1.28631e-05
R4172 3476 3477 1.632 0.8 13.056 37
I3477 0 3477 1.24921e-05
R4173 3477 3478 1.632 0.8 13.056 37
I3478 0 3478 1.31105e-05
R4174 3478 3479 1.68 0.8 13.44 37
I3479 0 3479 1.26158e-05
R4175 3479 3480 1.744 0.8 13.952 37
I3480 0 3480 1.23684e-05
R4176 3480 0 0.1 49.28 49.28 37
*seg: 349
R4177 0 3481 0.1 49.28 49.28 37
R4178 3485 3495 6.16 0.8 49.28 37
I3481 0 3481 1.33579e-05
R4179 3481 3482 1.744 0.8 13.952 37
I3482 0 3482 1.34816e-05
R4180 3482 3483 1.728 0.8 13.824 37
I3483 0 3483 1.27395e-05
R4181 3483 3484 1.696 0.8 13.568 37
I3484 0 3484 1.34816e-05
R4182 3484 3485 1.632 0.8 13.056 37
I3485 0 3485 1.34816e-05
R4183 3485 3486 1.712 0.8 13.696 37
I3486 0 3486 1.34816e-05
R4184 3486 3487 1.648 0.8 13.184 37
I3487 0 3487 1.33579e-05
R4185 3487 3488 1.632 0.8 13.056 37
I3488 0 3488 1.27395e-05
R4186 3488 3489 1.6 0.8 12.8 37
I3489 0 3489 1.26158e-05
R4187 3489 3490 1.632 0.8 13.056 37
I3490 0 3490 1.23684e-05
R4188 3490 0 0.1 49.28 49.28 37
*seg: 350
R4189 0 3491 0.1 49.28 49.28 37
R4190 3495 3505 6.16 0.8 49.28 37
I3491 0 3491 1.33579e-05
R4191 3491 3492 1.68 0.8 13.44 37
I3492 0 3492 1.29868e-05
R4192 3492 3493 1.648 0.8 13.184 37
I3493 0 3493 1.26158e-05
R4193 3493 3494 1.648 0.8 13.184 37
I3494 0 3494 1.32342e-05
R4194 3494 3495 1.68 0.8 13.44 37
I3495 0 3495 1.23684e-05
R4195 3495 3496 1.664 0.8 13.312 37
I3496 0 3496 1.24921e-05
R4196 3496 3497 1.6 0.8 12.8 37
I3497 0 3497 1.34816e-05
R4197 3497 3498 1.664 0.8 13.312 37
I3498 0 3498 1.32342e-05
R4198 3498 3499 1.616 0.8 12.928 37
I3499 0 3499 1.33579e-05
R4199 3499 3500 1.696 0.8 13.568 37
I3500 0 3500 1.23684e-05
R4200 3500 0 0.1 49.28 49.28 37
*seg: 351
R4201 0 3501 0.1 49.28 49.28 37
R4202 3505 3515 6.16 0.8 49.28 37
I3501 0 3501 1.28631e-05
R4203 3501 3502 1.68 0.8 13.44 37
I3502 0 3502 1.32342e-05
R4204 3502 3503 1.744 0.8 13.952 37
I3503 0 3503 1.26158e-05
R4205 3503 3504 1.744 0.8 13.952 37
I3504 0 3504 1.32342e-05
R4206 3504 3505 1.616 0.8 12.928 37
I3505 0 3505 1.33579e-05
R4207 3505 3506 1.696 0.8 13.568 37
I3506 0 3506 1.28631e-05
R4208 3506 3507 1.68 0.8 13.44 37
I3507 0 3507 1.26158e-05
R4209 3507 3508 1.712 0.8 13.696 37
I3508 0 3508 1.24921e-05
R4210 3508 3509 1.664 0.8 13.312 37
I3509 0 3509 1.31105e-05
R4211 3509 3510 1.616 0.8 12.928 37
I3510 0 3510 1.23684e-05
R4212 3510 0 0.1 49.28 49.28 37
*seg: 352
R4213 0 3511 0.1 49.28 49.28 37
R4214 3515 3525 6.16 0.8 49.28 37
I3511 0 3511 1.29868e-05
R4215 3511 3512 1.68 0.8 13.44 37
I3512 0 3512 1.32342e-05
R4216 3512 3513 1.6 0.8 12.8 37
I3513 0 3513 1.27395e-05
R4217 3513 3514 1.632 0.8 13.056 37
I3514 0 3514 1.34816e-05
R4218 3514 3515 1.712 0.8 13.696 37
I3515 0 3515 1.24921e-05
R4219 3515 3516 1.728 0.8 13.824 37
I3516 0 3516 1.29868e-05
R4220 3516 3517 1.744 0.8 13.952 37
I3517 0 3517 1.23684e-05
R4221 3517 3518 1.664 0.8 13.312 37
I3518 0 3518 1.23684e-05
R4222 3518 3519 1.6 0.8 12.8 37
I3519 0 3519 1.34816e-05
R4223 3519 3520 1.616 0.8 12.928 37
I3520 0 3520 1.23684e-05
R4224 3520 0 0.1 49.28 49.28 37
*seg: 353
R4225 0 3521 0.1 49.28 49.28 37
R4226 3525 3535 6.16 0.8 49.28 37
I3521 0 3521 1.34816e-05
R4227 3521 3522 1.616 0.8 12.928 37
I3522 0 3522 1.32342e-05
R4228 3522 3523 1.6 0.8 12.8 37
I3523 0 3523 1.34816e-05
R4229 3523 3524 1.68 0.8 13.44 37
I3524 0 3524 1.28631e-05
R4230 3524 3525 1.68 0.8 13.44 37
I3525 0 3525 1.32342e-05
R4231 3525 3526 1.616 0.8 12.928 37
I3526 0 3526 1.27395e-05
R4232 3526 3527 1.648 0.8 13.184 37
I3527 0 3527 1.29868e-05
R4233 3527 3528 1.648 0.8 13.184 37
I3528 0 3528 1.28631e-05
R4234 3528 3529 1.728 0.8 13.824 37
I3529 0 3529 1.26158e-05
R4235 3529 3530 1.68 0.8 13.44 37
I3530 0 3530 1.23684e-05
R4236 3530 0 0.1 49.28 49.28 37
*seg: 354
R4237 0 3531 0.1 49.28 49.28 37
R4238 3535 3545 6.16 0.8 49.28 37
I3531 0 3531 1.26158e-05
R4239 3531 3532 1.616 0.8 12.928 37
I3532 0 3532 1.27395e-05
R4240 3532 3533 1.68 0.8 13.44 37
I3533 0 3533 1.34816e-05
R4241 3533 3534 1.616 0.8 12.928 37
I3534 0 3534 1.23684e-05
R4242 3534 3535 1.712 0.8 13.696 37
I3535 0 3535 1.34816e-05
R4243 3535 3536 1.632 0.8 13.056 37
I3536 0 3536 1.32342e-05
R4244 3536 3537 1.712 0.8 13.696 37
I3537 0 3537 1.24921e-05
R4245 3537 3538 1.728 0.8 13.824 37
I3538 0 3538 1.29868e-05
R4246 3538 3539 1.664 0.8 13.312 37
I3539 0 3539 1.29868e-05
R4247 3539 3540 1.696 0.8 13.568 37
I3540 0 3540 1.23684e-05
R4248 3540 0 0.1 49.28 49.28 37
*seg: 355
R4249 0 3541 0.1 49.28 49.28 37
R4250 3545 3555 6.16 0.8 49.28 37
I3541 0 3541 1.29868e-05
R4251 3541 3542 1.696 0.8 13.568 37
I3542 0 3542 1.32342e-05
R4252 3542 3543 1.712 0.8 13.696 37
I3543 0 3543 1.29868e-05
R4253 3543 3544 1.632 0.8 13.056 37
I3544 0 3544 1.33579e-05
R4254 3544 3545 1.664 0.8 13.312 37
I3545 0 3545 1.28631e-05
R4255 3545 3546 1.728 0.8 13.824 37
I3546 0 3546 1.26158e-05
R4256 3546 3547 1.664 0.8 13.312 37
I3547 0 3547 1.28631e-05
R4257 3547 3548 1.744 0.8 13.952 37
I3548 0 3548 1.26158e-05
R4258 3548 3549 1.744 0.8 13.952 37
I3549 0 3549 1.23684e-05
R4259 3549 3550 1.6 0.8 12.8 37
I3550 0 3550 1.23684e-05
R4260 3550 0 0.1 49.28 49.28 37
*seg: 356
R4261 0 3551 0.1 49.28 49.28 37
R4262 3555 3565 6.16 0.8 49.28 37
I3551 0 3551 1.28631e-05
R4263 3551 3552 1.6 0.8 12.8 37
I3552 0 3552 1.26158e-05
R4264 3552 3553 1.696 0.8 13.568 37
I3553 0 3553 1.27395e-05
R4265 3553 3554 1.616 0.8 12.928 37
I3554 0 3554 1.32342e-05
R4266 3554 3555 1.616 0.8 12.928 37
I3555 0 3555 1.32342e-05
R4267 3555 3556 1.664 0.8 13.312 37
I3556 0 3556 1.24921e-05
R4268 3556 3557 1.712 0.8 13.696 37
I3557 0 3557 1.33579e-05
R4269 3557 3558 1.712 0.8 13.696 37
I3558 0 3558 1.28631e-05
R4270 3558 3559 1.696 0.8 13.568 37
I3559 0 3559 1.26158e-05
R4271 3559 3560 1.744 0.8 13.952 37
I3560 0 3560 1.23684e-05
R4272 3560 0 0.1 49.28 49.28 37
*seg: 357
R4273 0 3561 0.1 49.28 49.28 37
R4274 3565 3575 6.16 0.8 49.28 37
I3561 0 3561 1.31105e-05
R4275 3561 3562 1.616 0.8 12.928 37
I3562 0 3562 1.24921e-05
R4276 3562 3563 1.728 0.8 13.824 37
I3563 0 3563 1.23684e-05
R4277 3563 3564 1.744 0.8 13.952 37
I3564 0 3564 1.24921e-05
R4278 3564 3565 1.728 0.8 13.824 37
I3565 0 3565 1.27395e-05
R4279 3565 3566 1.712 0.8 13.696 37
I3566 0 3566 1.23684e-05
R4280 3566 3567 1.632 0.8 13.056 37
I3567 0 3567 1.27395e-05
R4281 3567 3568 1.648 0.8 13.184 37
I3568 0 3568 1.26158e-05
R4282 3568 3569 1.68 0.8 13.44 37
I3569 0 3569 1.27395e-05
R4283 3569 3570 1.616 0.8 12.928 37
I3570 0 3570 1.23684e-05
R4284 3570 0 0.1 49.28 49.28 37
*seg: 358
R4285 0 3571 0.1 49.28 49.28 37
R4286 3575 3585 6.16 0.8 49.28 37
I3571 0 3571 1.23684e-05
R4287 3571 3572 1.68 0.8 13.44 37
I3572 0 3572 1.24921e-05
R4288 3572 3573 1.728 0.8 13.824 37
I3573 0 3573 1.32342e-05
R4289 3573 3574 1.728 0.8 13.824 37
I3574 0 3574 1.33579e-05
R4290 3574 3575 1.696 0.8 13.568 37
I3575 0 3575 1.27395e-05
R4291 3575 3576 1.632 0.8 13.056 37
I3576 0 3576 1.29868e-05
R4292 3576 3577 1.744 0.8 13.952 37
I3577 0 3577 1.23684e-05
R4293 3577 3578 1.696 0.8 13.568 37
I3578 0 3578 1.27395e-05
R4294 3578 3579 1.696 0.8 13.568 37
I3579 0 3579 1.29868e-05
R4295 3579 3580 1.616 0.8 12.928 37
I3580 0 3580 1.23684e-05
R4296 3580 0 0.1 49.28 49.28 37
*seg: 359
R4297 0 3581 0.1 49.28 49.28 37
R4298 3585 3595 6.16 0.8 49.28 37
I3581 0 3581 1.24921e-05
R4299 3581 3582 1.696 0.8 13.568 37
I3582 0 3582 1.27395e-05
R4300 3582 3583 1.728 0.8 13.824 37
I3583 0 3583 1.27395e-05
R4301 3583 3584 1.696 0.8 13.568 37
I3584 0 3584 1.33579e-05
R4302 3584 3585 1.68 0.8 13.44 37
I3585 0 3585 1.34816e-05
R4303 3585 3586 1.744 0.8 13.952 37
I3586 0 3586 1.33579e-05
R4304 3586 3587 1.712 0.8 13.696 37
I3587 0 3587 1.24921e-05
R4305 3587 3588 1.696 0.8 13.568 37
I3588 0 3588 1.31105e-05
R4306 3588 3589 1.744 0.8 13.952 37
I3589 0 3589 1.29868e-05
R4307 3589 3590 1.68 0.8 13.44 37
I3590 0 3590 1.23684e-05
R4308 3590 0 0.1 49.28 49.28 37
*seg: 360
R4309 0 3591 0.1 49.28 49.28 37
R4310 3595 3605 6.16 0.8 49.28 37
I3591 0 3591 1.28631e-05
R4311 3591 3592 1.664 0.8 13.312 37
I3592 0 3592 1.29868e-05
R4312 3592 3593 1.6 0.8 12.8 37
I3593 0 3593 1.34816e-05
R4313 3593 3594 1.696 0.8 13.568 37
I3594 0 3594 1.33579e-05
R4314 3594 3595 1.728 0.8 13.824 37
I3595 0 3595 1.27395e-05
R4315 3595 3596 1.712 0.8 13.696 37
I3596 0 3596 1.32342e-05
R4316 3596 3597 1.632 0.8 13.056 37
I3597 0 3597 1.28631e-05
R4317 3597 3598 1.68 0.8 13.44 37
I3598 0 3598 1.34816e-05
R4318 3598 3599 1.712 0.8 13.696 37
I3599 0 3599 1.24921e-05
R4319 3599 3600 1.696 0.8 13.568 37
I3600 0 3600 1.23684e-05
R4320 3600 0 0.1 49.28 49.28 37
*seg: 361
R4321 0 3601 0.1 49.28 49.28 37
R4322 3605 3615 6.16 0.8 49.28 37
I3601 0 3601 1.28631e-05
R4323 3601 3602 1.712 0.8 13.696 37
I3602 0 3602 1.34816e-05
R4324 3602 3603 1.68 0.8 13.44 37
I3603 0 3603 1.29868e-05
R4325 3603 3604 1.712 0.8 13.696 37
I3604 0 3604 1.29868e-05
R4326 3604 3605 1.6 0.8 12.8 37
I3605 0 3605 1.26158e-05
R4327 3605 3606 1.696 0.8 13.568 37
I3606 0 3606 1.34816e-05
R4328 3606 3607 1.664 0.8 13.312 37
I3607 0 3607 1.27395e-05
R4329 3607 3608 1.744 0.8 13.952 37
I3608 0 3608 1.34816e-05
R4330 3608 3609 1.744 0.8 13.952 37
I3609 0 3609 1.29868e-05
R4331 3609 3610 1.68 0.8 13.44 37
I3610 0 3610 1.23684e-05
R4332 3610 0 0.1 49.28 49.28 37
*seg: 362
R4333 0 3611 0.1 49.28 49.28 37
R4334 3615 3625 6.16 0.8 49.28 37
I3611 0 3611 1.24921e-05
R4335 3611 3612 1.616 0.8 12.928 37
I3612 0 3612 1.32342e-05
R4336 3612 3613 1.68 0.8 13.44 37
I3613 0 3613 1.23684e-05
R4337 3613 3614 1.664 0.8 13.312 37
I3614 0 3614 1.31105e-05
R4338 3614 3615 1.664 0.8 13.312 37
I3615 0 3615 1.27395e-05
R4339 3615 3616 1.696 0.8 13.568 37
I3616 0 3616 1.28631e-05
R4340 3616 3617 1.68 0.8 13.44 37
I3617 0 3617 1.27395e-05
R4341 3617 3618 1.664 0.8 13.312 37
I3618 0 3618 1.23684e-05
R4342 3618 3619 1.648 0.8 13.184 37
I3619 0 3619 1.23684e-05
R4343 3619 3620 1.664 0.8 13.312 37
I3620 0 3620 1.23684e-05
R4344 3620 0 0.1 49.28 49.28 37
*seg: 363
R4345 0 3621 0.1 49.28 49.28 37
R4346 3625 3635 6.16 0.8 49.28 37
I3621 0 3621 1.33579e-05
R4347 3621 3622 1.632 0.8 13.056 37
I3622 0 3622 1.27395e-05
R4348 3622 3623 1.664 0.8 13.312 37
I3623 0 3623 1.28631e-05
R4349 3623 3624 1.616 0.8 12.928 37
I3624 0 3624 1.26158e-05
R4350 3624 3625 1.728 0.8 13.824 37
I3625 0 3625 1.33579e-05
R4351 3625 3626 1.68 0.8 13.44 37
I3626 0 3626 1.27395e-05
R4352 3626 3627 1.664 0.8 13.312 37
I3627 0 3627 1.34816e-05
R4353 3627 3628 1.68 0.8 13.44 37
I3628 0 3628 1.29868e-05
R4354 3628 3629 1.728 0.8 13.824 37
I3629 0 3629 1.34816e-05
R4355 3629 3630 1.744 0.8 13.952 37
I3630 0 3630 1.23684e-05
R4356 3630 0 0.1 49.28 49.28 37
*seg: 364
R4357 0 3631 0.1 49.28 49.28 37
R4358 3635 3645 6.16 0.8 49.28 37
I3631 0 3631 1.23684e-05
R4359 3631 3632 1.712 0.8 13.696 37
I3632 0 3632 1.31105e-05
R4360 3632 3633 1.712 0.8 13.696 37
I3633 0 3633 1.28631e-05
R4361 3633 3634 1.6 0.8 12.8 37
I3634 0 3634 1.27395e-05
R4362 3634 3635 1.632 0.8 13.056 37
I3635 0 3635 1.29868e-05
R4363 3635 3636 1.728 0.8 13.824 37
I3636 0 3636 1.32342e-05
R4364 3636 3637 1.712 0.8 13.696 37
I3637 0 3637 1.24921e-05
R4365 3637 3638 1.712 0.8 13.696 37
I3638 0 3638 1.27395e-05
R4366 3638 3639 1.6 0.8 12.8 37
I3639 0 3639 1.24921e-05
R4367 3639 3640 1.664 0.8 13.312 37
I3640 0 3640 1.23684e-05
R4368 3640 0 0.1 49.28 49.28 37
*seg: 365
R4369 0 3641 0.1 49.28 49.28 37
R4370 3645 3655 6.16 0.8 49.28 37
I3641 0 3641 1.34816e-05
R4371 3641 3642 1.6 0.8 12.8 37
I3642 0 3642 1.26158e-05
R4372 3642 3643 1.712 0.8 13.696 37
I3643 0 3643 1.31105e-05
R4373 3643 3644 1.632 0.8 13.056 37
I3644 0 3644 1.33579e-05
R4374 3644 3645 1.744 0.8 13.952 37
I3645 0 3645 1.24921e-05
R4375 3645 3646 1.712 0.8 13.696 37
I3646 0 3646 1.29868e-05
R4376 3646 3647 1.648 0.8 13.184 37
I3647 0 3647 1.23684e-05
R4377 3647 3648 1.6 0.8 12.8 37
I3648 0 3648 1.32342e-05
R4378 3648 3649 1.68 0.8 13.44 37
I3649 0 3649 1.34816e-05
R4379 3649 3650 1.6 0.8 12.8 37
I3650 0 3650 1.23684e-05
R4380 3650 0 0.1 49.28 49.28 37
*seg: 366
R4381 0 3651 0.1 49.28 49.28 37
R4382 3655 3665 6.16 0.8 49.28 37
I3651 0 3651 1.26158e-05
R4383 3651 3652 1.68 0.8 13.44 37
I3652 0 3652 1.24921e-05
R4384 3652 3653 1.648 0.8 13.184 37
I3653 0 3653 1.27395e-05
R4385 3653 3654 1.712 0.8 13.696 37
I3654 0 3654 1.31105e-05
R4386 3654 3655 1.616 0.8 12.928 37
I3655 0 3655 1.32342e-05
R4387 3655 3656 1.664 0.8 13.312 37
I3656 0 3656 1.27395e-05
R4388 3656 3657 1.632 0.8 13.056 37
I3657 0 3657 1.33579e-05
R4389 3657 3658 1.632 0.8 13.056 37
I3658 0 3658 1.27395e-05
R4390 3658 3659 1.648 0.8 13.184 37
I3659 0 3659 1.33579e-05
R4391 3659 3660 1.728 0.8 13.824 37
I3660 0 3660 1.23684e-05
R4392 3660 0 0.1 49.28 49.28 37
*seg: 367
R4393 0 3661 0.1 49.28 49.28 37
R4394 3665 3675 6.16 0.8 49.28 37
I3661 0 3661 1.31105e-05
R4395 3661 3662 1.648 0.8 13.184 37
I3662 0 3662 1.27395e-05
R4396 3662 3663 1.648 0.8 13.184 37
I3663 0 3663 1.32342e-05
R4397 3663 3664 1.728 0.8 13.824 37
I3664 0 3664 1.23684e-05
R4398 3664 3665 1.696 0.8 13.568 37
I3665 0 3665 1.27395e-05
R4399 3665 3666 1.632 0.8 13.056 37
I3666 0 3666 1.31105e-05
R4400 3666 3667 1.664 0.8 13.312 37
I3667 0 3667 1.29868e-05
R4401 3667 3668 1.68 0.8 13.44 37
I3668 0 3668 1.33579e-05
R4402 3668 3669 1.712 0.8 13.696 37
I3669 0 3669 1.23684e-05
R4403 3669 3670 1.68 0.8 13.44 37
I3670 0 3670 1.23684e-05
R4404 3670 0 0.1 49.28 49.28 37
*seg: 368
R4405 0 3671 0.1 49.28 49.28 37
R4406 3675 3685 6.16 0.8 49.28 37
I3671 0 3671 1.28631e-05
R4407 3671 3672 1.616 0.8 12.928 37
I3672 0 3672 1.28631e-05
R4408 3672 3673 1.728 0.8 13.824 37
I3673 0 3673 1.26158e-05
R4409 3673 3674 1.616 0.8 12.928 37
I3674 0 3674 1.26158e-05
R4410 3674 3675 1.6 0.8 12.8 37
I3675 0 3675 1.31105e-05
R4411 3675 3676 1.712 0.8 13.696 37
I3676 0 3676 1.34816e-05
R4412 3676 3677 1.68 0.8 13.44 37
I3677 0 3677 1.23684e-05
R4413 3677 3678 1.632 0.8 13.056 37
I3678 0 3678 1.28631e-05
R4414 3678 3679 1.712 0.8 13.696 37
I3679 0 3679 1.26158e-05
R4415 3679 3680 1.728 0.8 13.824 37
I3680 0 3680 1.23684e-05
R4416 3680 0 0.1 49.28 49.28 37
*seg: 369
R4417 0 3681 0.1 49.28 49.28 37
R4418 3685 3695 6.16 0.8 49.28 37
I3681 0 3681 1.23684e-05
R4419 3681 3682 1.6 0.8 12.8 37
I3682 0 3682 1.24921e-05
R4420 3682 3683 1.712 0.8 13.696 37
I3683 0 3683 1.29868e-05
R4421 3683 3684 1.616 0.8 12.928 37
I3684 0 3684 1.34816e-05
R4422 3684 3685 1.68 0.8 13.44 37
I3685 0 3685 1.28631e-05
R4423 3685 3686 1.712 0.8 13.696 37
I3686 0 3686 1.27395e-05
R4424 3686 3687 1.68 0.8 13.44 37
I3687 0 3687 1.23684e-05
R4425 3687 3688 1.712 0.8 13.696 37
I3688 0 3688 1.24921e-05
R4426 3688 3689 1.68 0.8 13.44 37
I3689 0 3689 1.27395e-05
R4427 3689 3690 1.632 0.8 13.056 37
I3690 0 3690 1.23684e-05
R4428 3690 0 0.1 49.28 49.28 37
*seg: 370
R4429 0 3691 0.1 49.28 49.28 37
R4430 3695 3705 6.16 0.8 49.28 37
I3691 0 3691 1.29868e-05
R4431 3691 3692 1.664 0.8 13.312 37
I3692 0 3692 1.23684e-05
R4432 3692 3693 1.6 0.8 12.8 37
I3693 0 3693 1.27395e-05
R4433 3693 3694 1.648 0.8 13.184 37
I3694 0 3694 1.23684e-05
R4434 3694 3695 1.616 0.8 12.928 37
I3695 0 3695 1.29868e-05
R4435 3695 3696 1.68 0.8 13.44 37
I3696 0 3696 1.23684e-05
R4436 3696 3697 1.632 0.8 13.056 37
I3697 0 3697 1.26158e-05
R4437 3697 3698 1.744 0.8 13.952 37
I3698 0 3698 1.31105e-05
R4438 3698 3699 1.712 0.8 13.696 37
I3699 0 3699 1.31105e-05
R4439 3699 3700 1.696 0.8 13.568 37
I3700 0 3700 1.23684e-05
R4440 3700 0 0.1 49.28 49.28 37
*seg: 371
R4441 0 3701 0.1 49.28 49.28 37
R4442 3705 3715 6.16 0.8 49.28 37
I3701 0 3701 1.27395e-05
R4443 3701 3702 1.632 0.8 13.056 37
I3702 0 3702 1.24921e-05
R4444 3702 3703 1.632 0.8 13.056 37
I3703 0 3703 1.28631e-05
R4445 3703 3704 1.6 0.8 12.8 37
I3704 0 3704 1.29868e-05
R4446 3704 3705 1.744 0.8 13.952 37
I3705 0 3705 1.29868e-05
R4447 3705 3706 1.728 0.8 13.824 37
I3706 0 3706 1.23684e-05
R4448 3706 3707 1.712 0.8 13.696 37
I3707 0 3707 1.24921e-05
R4449 3707 3708 1.68 0.8 13.44 37
I3708 0 3708 1.34816e-05
R4450 3708 3709 1.712 0.8 13.696 37
I3709 0 3709 1.32342e-05
R4451 3709 3710 1.68 0.8 13.44 37
I3710 0 3710 1.23684e-05
R4452 3710 0 0.1 49.28 49.28 37
*seg: 372
R4453 0 3711 0.1 49.28 49.28 37
R4454 3715 3725 6.16 0.8 49.28 37
I3711 0 3711 1.33579e-05
R4455 3711 3712 1.712 0.8 13.696 37
I3712 0 3712 1.23684e-05
R4456 3712 3713 1.68 0.8 13.44 37
I3713 0 3713 1.32342e-05
R4457 3713 3714 1.728 0.8 13.824 37
I3714 0 3714 1.24921e-05
R4458 3714 3715 1.68 0.8 13.44 37
I3715 0 3715 1.28631e-05
R4459 3715 3716 1.632 0.8 13.056 37
I3716 0 3716 1.24921e-05
R4460 3716 3717 1.6 0.8 12.8 37
I3717 0 3717 1.31105e-05
R4461 3717 3718 1.68 0.8 13.44 37
I3718 0 3718 1.29868e-05
R4462 3718 3719 1.712 0.8 13.696 37
I3719 0 3719 1.29868e-05
R4463 3719 3720 1.632 0.8 13.056 37
I3720 0 3720 1.23684e-05
R4464 3720 0 0.1 49.28 49.28 37
*seg: 373
R4465 0 3721 0.1 49.28 49.28 37
R4466 3725 3735 6.16 0.8 49.28 37
I3721 0 3721 1.27395e-05
R4467 3721 3722 1.616 0.8 12.928 37
I3722 0 3722 1.23684e-05
R4468 3722 3723 1.632 0.8 13.056 37
I3723 0 3723 1.23684e-05
R4469 3723 3724 1.648 0.8 13.184 37
I3724 0 3724 1.29868e-05
R4470 3724 3725 1.6 0.8 12.8 37
I3725 0 3725 1.29868e-05
R4471 3725 3726 1.6 0.8 12.8 37
I3726 0 3726 1.33579e-05
R4472 3726 3727 1.6 0.8 12.8 37
I3727 0 3727 1.31105e-05
R4473 3727 3728 1.728 0.8 13.824 37
I3728 0 3728 1.31105e-05
R4474 3728 3729 1.616 0.8 12.928 37
I3729 0 3729 1.32342e-05
R4475 3729 3730 1.648 0.8 13.184 37
I3730 0 3730 1.23684e-05
R4476 3730 0 0.1 49.28 49.28 37
*seg: 374
R4477 0 3731 0.1 49.28 49.28 37
R4478 3735 3745 6.16 0.8 49.28 37
I3731 0 3731 1.24921e-05
R4479 3731 3732 1.648 0.8 13.184 37
I3732 0 3732 1.34816e-05
R4480 3732 3733 1.712 0.8 13.696 37
I3733 0 3733 1.31105e-05
R4481 3733 3734 1.616 0.8 12.928 37
I3734 0 3734 1.26158e-05
R4482 3734 3735 1.68 0.8 13.44 37
I3735 0 3735 1.23684e-05
R4483 3735 3736 1.728 0.8 13.824 37
I3736 0 3736 1.34816e-05
R4484 3736 3737 1.696 0.8 13.568 37
I3737 0 3737 1.32342e-05
R4485 3737 3738 1.616 0.8 12.928 37
I3738 0 3738 1.32342e-05
R4486 3738 3739 1.728 0.8 13.824 37
I3739 0 3739 1.26158e-05
R4487 3739 3740 1.664 0.8 13.312 37
I3740 0 3740 1.23684e-05
R4488 3740 0 0.1 49.28 49.28 37
*seg: 375
R4489 0 3741 0.1 49.28 49.28 37
R4490 3745 3755 6.16 0.8 49.28 37
I3741 0 3741 1.28631e-05
R4491 3741 3742 1.68 0.8 13.44 37
I3742 0 3742 1.23684e-05
R4492 3742 3743 1.6 0.8 12.8 37
I3743 0 3743 1.24921e-05
R4493 3743 3744 1.6 0.8 12.8 37
I3744 0 3744 1.27395e-05
R4494 3744 3745 1.616 0.8 12.928 37
I3745 0 3745 1.26158e-05
R4495 3745 3746 1.664 0.8 13.312 37
I3746 0 3746 1.33579e-05
R4496 3746 3747 1.744 0.8 13.952 37
I3747 0 3747 1.26158e-05
R4497 3747 3748 1.6 0.8 12.8 37
I3748 0 3748 1.23684e-05
R4498 3748 3749 1.632 0.8 13.056 37
I3749 0 3749 1.26158e-05
R4499 3749 3750 1.68 0.8 13.44 37
I3750 0 3750 1.23684e-05
R4500 3750 0 0.1 49.28 49.28 37
*seg: 376
R4501 0 3751 0.1 49.28 49.28 37
R4502 3755 3765 6.16 0.8 49.28 37
I3751 0 3751 1.34816e-05
R4503 3751 3752 1.696 0.8 13.568 37
I3752 0 3752 1.29868e-05
R4504 3752 3753 1.648 0.8 13.184 37
I3753 0 3753 1.33579e-05
R4505 3753 3754 1.712 0.8 13.696 37
I3754 0 3754 1.29868e-05
R4506 3754 3755 1.68 0.8 13.44 37
I3755 0 3755 1.31105e-05
R4507 3755 3756 1.712 0.8 13.696 37
I3756 0 3756 1.23684e-05
R4508 3756 3757 1.632 0.8 13.056 37
I3757 0 3757 1.27395e-05
R4509 3757 3758 1.696 0.8 13.568 37
I3758 0 3758 1.32342e-05
R4510 3758 3759 1.664 0.8 13.312 37
I3759 0 3759 1.24921e-05
R4511 3759 3760 1.616 0.8 12.928 37
I3760 0 3760 1.23684e-05
R4512 3760 0 0.1 49.28 49.28 37
*seg: 377
R4513 0 3761 0.1 49.28 49.28 37
R4514 3765 3775 6.16 0.8 49.28 37
I3761 0 3761 1.27395e-05
R4515 3761 3762 1.648 0.8 13.184 37
I3762 0 3762 1.28631e-05
R4516 3762 3763 1.68 0.8 13.44 37
I3763 0 3763 1.24921e-05
R4517 3763 3764 1.696 0.8 13.568 37
I3764 0 3764 1.24921e-05
R4518 3764 3765 1.68 0.8 13.44 37
I3765 0 3765 1.27395e-05
R4519 3765 3766 1.696 0.8 13.568 37
I3766 0 3766 1.23684e-05
R4520 3766 3767 1.712 0.8 13.696 37
I3767 0 3767 1.24921e-05
R4521 3767 3768 1.6 0.8 12.8 37
I3768 0 3768 1.24921e-05
R4522 3768 3769 1.616 0.8 12.928 37
I3769 0 3769 1.23684e-05
R4523 3769 3770 1.728 0.8 13.824 37
I3770 0 3770 1.23684e-05
R4524 3770 0 0.1 49.28 49.28 37
*seg: 378
R4525 0 3771 0.1 49.28 49.28 37
R4526 3775 3785 6.16 0.8 49.28 37
I3771 0 3771 1.27395e-05
R4527 3771 3772 1.68 0.8 13.44 37
I3772 0 3772 1.28631e-05
R4528 3772 3773 1.712 0.8 13.696 37
I3773 0 3773 1.29868e-05
R4529 3773 3774 1.696 0.8 13.568 37
I3774 0 3774 1.23684e-05
R4530 3774 3775 1.664 0.8 13.312 37
I3775 0 3775 1.27395e-05
R4531 3775 3776 1.648 0.8 13.184 37
I3776 0 3776 1.24921e-05
R4532 3776 3777 1.68 0.8 13.44 37
I3777 0 3777 1.34816e-05
R4533 3777 3778 1.744 0.8 13.952 37
I3778 0 3778 1.28631e-05
R4534 3778 3779 1.712 0.8 13.696 37
I3779 0 3779 1.33579e-05
R4535 3779 3780 1.728 0.8 13.824 37
I3780 0 3780 1.23684e-05
R4536 3780 0 0.1 49.28 49.28 37
*seg: 379
R4537 0 3781 0.1 49.28 49.28 37
R4538 3785 3795 6.16 0.8 49.28 37
I3781 0 3781 1.24921e-05
R4539 3781 3782 1.696 0.8 13.568 37
I3782 0 3782 1.27395e-05
R4540 3782 3783 1.712 0.8 13.696 37
I3783 0 3783 1.23684e-05
R4541 3783 3784 1.6 0.8 12.8 37
I3784 0 3784 1.23684e-05
R4542 3784 3785 1.664 0.8 13.312 37
I3785 0 3785 1.34816e-05
R4543 3785 3786 1.744 0.8 13.952 37
I3786 0 3786 1.24921e-05
R4544 3786 3787 1.728 0.8 13.824 37
I3787 0 3787 1.23684e-05
R4545 3787 3788 1.664 0.8 13.312 37
I3788 0 3788 1.23684e-05
R4546 3788 3789 1.6 0.8 12.8 37
I3789 0 3789 1.29868e-05
R4547 3789 3790 1.616 0.8 12.928 37
I3790 0 3790 1.23684e-05
R4548 3790 0 0.1 49.28 49.28 37
*seg: 380
R4549 0 3791 0.1 49.28 49.28 37
R4550 3795 3805 6.16 0.8 49.28 37
I3791 0 3791 1.33579e-05
R4551 3791 3792 1.712 0.8 13.696 37
I3792 0 3792 1.24921e-05
R4552 3792 3793 1.632 0.8 13.056 37
I3793 0 3793 1.24921e-05
R4553 3793 3794 1.616 0.8 12.928 37
I3794 0 3794 1.23684e-05
R4554 3794 3795 1.696 0.8 13.568 37
I3795 0 3795 1.34816e-05
R4555 3795 3796 1.744 0.8 13.952 37
I3796 0 3796 1.33579e-05
R4556 3796 3797 1.68 0.8 13.44 37
I3797 0 3797 1.28631e-05
R4557 3797 3798 1.712 0.8 13.696 37
I3798 0 3798 1.33579e-05
R4558 3798 3799 1.696 0.8 13.568 37
I3799 0 3799 1.23684e-05
R4559 3799 3800 1.6 0.8 12.8 37
I3800 0 3800 1.23684e-05
R4560 3800 0 0.1 49.28 49.28 37
*seg: 381
R4561 0 3801 0.1 49.28 49.28 37
R4562 3805 3815 6.16 0.8 49.28 37
I3801 0 3801 1.29868e-05
R4563 3801 3802 1.712 0.8 13.696 37
I3802 0 3802 1.33579e-05
R4564 3802 3803 1.712 0.8 13.696 37
I3803 0 3803 1.26158e-05
R4565 3803 3804 1.68 0.8 13.44 37
I3804 0 3804 1.31105e-05
R4566 3804 3805 1.68 0.8 13.44 37
I3805 0 3805 1.23684e-05
R4567 3805 3806 1.68 0.8 13.44 37
I3806 0 3806 1.27395e-05
R4568 3806 3807 1.744 0.8 13.952 37
I3807 0 3807 1.29868e-05
R4569 3807 3808 1.728 0.8 13.824 37
I3808 0 3808 1.32342e-05
R4570 3808 3809 1.632 0.8 13.056 37
I3809 0 3809 1.28631e-05
R4571 3809 3810 1.728 0.8 13.824 37
I3810 0 3810 1.23684e-05
R4572 3810 0 0.1 49.28 49.28 37
*seg: 382
R4573 0 3811 0.1 49.28 49.28 37
R4574 3815 3825 6.16 0.8 49.28 37
I3811 0 3811 1.23684e-05
R4575 3811 3812 1.648 0.8 13.184 37
I3812 0 3812 1.26158e-05
R4576 3812 3813 1.616 0.8 12.928 37
I3813 0 3813 1.28631e-05
R4577 3813 3814 1.616 0.8 12.928 37
I3814 0 3814 1.32342e-05
R4578 3814 3815 1.712 0.8 13.696 37
I3815 0 3815 1.29868e-05
R4579 3815 3816 1.68 0.8 13.44 37
I3816 0 3816 1.24921e-05
R4580 3816 3817 1.6 0.8 12.8 37
I3817 0 3817 1.34816e-05
R4581 3817 3818 1.696 0.8 13.568 37
I3818 0 3818 1.34816e-05
R4582 3818 3819 1.6 0.8 12.8 37
I3819 0 3819 1.24921e-05
R4583 3819 3820 1.6 0.8 12.8 37
I3820 0 3820 1.23684e-05
R4584 3820 0 0.1 49.28 49.28 37
*seg: 383
R4585 0 3821 0.1 49.28 49.28 37
R4586 3825 3835 6.16 0.8 49.28 37
I3821 0 3821 1.33579e-05
R4587 3821 3822 1.6 0.8 12.8 37
I3822 0 3822 1.28631e-05
R4588 3822 3823 1.648 0.8 13.184 37
I3823 0 3823 1.28631e-05
R4589 3823 3824 1.648 0.8 13.184 37
I3824 0 3824 1.26158e-05
R4590 3824 3825 1.712 0.8 13.696 37
I3825 0 3825 1.26158e-05
R4591 3825 3826 1.712 0.8 13.696 37
I3826 0 3826 1.23684e-05
R4592 3826 3827 1.6 0.8 12.8 37
I3827 0 3827 1.28631e-05
R4593 3827 3828 1.616 0.8 12.928 37
I3828 0 3828 1.32342e-05
R4594 3828 3829 1.712 0.8 13.696 37
I3829 0 3829 1.28631e-05
R4595 3829 3830 1.616 0.8 12.928 37
I3830 0 3830 1.23684e-05
R4596 3830 0 0.1 49.28 49.28 37
*seg: 384
R4597 0 3831 0.1 49.28 49.28 37
R4598 3835 3845 6.16 0.8 49.28 37
I3831 0 3831 1.32342e-05
R4599 3831 3832 1.696 0.8 13.568 37
I3832 0 3832 1.33579e-05
R4600 3832 3833 1.632 0.8 13.056 37
I3833 0 3833 1.29868e-05
R4601 3833 3834 1.664 0.8 13.312 37
I3834 0 3834 1.32342e-05
R4602 3834 3835 1.744 0.8 13.952 37
I3835 0 3835 1.29868e-05
R4603 3835 3836 1.728 0.8 13.824 37
I3836 0 3836 1.24921e-05
R4604 3836 3837 1.664 0.8 13.312 37
I3837 0 3837 1.31105e-05
R4605 3837 3838 1.632 0.8 13.056 37
I3838 0 3838 1.32342e-05
R4606 3838 3839 1.616 0.8 12.928 37
I3839 0 3839 1.28631e-05
R4607 3839 3840 1.664 0.8 13.312 37
I3840 0 3840 1.23684e-05
R4608 3840 0 0.1 49.28 49.28 37
*seg: 385
R4609 0 3841 0.1 49.28 49.28 37
R4610 3845 3855 6.16 0.8 49.28 37
I3841 0 3841 1.28631e-05
R4611 3841 3842 1.68 0.8 13.44 37
I3842 0 3842 1.26158e-05
R4612 3842 3843 1.664 0.8 13.312 37
I3843 0 3843 1.34816e-05
R4613 3843 3844 1.6 0.8 12.8 37
I3844 0 3844 1.29868e-05
R4614 3844 3845 1.664 0.8 13.312 37
I3845 0 3845 1.26158e-05
R4615 3845 3846 1.744 0.8 13.952 37
I3846 0 3846 1.28631e-05
R4616 3846 3847 1.744 0.8 13.952 37
I3847 0 3847 1.24921e-05
R4617 3847 3848 1.712 0.8 13.696 37
I3848 0 3848 1.23684e-05
R4618 3848 3849 1.712 0.8 13.696 37
I3849 0 3849 1.27395e-05
R4619 3849 3850 1.648 0.8 13.184 37
I3850 0 3850 1.23684e-05
R4620 3850 0 0.1 49.28 49.28 37
*seg: 386
R4621 0 3851 0.1 49.28 49.28 37
R4622 3855 3865 6.16 0.8 49.28 37
I3851 0 3851 1.26158e-05
R4623 3851 3852 1.728 0.8 13.824 37
I3852 0 3852 1.29868e-05
R4624 3852 3853 1.712 0.8 13.696 37
I3853 0 3853 1.33579e-05
R4625 3853 3854 1.632 0.8 13.056 37
I3854 0 3854 1.29868e-05
R4626 3854 3855 1.696 0.8 13.568 37
I3855 0 3855 1.24921e-05
R4627 3855 3856 1.616 0.8 12.928 37
I3856 0 3856 1.24921e-05
R4628 3856 3857 1.664 0.8 13.312 37
I3857 0 3857 1.27395e-05
R4629 3857 3858 1.6 0.8 12.8 37
I3858 0 3858 1.33579e-05
R4630 3858 3859 1.664 0.8 13.312 37
I3859 0 3859 1.26158e-05
R4631 3859 3860 1.6 0.8 12.8 37
I3860 0 3860 1.23684e-05
R4632 3860 0 0.1 49.28 49.28 37
*seg: 387
R4633 0 3861 0.1 49.28 49.28 37
R4634 3865 3875 6.16 0.8 49.28 37
I3861 0 3861 1.33579e-05
R4635 3861 3862 1.68 0.8 13.44 37
I3862 0 3862 1.28631e-05
R4636 3862 3863 1.728 0.8 13.824 37
I3863 0 3863 1.31105e-05
R4637 3863 3864 1.68 0.8 13.44 37
I3864 0 3864 1.24921e-05
R4638 3864 3865 1.696 0.8 13.568 37
I3865 0 3865 1.27395e-05
R4639 3865 3866 1.648 0.8 13.184 37
I3866 0 3866 1.29868e-05
R4640 3866 3867 1.6 0.8 12.8 37
I3867 0 3867 1.34816e-05
R4641 3867 3868 1.744 0.8 13.952 37
I3868 0 3868 1.31105e-05
R4642 3868 3869 1.664 0.8 13.312 37
I3869 0 3869 1.31105e-05
R4643 3869 3870 1.696 0.8 13.568 37
I3870 0 3870 1.23684e-05
R4644 3870 0 0.1 49.28 49.28 37
*seg: 388
R4645 0 3871 0.1 49.28 49.28 37
R4646 3875 3885 6.16 0.8 49.28 37
I3871 0 3871 1.24921e-05
R4647 3871 3872 1.648 0.8 13.184 37
I3872 0 3872 1.29868e-05
R4648 3872 3873 1.616 0.8 12.928 37
I3873 0 3873 1.27395e-05
R4649 3873 3874 1.68 0.8 13.44 37
I3874 0 3874 1.29868e-05
R4650 3874 3875 1.728 0.8 13.824 37
I3875 0 3875 1.34816e-05
R4651 3875 3876 1.68 0.8 13.44 37
I3876 0 3876 1.23684e-05
R4652 3876 3877 1.648 0.8 13.184 37
I3877 0 3877 1.29868e-05
R4653 3877 3878 1.632 0.8 13.056 37
I3878 0 3878 1.34816e-05
R4654 3878 3879 1.648 0.8 13.184 37
I3879 0 3879 1.29868e-05
R4655 3879 3880 1.648 0.8 13.184 37
I3880 0 3880 1.23684e-05
R4656 3880 0 0.1 49.28 49.28 37
*seg: 389
R4657 0 3881 0.1 49.28 49.28 37
R4658 3885 3895 6.16 0.8 49.28 37
I3881 0 3881 1.28631e-05
R4659 3881 3882 1.6 0.8 12.8 37
I3882 0 3882 1.29868e-05
R4660 3882 3883 1.632 0.8 13.056 37
I3883 0 3883 1.28631e-05
R4661 3883 3884 1.648 0.8 13.184 37
I3884 0 3884 1.28631e-05
R4662 3884 3885 1.68 0.8 13.44 37
I3885 0 3885 1.23684e-05
R4663 3885 3886 1.616 0.8 12.928 37
I3886 0 3886 1.29868e-05
R4664 3886 3887 1.68 0.8 13.44 37
I3887 0 3887 1.32342e-05
R4665 3887 3888 1.6 0.8 12.8 37
I3888 0 3888 1.34816e-05
R4666 3888 3889 1.712 0.8 13.696 37
I3889 0 3889 1.34816e-05
R4667 3889 3890 1.664 0.8 13.312 37
I3890 0 3890 1.23684e-05
R4668 3890 0 0.1 49.28 49.28 37
*seg: 390
R4669 0 3891 0.1 49.28 49.28 37
R4670 3895 3905 6.16 0.8 49.28 37
I3891 0 3891 1.32342e-05
R4671 3891 3892 1.664 0.8 13.312 37
I3892 0 3892 1.28631e-05
R4672 3892 3893 1.68 0.8 13.44 37
I3893 0 3893 1.31105e-05
R4673 3893 3894 1.68 0.8 13.44 37
I3894 0 3894 1.29868e-05
R4674 3894 3895 1.696 0.8 13.568 37
I3895 0 3895 1.23684e-05
R4675 3895 3896 1.68 0.8 13.44 37
I3896 0 3896 1.32342e-05
R4676 3896 3897 1.728 0.8 13.824 37
I3897 0 3897 1.31105e-05
R4677 3897 3898 1.696 0.8 13.568 37
I3898 0 3898 1.34816e-05
R4678 3898 3899 1.648 0.8 13.184 37
I3899 0 3899 1.29868e-05
R4679 3899 3900 1.648 0.8 13.184 37
I3900 0 3900 1.23684e-05
R4680 3900 0 0.1 49.28 49.28 37
*seg: 391
R4681 0 3901 0.1 49.28 49.28 37
R4682 3905 3915 6.16 0.8 49.28 37
I3901 0 3901 1.32342e-05
R4683 3901 3902 1.632 0.8 13.056 37
I3902 0 3902 1.23684e-05
R4684 3902 3903 1.664 0.8 13.312 37
I3903 0 3903 1.33579e-05
R4685 3903 3904 1.632 0.8 13.056 37
I3904 0 3904 1.34816e-05
R4686 3904 3905 1.744 0.8 13.952 37
I3905 0 3905 1.34816e-05
R4687 3905 3906 1.6 0.8 12.8 37
I3906 0 3906 1.33579e-05
R4688 3906 3907 1.664 0.8 13.312 37
I3907 0 3907 1.31105e-05
R4689 3907 3908 1.616 0.8 12.928 37
I3908 0 3908 1.24921e-05
R4690 3908 3909 1.728 0.8 13.824 37
I3909 0 3909 1.23684e-05
R4691 3909 3910 1.648 0.8 13.184 37
I3910 0 3910 1.23684e-05
R4692 3910 0 0.1 49.28 49.28 37
*seg: 392
R4693 0 3911 0.1 49.28 49.28 37
R4694 3915 3925 6.16 0.8 49.28 37
I3911 0 3911 1.24921e-05
R4695 3911 3912 1.632 0.8 13.056 37
I3912 0 3912 1.28631e-05
R4696 3912 3913 1.728 0.8 13.824 37
I3913 0 3913 1.27395e-05
R4697 3913 3914 1.712 0.8 13.696 37
I3914 0 3914 1.28631e-05
R4698 3914 3915 1.68 0.8 13.44 37
I3915 0 3915 1.32342e-05
R4699 3915 3916 1.6 0.8 12.8 37
I3916 0 3916 1.34816e-05
R4700 3916 3917 1.68 0.8 13.44 37
I3917 0 3917 1.23684e-05
R4701 3917 3918 1.616 0.8 12.928 37
I3918 0 3918 1.33579e-05
R4702 3918 3919 1.6 0.8 12.8 37
I3919 0 3919 1.23684e-05
R4703 3919 3920 1.744 0.8 13.952 37
I3920 0 3920 1.23684e-05
R4704 3920 0 0.1 49.28 49.28 37
*seg: 393
R4705 0 3921 0.1 49.28 49.28 37
R4706 3925 3935 6.16 0.8 49.28 37
I3921 0 3921 1.26158e-05
R4707 3921 3922 1.616 0.8 12.928 37
I3922 0 3922 1.27395e-05
R4708 3922 3923 1.648 0.8 13.184 37
I3923 0 3923 1.29868e-05
R4709 3923 3924 1.664 0.8 13.312 37
I3924 0 3924 1.27395e-05
R4710 3924 3925 1.744 0.8 13.952 37
I3925 0 3925 1.34816e-05
R4711 3925 3926 1.68 0.8 13.44 37
I3926 0 3926 1.33579e-05
R4712 3926 3927 1.744 0.8 13.952 37
I3927 0 3927 1.34816e-05
R4713 3927 3928 1.632 0.8 13.056 37
I3928 0 3928 1.24921e-05
R4714 3928 3929 1.696 0.8 13.568 37
I3929 0 3929 1.24921e-05
R4715 3929 3930 1.632 0.8 13.056 37
I3930 0 3930 1.23684e-05
R4716 3930 0 0.1 49.28 49.28 37
*seg: 394
R4717 0 3931 0.1 49.28 49.28 37
R4718 3935 3945 6.16 0.8 49.28 37
I3931 0 3931 1.26158e-05
R4719 3931 3932 1.68 0.8 13.44 37
I3932 0 3932 1.26158e-05
R4720 3932 3933 1.744 0.8 13.952 37
I3933 0 3933 1.31105e-05
R4721 3933 3934 1.664 0.8 13.312 37
I3934 0 3934 1.28631e-05
R4722 3934 3935 1.712 0.8 13.696 37
I3935 0 3935 1.33579e-05
R4723 3935 3936 1.728 0.8 13.824 37
I3936 0 3936 1.34816e-05
R4724 3936 3937 1.664 0.8 13.312 37
I3937 0 3937 1.34816e-05
R4725 3937 3938 1.712 0.8 13.696 37
I3938 0 3938 1.31105e-05
R4726 3938 3939 1.696 0.8 13.568 37
I3939 0 3939 1.23684e-05
R4727 3939 3940 1.68 0.8 13.44 37
I3940 0 3940 1.23684e-05
R4728 3940 0 0.1 49.28 49.28 37
*seg: 395
R4729 0 3941 0.1 49.28 49.28 37
R4730 3945 3955 6.16 0.8 49.28 37
I3941 0 3941 1.28631e-05
R4731 3941 3942 1.744 0.8 13.952 37
I3942 0 3942 1.34816e-05
R4732 3942 3943 1.696 0.8 13.568 37
I3943 0 3943 1.23684e-05
R4733 3943 3944 1.696 0.8 13.568 37
I3944 0 3944 1.32342e-05
R4734 3944 3945 1.712 0.8 13.696 37
I3945 0 3945 1.34816e-05
R4735 3945 3946 1.68 0.8 13.44 37
I3946 0 3946 1.24921e-05
R4736 3946 3947 1.744 0.8 13.952 37
I3947 0 3947 1.26158e-05
R4737 3947 3948 1.712 0.8 13.696 37
I3948 0 3948 1.31105e-05
R4738 3948 3949 1.744 0.8 13.952 37
I3949 0 3949 1.29868e-05
R4739 3949 3950 1.744 0.8 13.952 37
I3950 0 3950 1.23684e-05
R4740 3950 0 0.1 49.28 49.28 37
*seg: 396
R4741 0 3951 0.1 49.28 49.28 37
R4742 3955 3965 6.16 0.8 49.28 37
I3951 0 3951 1.32342e-05
R4743 3951 3952 1.696 0.8 13.568 37
I3952 0 3952 1.34816e-05
R4744 3952 3953 1.728 0.8 13.824 37
I3953 0 3953 1.34816e-05
R4745 3953 3954 1.68 0.8 13.44 37
I3954 0 3954 1.32342e-05
R4746 3954 3955 1.744 0.8 13.952 37
I3955 0 3955 1.29868e-05
R4747 3955 3956 1.616 0.8 12.928 37
I3956 0 3956 1.26158e-05
R4748 3956 3957 1.696 0.8 13.568 37
I3957 0 3957 1.27395e-05
R4749 3957 3958 1.68 0.8 13.44 37
I3958 0 3958 1.23684e-05
R4750 3958 3959 1.648 0.8 13.184 37
I3959 0 3959 1.23684e-05
R4751 3959 3960 1.632 0.8 13.056 37
I3960 0 3960 1.23684e-05
R4752 3960 0 0.1 49.28 49.28 37
*seg: 397
R4753 0 3961 0.1 49.28 49.28 37
R4754 3965 3975 6.16 0.8 49.28 37
I3961 0 3961 1.32342e-05
R4755 3961 3962 1.728 0.8 13.824 37
I3962 0 3962 1.23684e-05
R4756 3962 3963 1.744 0.8 13.952 37
I3963 0 3963 1.27395e-05
R4757 3963 3964 1.728 0.8 13.824 37
I3964 0 3964 1.33579e-05
R4758 3964 3965 1.696 0.8 13.568 37
I3965 0 3965 1.23684e-05
R4759 3965 3966 1.664 0.8 13.312 37
I3966 0 3966 1.31105e-05
R4760 3966 3967 1.712 0.8 13.696 37
I3967 0 3967 1.28631e-05
R4761 3967 3968 1.728 0.8 13.824 37
I3968 0 3968 1.26158e-05
R4762 3968 3969 1.616 0.8 12.928 37
I3969 0 3969 1.32342e-05
R4763 3969 3970 1.616 0.8 12.928 37
I3970 0 3970 1.23684e-05
R4764 3970 0 0.1 49.28 49.28 37
*seg: 398
R4765 0 3971 0.1 49.28 49.28 37
R4766 3975 3985 6.16 0.8 49.28 37
I3971 0 3971 1.29868e-05
R4767 3971 3972 1.616 0.8 12.928 37
I3972 0 3972 1.31105e-05
R4768 3972 3973 1.6 0.8 12.8 37
I3973 0 3973 1.23684e-05
R4769 3973 3974 1.744 0.8 13.952 37
I3974 0 3974 1.29868e-05
R4770 3974 3975 1.696 0.8 13.568 37
I3975 0 3975 1.28631e-05
R4771 3975 3976 1.648 0.8 13.184 37
I3976 0 3976 1.24921e-05
R4772 3976 3977 1.744 0.8 13.952 37
I3977 0 3977 1.26158e-05
R4773 3977 3978 1.744 0.8 13.952 37
I3978 0 3978 1.28631e-05
R4774 3978 3979 1.68 0.8 13.44 37
I3979 0 3979 1.27395e-05
R4775 3979 3980 1.6 0.8 12.8 37
I3980 0 3980 1.23684e-05
R4776 3980 0 0.1 49.28 49.28 37
*seg: 399
R4777 0 3981 0.1 49.28 49.28 37
R4778 3985 3995 6.16 0.8 49.28 37
I3981 0 3981 1.23684e-05
R4779 3981 3982 1.648 0.8 13.184 37
I3982 0 3982 1.31105e-05
R4780 3982 3983 1.744 0.8 13.952 37
I3983 0 3983 1.24921e-05
R4781 3983 3984 1.712 0.8 13.696 37
I3984 0 3984 1.28631e-05
R4782 3984 3985 1.68 0.8 13.44 37
I3985 0 3985 1.31105e-05
R4783 3985 3986 1.632 0.8 13.056 37
I3986 0 3986 1.31105e-05
R4784 3986 3987 1.616 0.8 12.928 37
I3987 0 3987 1.31105e-05
R4785 3987 3988 1.696 0.8 13.568 37
I3988 0 3988 1.33579e-05
R4786 3988 3989 1.696 0.8 13.568 37
I3989 0 3989 1.29868e-05
R4787 3989 3990 1.728 0.8 13.824 37
I3990 0 3990 1.23684e-05
R4788 3990 0 0.1 49.28 49.28 37
*seg: 400
R4789 0 3991 0.1 49.28 49.28 37
R4790 3995 4005 6.16 0.8 49.28 37
I3991 0 3991 1.29868e-05
R4791 3991 3992 1.696 0.8 13.568 37
I3992 0 3992 1.33579e-05
R4792 3992 3993 1.712 0.8 13.696 37
I3993 0 3993 1.28631e-05
R4793 3993 3994 1.616 0.8 12.928 37
I3994 0 3994 1.32342e-05
R4794 3994 3995 1.6 0.8 12.8 37
I3995 0 3995 1.26158e-05
R4795 3995 3996 1.632 0.8 13.056 37
I3996 0 3996 1.32342e-05
R4796 3996 3997 1.68 0.8 13.44 37
I3997 0 3997 1.27395e-05
R4797 3997 3998 1.6 0.8 12.8 37
I3998 0 3998 1.33579e-05
R4798 3998 3999 1.6 0.8 12.8 37
I3999 0 3999 1.34816e-05
R4799 3999 4000 1.68 0.8 13.44 37
I4000 0 4000 1.23684e-05
R4800 4000 0 0.1 49.28 49.28 37
*seg: 401
R4801 0 4001 0.1 49.28 49.28 37
R4802 4005 4015 6.16 0.8 49.28 37
I4001 0 4001 1.27395e-05
R4803 4001 4002 1.648 0.8 13.184 37
I4002 0 4002 1.29868e-05
R4804 4002 4003 1.712 0.8 13.696 37
I4003 0 4003 1.24921e-05
R4805 4003 4004 1.6 0.8 12.8 37
I4004 0 4004 1.28631e-05
R4806 4004 4005 1.664 0.8 13.312 37
I4005 0 4005 1.26158e-05
R4807 4005 4006 1.696 0.8 13.568 37
I4006 0 4006 1.28631e-05
R4808 4006 4007 1.744 0.8 13.952 37
I4007 0 4007 1.31105e-05
R4809 4007 4008 1.632 0.8 13.056 37
I4008 0 4008 1.29868e-05
R4810 4008 4009 1.632 0.8 13.056 37
I4009 0 4009 1.31105e-05
R4811 4009 4010 1.728 0.8 13.824 37
I4010 0 4010 1.23684e-05
R4812 4010 0 0.1 49.28 49.28 37
*seg: 402
R4813 0 4011 0.1 49.28 49.28 37
R4814 4015 4025 6.16 0.8 49.28 37
I4011 0 4011 1.32342e-05
R4815 4011 4012 1.616 0.8 12.928 37
I4012 0 4012 1.29868e-05
R4816 4012 4013 1.712 0.8 13.696 37
I4013 0 4013 1.24921e-05
R4817 4013 4014 1.744 0.8 13.952 37
I4014 0 4014 1.29868e-05
R4818 4014 4015 1.68 0.8 13.44 37
I4015 0 4015 1.34816e-05
R4819 4015 4016 1.6 0.8 12.8 37
I4016 0 4016 1.34816e-05
R4820 4016 4017 1.6 0.8 12.8 37
I4017 0 4017 1.23684e-05
R4821 4017 4018 1.616 0.8 12.928 37
I4018 0 4018 1.32342e-05
R4822 4018 4019 1.696 0.8 13.568 37
I4019 0 4019 1.28631e-05
R4823 4019 4020 1.648 0.8 13.184 37
I4020 0 4020 1.23684e-05
R4824 4020 0 0.1 49.28 49.28 37
*seg: 403
R4825 0 4021 0.1 49.28 49.28 37
R4826 4025 4035 6.16 0.8 49.28 37
I4021 0 4021 1.29868e-05
R4827 4021 4022 1.696 0.8 13.568 37
I4022 0 4022 1.32342e-05
R4828 4022 4023 1.696 0.8 13.568 37
I4023 0 4023 1.32342e-05
R4829 4023 4024 1.696 0.8 13.568 37
I4024 0 4024 1.32342e-05
R4830 4024 4025 1.664 0.8 13.312 37
I4025 0 4025 1.34816e-05
R4831 4025 4026 1.616 0.8 12.928 37
I4026 0 4026 1.27395e-05
R4832 4026 4027 1.68 0.8 13.44 37
I4027 0 4027 1.28631e-05
R4833 4027 4028 1.632 0.8 13.056 37
I4028 0 4028 1.28631e-05
R4834 4028 4029 1.68 0.8 13.44 37
I4029 0 4029 1.26158e-05
R4835 4029 4030 1.616 0.8 12.928 37
I4030 0 4030 1.23684e-05
R4836 4030 0 0.1 49.28 49.28 37
*seg: 404
R4837 0 4031 0.1 49.28 49.28 37
R4838 4035 4045 6.16 0.8 49.28 37
I4031 0 4031 1.31105e-05
R4839 4031 4032 1.6 0.8 12.8 37
I4032 0 4032 1.29868e-05
R4840 4032 4033 1.632 0.8 13.056 37
I4033 0 4033 1.33579e-05
R4841 4033 4034 1.696 0.8 13.568 37
I4034 0 4034 1.34816e-05
R4842 4034 4035 1.648 0.8 13.184 37
I4035 0 4035 1.33579e-05
R4843 4035 4036 1.744 0.8 13.952 37
I4036 0 4036 1.32342e-05
R4844 4036 4037 1.616 0.8 12.928 37
I4037 0 4037 1.27395e-05
R4845 4037 4038 1.6 0.8 12.8 37
I4038 0 4038 1.26158e-05
R4846 4038 4039 1.712 0.8 13.696 37
I4039 0 4039 1.34816e-05
R4847 4039 4040 1.68 0.8 13.44 37
I4040 0 4040 1.23684e-05
R4848 4040 0 0.1 49.28 49.28 37
*seg: 405
R4849 0 4041 0.1 49.28 49.28 37
R4850 4045 4055 6.16 0.8 49.28 37
I4041 0 4041 1.32342e-05
R4851 4041 4042 1.712 0.8 13.696 37
I4042 0 4042 1.32342e-05
R4852 4042 4043 1.744 0.8 13.952 37
I4043 0 4043 1.27395e-05
R4853 4043 4044 1.68 0.8 13.44 37
I4044 0 4044 1.34816e-05
R4854 4044 4045 1.712 0.8 13.696 37
I4045 0 4045 1.32342e-05
R4855 4045 4046 1.696 0.8 13.568 37
I4046 0 4046 1.31105e-05
R4856 4046 4047 1.728 0.8 13.824 37
I4047 0 4047 1.28631e-05
R4857 4047 4048 1.712 0.8 13.696 37
I4048 0 4048 1.26158e-05
R4858 4048 4049 1.68 0.8 13.44 37
I4049 0 4049 1.24921e-05
R4859 4049 4050 1.712 0.8 13.696 37
I4050 0 4050 1.23684e-05
R4860 4050 0 0.1 49.28 49.28 37
*seg: 406
R4861 0 4051 0.1 49.28 49.28 37
R4862 4055 4065 6.16 0.8 49.28 37
I4051 0 4051 1.27395e-05
R4863 4051 4052 1.664 0.8 13.312 37
I4052 0 4052 1.27395e-05
R4864 4052 4053 1.616 0.8 12.928 37
I4053 0 4053 1.27395e-05
R4865 4053 4054 1.648 0.8 13.184 37
I4054 0 4054 1.29868e-05
R4866 4054 4055 1.664 0.8 13.312 37
I4055 0 4055 1.29868e-05
R4867 4055 4056 1.728 0.8 13.824 37
I4056 0 4056 1.27395e-05
R4868 4056 4057 1.616 0.8 12.928 37
I4057 0 4057 1.28631e-05
R4869 4057 4058 1.68 0.8 13.44 37
I4058 0 4058 1.29868e-05
R4870 4058 4059 1.664 0.8 13.312 37
I4059 0 4059 1.33579e-05
R4871 4059 4060 1.664 0.8 13.312 37
I4060 0 4060 1.23684e-05
R4872 4060 0 0.1 49.28 49.28 37
*seg: 407
R4873 0 4061 0.1 49.28 49.28 37
R4874 4065 4075 6.16 0.8 49.28 37
I4061 0 4061 1.28631e-05
R4875 4061 4062 1.712 0.8 13.696 37
I4062 0 4062 1.34816e-05
R4876 4062 4063 1.664 0.8 13.312 37
I4063 0 4063 1.26158e-05
R4877 4063 4064 1.616 0.8 12.928 37
I4064 0 4064 1.24921e-05
R4878 4064 4065 1.696 0.8 13.568 37
I4065 0 4065 1.24921e-05
R4879 4065 4066 1.696 0.8 13.568 37
I4066 0 4066 1.27395e-05
R4880 4066 4067 1.664 0.8 13.312 37
I4067 0 4067 1.27395e-05
R4881 4067 4068 1.632 0.8 13.056 37
I4068 0 4068 1.33579e-05
R4882 4068 4069 1.696 0.8 13.568 37
I4069 0 4069 1.32342e-05
R4883 4069 4070 1.632 0.8 13.056 37
I4070 0 4070 1.23684e-05
R4884 4070 0 0.1 49.28 49.28 37
*seg: 408
R4885 0 4071 0.1 49.28 49.28 37
R4886 4075 4085 6.16 0.8 49.28 37
I4071 0 4071 1.23684e-05
R4887 4071 4072 1.696 0.8 13.568 37
I4072 0 4072 1.26158e-05
R4888 4072 4073 1.728 0.8 13.824 37
I4073 0 4073 1.32342e-05
R4889 4073 4074 1.6 0.8 12.8 37
I4074 0 4074 1.29868e-05
R4890 4074 4075 1.616 0.8 12.928 37
I4075 0 4075 1.34816e-05
R4891 4075 4076 1.6 0.8 12.8 37
I4076 0 4076 1.23684e-05
R4892 4076 4077 1.728 0.8 13.824 37
I4077 0 4077 1.26158e-05
R4893 4077 4078 1.712 0.8 13.696 37
I4078 0 4078 1.23684e-05
R4894 4078 4079 1.648 0.8 13.184 37
I4079 0 4079 1.24921e-05
R4895 4079 4080 1.632 0.8 13.056 37
I4080 0 4080 1.23684e-05
R4896 4080 0 0.1 49.28 49.28 37
*seg: 409
R4897 0 4081 0.1 49.28 49.28 37
R4898 4085 4095 6.16 0.8 49.28 37
I4081 0 4081 1.28631e-05
R4899 4081 4082 1.728 0.8 13.824 37
I4082 0 4082 1.28631e-05
R4900 4082 4083 1.664 0.8 13.312 37
I4083 0 4083 1.24921e-05
R4901 4083 4084 1.728 0.8 13.824 37
I4084 0 4084 1.24921e-05
R4902 4084 4085 1.632 0.8 13.056 37
I4085 0 4085 1.31105e-05
R4903 4085 4086 1.632 0.8 13.056 37
I4086 0 4086 1.29868e-05
R4904 4086 4087 1.6 0.8 12.8 37
I4087 0 4087 1.32342e-05
R4905 4087 4088 1.616 0.8 12.928 37
I4088 0 4088 1.26158e-05
R4906 4088 4089 1.648 0.8 13.184 37
I4089 0 4089 1.29868e-05
R4907 4089 4090 1.6 0.8 12.8 37
I4090 0 4090 1.23684e-05
R4908 4090 0 0.1 49.28 49.28 37
*seg: 410
R4909 0 4091 0.1 49.28 49.28 37
R4910 4095 4105 6.16 0.8 49.28 37
I4091 0 4091 1.32342e-05
R4911 4091 4092 1.648 0.8 13.184 37
I4092 0 4092 1.28631e-05
R4912 4092 4093 1.696 0.8 13.568 37
I4093 0 4093 1.27395e-05
R4913 4093 4094 1.696 0.8 13.568 37
I4094 0 4094 1.26158e-05
R4914 4094 4095 1.664 0.8 13.312 37
I4095 0 4095 1.27395e-05
R4915 4095 4096 1.744 0.8 13.952 37
I4096 0 4096 1.31105e-05
R4916 4096 4097 1.648 0.8 13.184 37
I4097 0 4097 1.32342e-05
R4917 4097 4098 1.632 0.8 13.056 37
I4098 0 4098 1.26158e-05
R4918 4098 4099 1.712 0.8 13.696 37
I4099 0 4099 1.27395e-05
R4919 4099 4100 1.712 0.8 13.696 37
I4100 0 4100 1.23684e-05
R4920 4100 0 0.1 49.28 49.28 37
*seg: 411
R4921 0 4101 0.1 49.28 49.28 37
R4922 4105 4115 6.16 0.8 49.28 37
I4101 0 4101 1.29868e-05
R4923 4101 4102 1.632 0.8 13.056 37
I4102 0 4102 1.27395e-05
R4924 4102 4103 1.744 0.8 13.952 37
I4103 0 4103 1.33579e-05
R4925 4103 4104 1.632 0.8 13.056 37
I4104 0 4104 1.32342e-05
R4926 4104 4105 1.68 0.8 13.44 37
I4105 0 4105 1.23684e-05
R4927 4105 4106 1.696 0.8 13.568 37
I4106 0 4106 1.24921e-05
R4928 4106 4107 1.6 0.8 12.8 37
I4107 0 4107 1.31105e-05
R4929 4107 4108 1.696 0.8 13.568 37
I4108 0 4108 1.27395e-05
R4930 4108 4109 1.648 0.8 13.184 37
I4109 0 4109 1.23684e-05
R4931 4109 4110 1.664 0.8 13.312 37
I4110 0 4110 1.23684e-05
R4932 4110 0 0.1 49.28 49.28 37
*seg: 412
R4933 0 4111 0.1 49.28 49.28 37
R4934 4115 4125 6.16 0.8 49.28 37
I4111 0 4111 1.26158e-05
R4935 4111 4112 1.728 0.8 13.824 37
I4112 0 4112 1.24921e-05
R4936 4112 4113 1.632 0.8 13.056 37
I4113 0 4113 1.32342e-05
R4937 4113 4114 1.632 0.8 13.056 37
I4114 0 4114 1.26158e-05
R4938 4114 4115 1.6 0.8 12.8 37
I4115 0 4115 1.34816e-05
R4939 4115 4116 1.6 0.8 12.8 37
I4116 0 4116 1.28631e-05
R4940 4116 4117 1.68 0.8 13.44 37
I4117 0 4117 1.32342e-05
R4941 4117 4118 1.712 0.8 13.696 37
I4118 0 4118 1.26158e-05
R4942 4118 4119 1.696 0.8 13.568 37
I4119 0 4119 1.31105e-05
R4943 4119 4120 1.744 0.8 13.952 37
I4120 0 4120 1.23684e-05
R4944 4120 0 0.1 49.28 49.28 37
*seg: 413
R4945 0 4121 0.1 49.28 49.28 37
R4946 4125 4135 6.16 0.8 49.28 37
I4121 0 4121 1.34816e-05
R4947 4121 4122 1.616 0.8 12.928 37
I4122 0 4122 1.32342e-05
R4948 4122 4123 1.744 0.8 13.952 37
I4123 0 4123 1.32342e-05
R4949 4123 4124 1.728 0.8 13.824 37
I4124 0 4124 1.26158e-05
R4950 4124 4125 1.664 0.8 13.312 37
I4125 0 4125 1.34816e-05
R4951 4125 4126 1.632 0.8 13.056 37
I4126 0 4126 1.26158e-05
R4952 4126 4127 1.6 0.8 12.8 37
I4127 0 4127 1.27395e-05
R4953 4127 4128 1.632 0.8 13.056 37
I4128 0 4128 1.34816e-05
R4954 4128 4129 1.664 0.8 13.312 37
I4129 0 4129 1.31105e-05
R4955 4129 4130 1.648 0.8 13.184 37
I4130 0 4130 1.23684e-05
R4956 4130 0 0.1 49.28 49.28 37
*seg: 414
R4957 0 4131 0.1 49.28 49.28 37
R4958 4135 4145 6.16 0.8 49.28 37
I4131 0 4131 1.29868e-05
R4959 4131 4132 1.712 0.8 13.696 37
I4132 0 4132 1.31105e-05
R4960 4132 4133 1.648 0.8 13.184 37
I4133 0 4133 1.34816e-05
R4961 4133 4134 1.68 0.8 13.44 37
I4134 0 4134 1.28631e-05
R4962 4134 4135 1.616 0.8 12.928 37
I4135 0 4135 1.32342e-05
R4963 4135 4136 1.728 0.8 13.824 37
I4136 0 4136 1.27395e-05
R4964 4136 4137 1.6 0.8 12.8 37
I4137 0 4137 1.23684e-05
R4965 4137 4138 1.744 0.8 13.952 37
I4138 0 4138 1.28631e-05
R4966 4138 4139 1.696 0.8 13.568 37
I4139 0 4139 1.32342e-05
R4967 4139 4140 1.744 0.8 13.952 37
I4140 0 4140 1.23684e-05
R4968 4140 0 0.1 49.28 49.28 37
*seg: 415
R4969 0 4141 0.1 49.28 49.28 37
R4970 4145 4155 6.16 0.8 49.28 37
I4141 0 4141 1.23684e-05
R4971 4141 4142 1.712 0.8 13.696 37
I4142 0 4142 1.28631e-05
R4972 4142 4143 1.616 0.8 12.928 37
I4143 0 4143 1.33579e-05
R4973 4143 4144 1.616 0.8 12.928 37
I4144 0 4144 1.34816e-05
R4974 4144 4145 1.632 0.8 13.056 37
I4145 0 4145 1.26158e-05
R4975 4145 4146 1.632 0.8 13.056 37
I4146 0 4146 1.29868e-05
R4976 4146 4147 1.728 0.8 13.824 37
I4147 0 4147 1.32342e-05
R4977 4147 4148 1.632 0.8 13.056 37
I4148 0 4148 1.33579e-05
R4978 4148 4149 1.744 0.8 13.952 37
I4149 0 4149 1.32342e-05
R4979 4149 4150 1.6 0.8 12.8 37
I4150 0 4150 1.23684e-05
R4980 4150 0 0.1 49.28 49.28 37
*seg: 416
R4981 0 4151 0.1 49.28 49.28 37
R4982 4155 4165 6.16 0.8 49.28 37
I4151 0 4151 1.27395e-05
R4983 4151 4152 1.6 0.8 12.8 37
I4152 0 4152 1.31105e-05
R4984 4152 4153 1.728 0.8 13.824 37
I4153 0 4153 1.27395e-05
R4985 4153 4154 1.648 0.8 13.184 37
I4154 0 4154 1.28631e-05
R4986 4154 4155 1.664 0.8 13.312 37
I4155 0 4155 1.26158e-05
R4987 4155 4156 1.68 0.8 13.44 37
I4156 0 4156 1.29868e-05
R4988 4156 4157 1.744 0.8 13.952 37
I4157 0 4157 1.31105e-05
R4989 4157 4158 1.6 0.8 12.8 37
I4158 0 4158 1.27395e-05
R4990 4158 4159 1.6 0.8 12.8 37
I4159 0 4159 1.24921e-05
R4991 4159 4160 1.616 0.8 12.928 37
I4160 0 4160 1.23684e-05
R4992 4160 0 0.1 49.28 49.28 37
*seg: 417
R4993 0 4161 0.1 49.28 49.28 37
R4994 4165 4175 6.16 0.8 49.28 37
I4161 0 4161 1.28631e-05
R4995 4161 4162 1.616 0.8 12.928 37
I4162 0 4162 1.27395e-05
R4996 4162 4163 1.648 0.8 13.184 37
I4163 0 4163 1.32342e-05
R4997 4163 4164 1.744 0.8 13.952 37
I4164 0 4164 1.23684e-05
R4998 4164 4165 1.664 0.8 13.312 37
I4165 0 4165 1.33579e-05
R4999 4165 4166 1.6 0.8 12.8 37
I4166 0 4166 1.26158e-05
R5000 4166 4167 1.6 0.8 12.8 37
I4167 0 4167 1.29868e-05
R5001 4167 4168 1.744 0.8 13.952 37
I4168 0 4168 1.32342e-05
R5002 4168 4169 1.68 0.8 13.44 37
I4169 0 4169 1.32342e-05
R5003 4169 4170 1.744 0.8 13.952 37
I4170 0 4170 1.23684e-05
R5004 4170 0 0.1 49.28 49.28 37
*seg: 418
R5005 0 4171 0.1 49.28 49.28 37
R5006 4175 4185 6.16 0.8 49.28 37
I4171 0 4171 1.26158e-05
R5007 4171 4172 1.648 0.8 13.184 37
I4172 0 4172 1.29868e-05
R5008 4172 4173 1.728 0.8 13.824 37
I4173 0 4173 1.32342e-05
R5009 4173 4174 1.6 0.8 12.8 37
I4174 0 4174 1.29868e-05
R5010 4174 4175 1.68 0.8 13.44 37
I4175 0 4175 1.34816e-05
R5011 4175 4176 1.6 0.8 12.8 37
I4176 0 4176 1.29868e-05
R5012 4176 4177 1.632 0.8 13.056 37
I4177 0 4177 1.28631e-05
R5013 4177 4178 1.632 0.8 13.056 37
I4178 0 4178 1.29868e-05
R5014 4178 4179 1.712 0.8 13.696 37
I4179 0 4179 1.24921e-05
R5015 4179 4180 1.696 0.8 13.568 37
I4180 0 4180 1.23684e-05
R5016 4180 0 0.1 49.28 49.28 37
*seg: 419
R5017 0 4181 0.1 49.28 49.28 37
R5018 4185 4195 6.16 0.8 49.28 37
I4181 0 4181 1.26158e-05
R5019 4181 4182 1.68 0.8 13.44 37
I4182 0 4182 1.32342e-05
R5020 4182 4183 1.728 0.8 13.824 37
I4183 0 4183 1.31105e-05
R5021 4183 4184 1.664 0.8 13.312 37
I4184 0 4184 1.32342e-05
R5022 4184 4185 1.744 0.8 13.952 37
I4185 0 4185 1.29868e-05
R5023 4185 4186 1.616 0.8 12.928 37
I4186 0 4186 1.33579e-05
R5024 4186 4187 1.632 0.8 13.056 37
I4187 0 4187 1.31105e-05
R5025 4187 4188 1.712 0.8 13.696 37
I4188 0 4188 1.27395e-05
R5026 4188 4189 1.728 0.8 13.824 37
I4189 0 4189 1.26158e-05
R5027 4189 4190 1.648 0.8 13.184 37
I4190 0 4190 1.23684e-05
R5028 4190 0 0.1 49.28 49.28 37
*seg: 420
R5029 0 4191 0.1 49.28 49.28 37
R5030 4195 4205 6.16 0.8 49.28 37
I4191 0 4191 1.27395e-05
R5031 4191 4192 1.648 0.8 13.184 37
I4192 0 4192 1.28631e-05
R5032 4192 4193 1.728 0.8 13.824 37
I4193 0 4193 1.31105e-05
R5033 4193 4194 1.744 0.8 13.952 37
I4194 0 4194 1.33579e-05
R5034 4194 4195 1.696 0.8 13.568 37
I4195 0 4195 1.28631e-05
R5035 4195 4196 1.696 0.8 13.568 37
I4196 0 4196 1.32342e-05
R5036 4196 4197 1.664 0.8 13.312 37
I4197 0 4197 1.32342e-05
R5037 4197 4198 1.648 0.8 13.184 37
I4198 0 4198 1.28631e-05
R5038 4198 4199 1.712 0.8 13.696 37
I4199 0 4199 1.27395e-05
R5039 4199 4200 1.664 0.8 13.312 37
I4200 0 4200 1.23684e-05
R5040 4200 0 0.1 49.28 49.28 37
*seg: 421
R5041 0 4201 0.1 49.28 49.28 37
R5042 4205 4215 6.16 0.8 49.28 37
I4201 0 4201 1.32342e-05
R5043 4201 4202 1.68 0.8 13.44 37
I4202 0 4202 1.24921e-05
R5044 4202 4203 1.712 0.8 13.696 37
I4203 0 4203 1.29868e-05
R5045 4203 4204 1.632 0.8 13.056 37
I4204 0 4204 1.27395e-05
R5046 4204 4205 1.696 0.8 13.568 37
I4205 0 4205 1.29868e-05
R5047 4205 4206 1.648 0.8 13.184 37
I4206 0 4206 1.31105e-05
R5048 4206 4207 1.744 0.8 13.952 37
I4207 0 4207 1.34816e-05
R5049 4207 4208 1.696 0.8 13.568 37
I4208 0 4208 1.34816e-05
R5050 4208 4209 1.664 0.8 13.312 37
I4209 0 4209 1.28631e-05
R5051 4209 4210 1.648 0.8 13.184 37
I4210 0 4210 1.23684e-05
R5052 4210 0 0.1 49.28 49.28 37
*seg: 422
R5053 0 4211 0.1 49.28 49.28 37
R5054 4215 4225 6.16 0.8 49.28 37
I4211 0 4211 1.32342e-05
R5055 4211 4212 1.744 0.8 13.952 37
I4212 0 4212 1.26158e-05
R5056 4212 4213 1.712 0.8 13.696 37
I4213 0 4213 1.29868e-05
R5057 4213 4214 1.68 0.8 13.44 37
I4214 0 4214 1.24921e-05
R5058 4214 4215 1.648 0.8 13.184 37
I4215 0 4215 1.29868e-05
R5059 4215 4216 1.728 0.8 13.824 37
I4216 0 4216 1.32342e-05
R5060 4216 4217 1.664 0.8 13.312 37
I4217 0 4217 1.23684e-05
R5061 4217 4218 1.6 0.8 12.8 37
I4218 0 4218 1.29868e-05
R5062 4218 4219 1.728 0.8 13.824 37
I4219 0 4219 1.27395e-05
R5063 4219 4220 1.648 0.8 13.184 37
I4220 0 4220 1.23684e-05
R5064 4220 0 0.1 49.28 49.28 37
*seg: 423
R5065 0 4221 0.1 49.28 49.28 37
R5066 4225 4235 6.16 0.8 49.28 37
I4221 0 4221 1.34816e-05
R5067 4221 4222 1.648 0.8 13.184 37
I4222 0 4222 1.29868e-05
R5068 4222 4223 1.6 0.8 12.8 37
I4223 0 4223 1.28631e-05
R5069 4223 4224 1.648 0.8 13.184 37
I4224 0 4224 1.32342e-05
R5070 4224 4225 1.664 0.8 13.312 37
I4225 0 4225 1.34816e-05
R5071 4225 4226 1.728 0.8 13.824 37
I4226 0 4226 1.33579e-05
R5072 4226 4227 1.664 0.8 13.312 37
I4227 0 4227 1.23684e-05
R5073 4227 4228 1.6 0.8 12.8 37
I4228 0 4228 1.24921e-05
R5074 4228 4229 1.632 0.8 13.056 37
I4229 0 4229 1.24921e-05
R5075 4229 4230 1.664 0.8 13.312 37
I4230 0 4230 1.23684e-05
R5076 4230 0 0.1 49.28 49.28 37
*seg: 424
R5077 0 4231 0.1 49.28 49.28 37
R5078 4235 4245 6.16 0.8 49.28 37
I4231 0 4231 1.29868e-05
R5079 4231 4232 1.728 0.8 13.824 37
I4232 0 4232 1.29868e-05
R5080 4232 4233 1.68 0.8 13.44 37
I4233 0 4233 1.31105e-05
R5081 4233 4234 1.616 0.8 12.928 37
I4234 0 4234 1.31105e-05
R5082 4234 4235 1.712 0.8 13.696 37
I4235 0 4235 1.27395e-05
R5083 4235 4236 1.744 0.8 13.952 37
I4236 0 4236 1.34816e-05
R5084 4236 4237 1.6 0.8 12.8 37
I4237 0 4237 1.24921e-05
R5085 4237 4238 1.696 0.8 13.568 37
I4238 0 4238 1.28631e-05
R5086 4238 4239 1.648 0.8 13.184 37
I4239 0 4239 1.28631e-05
R5087 4239 4240 1.6 0.8 12.8 37
I4240 0 4240 1.23684e-05
R5088 4240 0 0.1 49.28 49.28 37
*seg: 425
R5089 0 4241 0.1 49.28 49.28 37
R5090 4245 4255 6.16 0.8 49.28 37
I4241 0 4241 1.24921e-05
R5091 4241 4242 1.696 0.8 13.568 37
I4242 0 4242 1.29868e-05
R5092 4242 4243 1.648 0.8 13.184 37
I4243 0 4243 1.33579e-05
R5093 4243 4244 1.744 0.8 13.952 37
I4244 0 4244 1.31105e-05
R5094 4244 4245 1.744 0.8 13.952 37
I4245 0 4245 1.31105e-05
R5095 4245 4246 1.664 0.8 13.312 37
I4246 0 4246 1.26158e-05
R5096 4246 4247 1.616 0.8 12.928 37
I4247 0 4247 1.23684e-05
R5097 4247 4248 1.696 0.8 13.568 37
I4248 0 4248 1.27395e-05
R5098 4248 4249 1.616 0.8 12.928 37
I4249 0 4249 1.33579e-05
R5099 4249 4250 1.68 0.8 13.44 37
I4250 0 4250 1.23684e-05
R5100 4250 0 0.1 49.28 49.28 37
*seg: 426
R5101 0 4251 0.1 49.28 49.28 37
R5102 4255 4265 6.16 0.8 49.28 37
I4251 0 4251 1.34816e-05
R5103 4251 4252 1.664 0.8 13.312 37
I4252 0 4252 1.34816e-05
R5104 4252 4253 1.68 0.8 13.44 37
I4253 0 4253 1.32342e-05
R5105 4253 4254 1.728 0.8 13.824 37
I4254 0 4254 1.29868e-05
R5106 4254 4255 1.632 0.8 13.056 37
I4255 0 4255 1.27395e-05
R5107 4255 4256 1.664 0.8 13.312 37
I4256 0 4256 1.26158e-05
R5108 4256 4257 1.648 0.8 13.184 37
I4257 0 4257 1.26158e-05
R5109 4257 4258 1.744 0.8 13.952 37
I4258 0 4258 1.26158e-05
R5110 4258 4259 1.68 0.8 13.44 37
I4259 0 4259 1.28631e-05
R5111 4259 4260 1.664 0.8 13.312 37
I4260 0 4260 1.23684e-05
R5112 4260 0 0.1 49.28 49.28 37
*seg: 427
R5113 0 4261 0.1 49.28 49.28 37
R5114 4265 4275 6.16 0.8 49.28 37
I4261 0 4261 1.28631e-05
R5115 4261 4262 1.6 0.8 12.8 37
I4262 0 4262 1.26158e-05
R5116 4262 4263 1.664 0.8 13.312 37
I4263 0 4263 1.26158e-05
R5117 4263 4264 1.664 0.8 13.312 37
I4264 0 4264 1.31105e-05
R5118 4264 4265 1.664 0.8 13.312 37
I4265 0 4265 1.32342e-05
R5119 4265 4266 1.648 0.8 13.184 37
I4266 0 4266 1.26158e-05
R5120 4266 4267 1.712 0.8 13.696 37
I4267 0 4267 1.26158e-05
R5121 4267 4268 1.696 0.8 13.568 37
I4268 0 4268 1.28631e-05
R5122 4268 4269 1.68 0.8 13.44 37
I4269 0 4269 1.26158e-05
R5123 4269 4270 1.68 0.8 13.44 37
I4270 0 4270 1.23684e-05
R5124 4270 0 0.1 49.28 49.28 37
*seg: 428
R5125 0 4271 0.1 49.28 49.28 37
R5126 4275 4285 6.16 0.8 49.28 37
I4271 0 4271 1.33579e-05
R5127 4271 4272 1.712 0.8 13.696 37
I4272 0 4272 1.23684e-05
R5128 4272 4273 1.664 0.8 13.312 37
I4273 0 4273 1.28631e-05
R5129 4273 4274 1.696 0.8 13.568 37
I4274 0 4274 1.31105e-05
R5130 4274 4275 1.728 0.8 13.824 37
I4275 0 4275 1.28631e-05
R5131 4275 4276 1.744 0.8 13.952 37
I4276 0 4276 1.23684e-05
R5132 4276 4277 1.712 0.8 13.696 37
I4277 0 4277 1.33579e-05
R5133 4277 4278 1.648 0.8 13.184 37
I4278 0 4278 1.34816e-05
R5134 4278 4279 1.6 0.8 12.8 37
I4279 0 4279 1.33579e-05
R5135 4279 4280 1.744 0.8 13.952 37
I4280 0 4280 1.23684e-05
R5136 4280 0 0.1 49.28 49.28 37
*seg: 429
R5137 0 4281 0.1 49.28 49.28 37
R5138 4285 4295 6.16 0.8 49.28 37
I4281 0 4281 1.32342e-05
R5139 4281 4282 1.616 0.8 12.928 37
I4282 0 4282 1.29868e-05
R5140 4282 4283 1.6 0.8 12.8 37
I4283 0 4283 1.33579e-05
R5141 4283 4284 1.728 0.8 13.824 37
I4284 0 4284 1.34816e-05
R5142 4284 4285 1.616 0.8 12.928 37
I4285 0 4285 1.34816e-05
R5143 4285 4286 1.744 0.8 13.952 37
I4286 0 4286 1.23684e-05
R5144 4286 4287 1.728 0.8 13.824 37
I4287 0 4287 1.23684e-05
R5145 4287 4288 1.6 0.8 12.8 37
I4288 0 4288 1.28631e-05
R5146 4288 4289 1.648 0.8 13.184 37
I4289 0 4289 1.26158e-05
R5147 4289 4290 1.648 0.8 13.184 37
I4290 0 4290 1.23684e-05
R5148 4290 0 0.1 49.28 49.28 37
*seg: 430
R5149 0 4291 0.1 49.28 49.28 37
R5150 4295 4305 6.16 0.8 49.28 37
I4291 0 4291 1.24921e-05
R5151 4291 4292 1.664 0.8 13.312 37
I4292 0 4292 1.23684e-05
R5152 4292 4293 1.648 0.8 13.184 37
I4293 0 4293 1.32342e-05
R5153 4293 4294 1.696 0.8 13.568 37
I4294 0 4294 1.28631e-05
R5154 4294 4295 1.648 0.8 13.184 37
I4295 0 4295 1.34816e-05
R5155 4295 4296 1.696 0.8 13.568 37
I4296 0 4296 1.28631e-05
R5156 4296 4297 1.664 0.8 13.312 37
I4297 0 4297 1.32342e-05
R5157 4297 4298 1.616 0.8 12.928 37
I4298 0 4298 1.29868e-05
R5158 4298 4299 1.728 0.8 13.824 37
I4299 0 4299 1.33579e-05
R5159 4299 4300 1.616 0.8 12.928 37
I4300 0 4300 1.23684e-05
R5160 4300 0 0.1 49.28 49.28 37
*seg: 431
R5161 0 4301 0.1 49.28 49.28 37
R5162 4305 4315 6.16 0.8 49.28 37
I4301 0 4301 1.27395e-05
R5163 4301 4302 1.728 0.8 13.824 37
I4302 0 4302 1.33579e-05
R5164 4302 4303 1.744 0.8 13.952 37
I4303 0 4303 1.33579e-05
R5165 4303 4304 1.632 0.8 13.056 37
I4304 0 4304 1.31105e-05
R5166 4304 4305 1.68 0.8 13.44 37
I4305 0 4305 1.29868e-05
R5167 4305 4306 1.696 0.8 13.568 37
I4306 0 4306 1.28631e-05
R5168 4306 4307 1.632 0.8 13.056 37
I4307 0 4307 1.24921e-05
R5169 4307 4308 1.632 0.8 13.056 37
I4308 0 4308 1.28631e-05
R5170 4308 4309 1.6 0.8 12.8 37
I4309 0 4309 1.28631e-05
R5171 4309 4310 1.68 0.8 13.44 37
I4310 0 4310 1.23684e-05
R5172 4310 0 0.1 49.28 49.28 37
*seg: 432
R5173 0 4311 0.1 49.28 49.28 37
R5174 4315 4325 6.16 0.8 49.28 37
I4311 0 4311 1.27395e-05
R5175 4311 4312 1.728 0.8 13.824 37
I4312 0 4312 1.26158e-05
R5176 4312 4313 1.696 0.8 13.568 37
I4313 0 4313 1.28631e-05
R5177 4313 4314 1.616 0.8 12.928 37
I4314 0 4314 1.28631e-05
R5178 4314 4315 1.68 0.8 13.44 37
I4315 0 4315 1.26158e-05
R5179 4315 4316 1.744 0.8 13.952 37
I4316 0 4316 1.33579e-05
R5180 4316 4317 1.648 0.8 13.184 37
I4317 0 4317 1.27395e-05
R5181 4317 4318 1.6 0.8 12.8 37
I4318 0 4318 1.33579e-05
R5182 4318 4319 1.696 0.8 13.568 37
I4319 0 4319 1.27395e-05
R5183 4319 4320 1.744 0.8 13.952 37
I4320 0 4320 1.23684e-05
R5184 4320 0 0.1 49.28 49.28 37
*seg: 433
R5185 0 4321 0.1 49.28 49.28 37
R5186 4325 4335 6.16 0.8 49.28 37
I4321 0 4321 1.24921e-05
R5187 4321 4322 1.664 0.8 13.312 37
I4322 0 4322 1.26158e-05
R5188 4322 4323 1.728 0.8 13.824 37
I4323 0 4323 1.31105e-05
R5189 4323 4324 1.696 0.8 13.568 37
I4324 0 4324 1.29868e-05
R5190 4324 4325 1.632 0.8 13.056 37
I4325 0 4325 1.28631e-05
R5191 4325 4326 1.6 0.8 12.8 37
I4326 0 4326 1.28631e-05
R5192 4326 4327 1.664 0.8 13.312 37
I4327 0 4327 1.34816e-05
R5193 4327 4328 1.632 0.8 13.056 37
I4328 0 4328 1.32342e-05
R5194 4328 4329 1.68 0.8 13.44 37
I4329 0 4329 1.28631e-05
R5195 4329 4330 1.616 0.8 12.928 37
I4330 0 4330 1.23684e-05
R5196 4330 0 0.1 49.28 49.28 37
*seg: 434
R5197 0 4331 0.1 49.28 49.28 37
R5198 4335 4345 6.16 0.8 49.28 37
I4331 0 4331 1.34816e-05
R5199 4331 4332 1.744 0.8 13.952 37
I4332 0 4332 1.29868e-05
R5200 4332 4333 1.6 0.8 12.8 37
I4333 0 4333 1.32342e-05
R5201 4333 4334 1.632 0.8 13.056 37
I4334 0 4334 1.32342e-05
R5202 4334 4335 1.744 0.8 13.952 37
I4335 0 4335 1.34816e-05
R5203 4335 4336 1.744 0.8 13.952 37
I4336 0 4336 1.31105e-05
R5204 4336 4337 1.616 0.8 12.928 37
I4337 0 4337 1.31105e-05
R5205 4337 4338 1.712 0.8 13.696 37
I4338 0 4338 1.29868e-05
R5206 4338 4339 1.728 0.8 13.824 37
I4339 0 4339 1.29868e-05
R5207 4339 4340 1.648 0.8 13.184 37
I4340 0 4340 1.23684e-05
R5208 4340 0 0.1 49.28 49.28 37
*seg: 435
R5209 0 4341 0.1 49.28 49.28 37
R5210 4345 4355 6.16 0.8 49.28 37
I4341 0 4341 1.27395e-05
R5211 4341 4342 1.712 0.8 13.696 37
I4342 0 4342 1.28631e-05
R5212 4342 4343 1.6 0.8 12.8 37
I4343 0 4343 1.29868e-05
R5213 4343 4344 1.632 0.8 13.056 37
I4344 0 4344 1.23684e-05
R5214 4344 4345 1.664 0.8 13.312 37
I4345 0 4345 1.29868e-05
R5215 4345 4346 1.712 0.8 13.696 37
I4346 0 4346 1.26158e-05
R5216 4346 4347 1.616 0.8 12.928 37
I4347 0 4347 1.29868e-05
R5217 4347 4348 1.744 0.8 13.952 37
I4348 0 4348 1.24921e-05
R5218 4348 4349 1.728 0.8 13.824 37
I4349 0 4349 1.34816e-05
R5219 4349 4350 1.696 0.8 13.568 37
I4350 0 4350 1.23684e-05
R5220 4350 0 0.1 49.28 49.28 37
*seg: 436
R5221 0 4351 0.1 49.28 49.28 37
R5222 4355 4365 6.16 0.8 49.28 37
I4351 0 4351 1.24921e-05
R5223 4351 4352 1.68 0.8 13.44 37
I4352 0 4352 1.34816e-05
R5224 4352 4353 1.6 0.8 12.8 37
I4353 0 4353 1.27395e-05
R5225 4353 4354 1.632 0.8 13.056 37
I4354 0 4354 1.33579e-05
R5226 4354 4355 1.728 0.8 13.824 37
I4355 0 4355 1.29868e-05
R5227 4355 4356 1.68 0.8 13.44 37
I4356 0 4356 1.31105e-05
R5228 4356 4357 1.616 0.8 12.928 37
I4357 0 4357 1.31105e-05
R5229 4357 4358 1.68 0.8 13.44 37
I4358 0 4358 1.33579e-05
R5230 4358 4359 1.664 0.8 13.312 37
I4359 0 4359 1.24921e-05
R5231 4359 4360 1.664 0.8 13.312 37
I4360 0 4360 1.23684e-05
R5232 4360 0 0.1 49.28 49.28 37
*seg: 437
R5233 0 4361 0.1 49.28 49.28 37
R5234 4365 4375 6.16 0.8 49.28 37
I4361 0 4361 1.24921e-05
R5235 4361 4362 1.648 0.8 13.184 37
I4362 0 4362 1.23684e-05
R5236 4362 4363 1.6 0.8 12.8 37
I4363 0 4363 1.33579e-05
R5237 4363 4364 1.6 0.8 12.8 37
I4364 0 4364 1.24921e-05
R5238 4364 4365 1.632 0.8 13.056 37
I4365 0 4365 1.24921e-05
R5239 4365 4366 1.68 0.8 13.44 37
I4366 0 4366 1.29868e-05
R5240 4366 4367 1.616 0.8 12.928 37
I4367 0 4367 1.28631e-05
R5241 4367 4368 1.712 0.8 13.696 37
I4368 0 4368 1.26158e-05
R5242 4368 4369 1.664 0.8 13.312 37
I4369 0 4369 1.28631e-05
R5243 4369 4370 1.632 0.8 13.056 37
I4370 0 4370 1.23684e-05
R5244 4370 0 0.1 49.28 49.28 37
*seg: 438
R5245 0 4371 0.1 49.28 49.28 37
R5246 4375 4385 6.16 0.8 49.28 37
I4371 0 4371 1.28631e-05
R5247 4371 4372 1.632 0.8 13.056 37
I4372 0 4372 1.27395e-05
R5248 4372 4373 1.6 0.8 12.8 37
I4373 0 4373 1.33579e-05
R5249 4373 4374 1.728 0.8 13.824 37
I4374 0 4374 1.26158e-05
R5250 4374 4375 1.696 0.8 13.568 37
I4375 0 4375 1.34816e-05
R5251 4375 4376 1.632 0.8 13.056 37
I4376 0 4376 1.26158e-05
R5252 4376 4377 1.6 0.8 12.8 37
I4377 0 4377 1.24921e-05
R5253 4377 4378 1.744 0.8 13.952 37
I4378 0 4378 1.23684e-05
R5254 4378 4379 1.664 0.8 13.312 37
I4379 0 4379 1.28631e-05
R5255 4379 4380 1.6 0.8 12.8 37
I4380 0 4380 1.23684e-05
R5256 4380 0 0.1 49.28 49.28 37
*seg: 439
R5257 0 4381 0.1 49.28 49.28 37
R5258 4385 4395 6.16 0.8 49.28 37
I4381 0 4381 1.29868e-05
R5259 4381 4382 1.68 0.8 13.44 37
I4382 0 4382 1.23684e-05
R5260 4382 4383 1.712 0.8 13.696 37
I4383 0 4383 1.23684e-05
R5261 4383 4384 1.68 0.8 13.44 37
I4384 0 4384 1.28631e-05
R5262 4384 4385 1.744 0.8 13.952 37
I4385 0 4385 1.32342e-05
R5263 4385 4386 1.728 0.8 13.824 37
I4386 0 4386 1.29868e-05
R5264 4386 4387 1.728 0.8 13.824 37
I4387 0 4387 1.33579e-05
R5265 4387 4388 1.632 0.8 13.056 37
I4388 0 4388 1.26158e-05
R5266 4388 4389 1.744 0.8 13.952 37
I4389 0 4389 1.29868e-05
R5267 4389 4390 1.68 0.8 13.44 37
I4390 0 4390 1.23684e-05
R5268 4390 0 0.1 49.28 49.28 37
*seg: 440
R5269 0 4391 0.1 49.28 49.28 37
R5270 4395 4405 6.16 0.8 49.28 37
I4391 0 4391 1.24921e-05
R5271 4391 4392 1.6 0.8 12.8 37
I4392 0 4392 1.33579e-05
R5272 4392 4393 1.664 0.8 13.312 37
I4393 0 4393 1.31105e-05
R5273 4393 4394 1.728 0.8 13.824 37
I4394 0 4394 1.34816e-05
R5274 4394 4395 1.6 0.8 12.8 37
I4395 0 4395 1.34816e-05
R5275 4395 4396 1.616 0.8 12.928 37
I4396 0 4396 1.33579e-05
R5276 4396 4397 1.744 0.8 13.952 37
I4397 0 4397 1.24921e-05
R5277 4397 4398 1.6 0.8 12.8 37
I4398 0 4398 1.29868e-05
R5278 4398 4399 1.648 0.8 13.184 37
I4399 0 4399 1.32342e-05
R5279 4399 4400 1.664 0.8 13.312 37
I4400 0 4400 1.23684e-05
R5280 4400 0 0.1 49.28 49.28 37
*seg: 441
R5281 0 4401 0.1 49.28 49.28 37
R5282 4405 4415 6.16 0.8 49.28 37
I4401 0 4401 1.24921e-05
R5283 4401 4402 1.728 0.8 13.824 37
I4402 0 4402 1.33579e-05
R5284 4402 4403 1.664 0.8 13.312 37
I4403 0 4403 1.23684e-05
R5285 4403 4404 1.6 0.8 12.8 37
I4404 0 4404 1.32342e-05
R5286 4404 4405 1.68 0.8 13.44 37
I4405 0 4405 1.29868e-05
R5287 4405 4406 1.744 0.8 13.952 37
I4406 0 4406 1.34816e-05
R5288 4406 4407 1.728 0.8 13.824 37
I4407 0 4407 1.33579e-05
R5289 4407 4408 1.6 0.8 12.8 37
I4408 0 4408 1.31105e-05
R5290 4408 4409 1.664 0.8 13.312 37
I4409 0 4409 1.28631e-05
R5291 4409 4410 1.664 0.8 13.312 37
I4410 0 4410 1.23684e-05
R5292 4410 0 0.1 49.28 49.28 37
*seg: 442
R5293 0 4411 0.1 49.28 49.28 37
R5294 4415 4425 6.16 0.8 49.28 37
I4411 0 4411 1.33579e-05
R5295 4411 4412 1.68 0.8 13.44 37
I4412 0 4412 1.23684e-05
R5296 4412 4413 1.648 0.8 13.184 37
I4413 0 4413 1.29868e-05
R5297 4413 4414 1.648 0.8 13.184 37
I4414 0 4414 1.33579e-05
R5298 4414 4415 1.648 0.8 13.184 37
I4415 0 4415 1.26158e-05
R5299 4415 4416 1.68 0.8 13.44 37
I4416 0 4416 1.32342e-05
R5300 4416 4417 1.68 0.8 13.44 37
I4417 0 4417 1.34816e-05
R5301 4417 4418 1.632 0.8 13.056 37
I4418 0 4418 1.31105e-05
R5302 4418 4419 1.616 0.8 12.928 37
I4419 0 4419 1.32342e-05
R5303 4419 4420 1.6 0.8 12.8 37
I4420 0 4420 1.23684e-05
R5304 4420 0 0.1 49.28 49.28 37
*seg: 443
R5305 0 4421 0.1 49.28 49.28 37
R5306 4425 4435 6.16 0.8 49.28 37
I4421 0 4421 1.29868e-05
R5307 4421 4422 1.664 0.8 13.312 37
I4422 0 4422 1.28631e-05
R5308 4422 4423 1.728 0.8 13.824 37
I4423 0 4423 1.27395e-05
R5309 4423 4424 1.696 0.8 13.568 37
I4424 0 4424 1.32342e-05
R5310 4424 4425 1.728 0.8 13.824 37
I4425 0 4425 1.24921e-05
R5311 4425 4426 1.744 0.8 13.952 37
I4426 0 4426 1.32342e-05
R5312 4426 4427 1.6 0.8 12.8 37
I4427 0 4427 1.33579e-05
R5313 4427 4428 1.664 0.8 13.312 37
I4428 0 4428 1.33579e-05
R5314 4428 4429 1.616 0.8 12.928 37
I4429 0 4429 1.29868e-05
R5315 4429 4430 1.616 0.8 12.928 37
I4430 0 4430 1.23684e-05
R5316 4430 0 0.1 49.28 49.28 37
*seg: 444
R5317 0 4431 0.1 49.28 49.28 37
R5318 4435 4445 6.16 0.8 49.28 37
I4431 0 4431 1.26158e-05
R5319 4431 4432 1.744 0.8 13.952 37
I4432 0 4432 1.31105e-05
R5320 4432 4433 1.728 0.8 13.824 37
I4433 0 4433 1.31105e-05
R5321 4433 4434 1.712 0.8 13.696 37
I4434 0 4434 1.34816e-05
R5322 4434 4435 1.68 0.8 13.44 37
I4435 0 4435 1.29868e-05
R5323 4435 4436 1.664 0.8 13.312 37
I4436 0 4436 1.26158e-05
R5324 4436 4437 1.744 0.8 13.952 37
I4437 0 4437 1.29868e-05
R5325 4437 4438 1.632 0.8 13.056 37
I4438 0 4438 1.34816e-05
R5326 4438 4439 1.712 0.8 13.696 37
I4439 0 4439 1.27395e-05
R5327 4439 4440 1.648 0.8 13.184 37
I4440 0 4440 1.23684e-05
R5328 4440 0 0.1 49.28 49.28 37
*seg: 445
R5329 0 4441 0.1 49.28 49.28 37
R5330 4445 4455 6.16 0.8 49.28 37
I4441 0 4441 1.28631e-05
R5331 4441 4442 1.632 0.8 13.056 37
I4442 0 4442 1.23684e-05
R5332 4442 4443 1.68 0.8 13.44 37
I4443 0 4443 1.23684e-05
R5333 4443 4444 1.6 0.8 12.8 37
I4444 0 4444 1.23684e-05
R5334 4444 4445 1.744 0.8 13.952 37
I4445 0 4445 1.34816e-05
R5335 4445 4446 1.616 0.8 12.928 37
I4446 0 4446 1.34816e-05
R5336 4446 4447 1.68 0.8 13.44 37
I4447 0 4447 1.31105e-05
R5337 4447 4448 1.744 0.8 13.952 37
I4448 0 4448 1.31105e-05
R5338 4448 4449 1.616 0.8 12.928 37
I4449 0 4449 1.23684e-05
R5339 4449 4450 1.696 0.8 13.568 37
I4450 0 4450 1.23684e-05
R5340 4450 0 0.1 49.28 49.28 37
*seg: 446
R5341 0 4451 0.1 49.28 49.28 37
R5342 4455 4465 6.16 0.8 49.28 37
I4451 0 4451 1.26158e-05
R5343 4451 4452 1.632 0.8 13.056 37
I4452 0 4452 1.24921e-05
R5344 4452 4453 1.68 0.8 13.44 37
I4453 0 4453 1.33579e-05
R5345 4453 4454 1.728 0.8 13.824 37
I4454 0 4454 1.27395e-05
R5346 4454 4455 1.648 0.8 13.184 37
I4455 0 4455 1.26158e-05
R5347 4455 4456 1.712 0.8 13.696 37
I4456 0 4456 1.29868e-05
R5348 4456 4457 1.728 0.8 13.824 37
I4457 0 4457 1.32342e-05
R5349 4457 4458 1.664 0.8 13.312 37
I4458 0 4458 1.31105e-05
R5350 4458 4459 1.68 0.8 13.44 37
I4459 0 4459 1.31105e-05
R5351 4459 4460 1.6 0.8 12.8 37
I4460 0 4460 1.23684e-05
R5352 4460 0 0.1 49.28 49.28 37
*seg: 447
R5353 0 4461 0.1 49.28 49.28 37
R5354 4465 4475 6.16 0.8 49.28 37
I4461 0 4461 1.24921e-05
R5355 4461 4462 1.6 0.8 12.8 37
I4462 0 4462 1.29868e-05
R5356 4462 4463 1.616 0.8 12.928 37
I4463 0 4463 1.29868e-05
R5357 4463 4464 1.616 0.8 12.928 37
I4464 0 4464 1.33579e-05
R5358 4464 4465 1.6 0.8 12.8 37
I4465 0 4465 1.33579e-05
R5359 4465 4466 1.696 0.8 13.568 37
I4466 0 4466 1.26158e-05
R5360 4466 4467 1.68 0.8 13.44 37
I4467 0 4467 1.27395e-05
R5361 4467 4468 1.728 0.8 13.824 37
I4468 0 4468 1.23684e-05
R5362 4468 4469 1.632 0.8 13.056 37
I4469 0 4469 1.29868e-05
R5363 4469 4470 1.632 0.8 13.056 37
I4470 0 4470 1.23684e-05
R5364 4470 0 0.1 49.28 49.28 37
*seg: 448
R5365 0 4471 0.1 49.28 49.28 37
R5366 4475 4485 6.16 0.8 49.28 37
I4471 0 4471 1.26158e-05
R5367 4471 4472 1.6 0.8 12.8 37
I4472 0 4472 1.24921e-05
R5368 4472 4473 1.6 0.8 12.8 37
I4473 0 4473 1.28631e-05
R5369 4473 4474 1.744 0.8 13.952 37
I4474 0 4474 1.34816e-05
R5370 4474 4475 1.632 0.8 13.056 37
I4475 0 4475 1.28631e-05
R5371 4475 4476 1.68 0.8 13.44 37
I4476 0 4476 1.34816e-05
R5372 4476 4477 1.648 0.8 13.184 37
I4477 0 4477 1.32342e-05
R5373 4477 4478 1.664 0.8 13.312 37
I4478 0 4478 1.29868e-05
R5374 4478 4479 1.632 0.8 13.056 37
I4479 0 4479 1.31105e-05
R5375 4479 4480 1.712 0.8 13.696 37
I4480 0 4480 1.23684e-05
R5376 4480 0 0.1 49.28 49.28 37
*seg: 449
R5377 0 4481 0.1 49.28 49.28 37
R5378 4485 4495 6.16 0.8 49.28 37
I4481 0 4481 1.33579e-05
R5379 4481 4482 1.664 0.8 13.312 37
I4482 0 4482 1.27395e-05
R5380 4482 4483 1.664 0.8 13.312 37
I4483 0 4483 1.27395e-05
R5381 4483 4484 1.68 0.8 13.44 37
I4484 0 4484 1.32342e-05
R5382 4484 4485 1.712 0.8 13.696 37
I4485 0 4485 1.27395e-05
R5383 4485 4486 1.744 0.8 13.952 37
I4486 0 4486 1.31105e-05
R5384 4486 4487 1.712 0.8 13.696 37
I4487 0 4487 1.32342e-05
R5385 4487 4488 1.728 0.8 13.824 37
I4488 0 4488 1.26158e-05
R5386 4488 4489 1.744 0.8 13.952 37
I4489 0 4489 1.29868e-05
R5387 4489 4490 1.68 0.8 13.44 37
I4490 0 4490 1.23684e-05
R5388 4490 0 0.1 49.28 49.28 37
*seg: 450
R5389 0 4491 0.1 49.28 49.28 37
R5390 4495 4505 6.16 0.8 49.28 37
I4491 0 4491 1.33579e-05
R5391 4491 4492 1.712 0.8 13.696 37
I4492 0 4492 1.32342e-05
R5392 4492 4493 1.648 0.8 13.184 37
I4493 0 4493 1.32342e-05
R5393 4493 4494 1.712 0.8 13.696 37
I4494 0 4494 1.29868e-05
R5394 4494 4495 1.728 0.8 13.824 37
I4495 0 4495 1.32342e-05
R5395 4495 4496 1.696 0.8 13.568 37
I4496 0 4496 1.33579e-05
R5396 4496 4497 1.712 0.8 13.696 37
I4497 0 4497 1.23684e-05
R5397 4497 4498 1.744 0.8 13.952 37
I4498 0 4498 1.32342e-05
R5398 4498 4499 1.744 0.8 13.952 37
I4499 0 4499 1.33579e-05
R5399 4499 4500 1.696 0.8 13.568 37
I4500 0 4500 1.23684e-05
R5400 4500 0 0.1 49.28 49.28 37
*seg: 451
R5401 0 4501 0.1 49.28 49.28 37
R5402 4505 4515 6.16 0.8 49.28 37
I4501 0 4501 1.27395e-05
R5403 4501 4502 1.6 0.8 12.8 37
I4502 0 4502 1.29868e-05
R5404 4502 4503 1.616 0.8 12.928 37
I4503 0 4503 1.26158e-05
R5405 4503 4504 1.68 0.8 13.44 37
I4504 0 4504 1.34816e-05
R5406 4504 4505 1.616 0.8 12.928 37
I4505 0 4505 1.28631e-05
R5407 4505 4506 1.696 0.8 13.568 37
I4506 0 4506 1.31105e-05
R5408 4506 4507 1.664 0.8 13.312 37
I4507 0 4507 1.34816e-05
R5409 4507 4508 1.728 0.8 13.824 37
I4508 0 4508 1.32342e-05
R5410 4508 4509 1.744 0.8 13.952 37
I4509 0 4509 1.31105e-05
R5411 4509 4510 1.632 0.8 13.056 37
I4510 0 4510 1.23684e-05
R5412 4510 0 0.1 49.28 49.28 37
*seg: 452
R5413 0 4511 0.1 49.28 49.28 37
R5414 4515 4525 6.16 0.8 49.28 37
I4511 0 4511 1.24921e-05
R5415 4511 4512 1.696 0.8 13.568 37
I4512 0 4512 1.31105e-05
R5416 4512 4513 1.68 0.8 13.44 37
I4513 0 4513 1.26158e-05
R5417 4513 4514 1.648 0.8 13.184 37
I4514 0 4514 1.34816e-05
R5418 4514 4515 1.6 0.8 12.8 37
I4515 0 4515 1.23684e-05
R5419 4515 4516 1.728 0.8 13.824 37
I4516 0 4516 1.28631e-05
R5420 4516 4517 1.712 0.8 13.696 37
I4517 0 4517 1.31105e-05
R5421 4517 4518 1.696 0.8 13.568 37
I4518 0 4518 1.26158e-05
R5422 4518 4519 1.648 0.8 13.184 37
I4519 0 4519 1.23684e-05
R5423 4519 4520 1.744 0.8 13.952 37
I4520 0 4520 1.23684e-05
R5424 4520 0 0.1 49.28 49.28 37
*seg: 453
R5425 0 4521 0.1 49.28 49.28 37
R5426 4525 4535 6.16 0.8 49.28 37
I4521 0 4521 1.27395e-05
R5427 4521 4522 1.696 0.8 13.568 37
I4522 0 4522 1.33579e-05
R5428 4522 4523 1.664 0.8 13.312 37
I4523 0 4523 1.29868e-05
R5429 4523 4524 1.68 0.8 13.44 37
I4524 0 4524 1.34816e-05
R5430 4524 4525 1.712 0.8 13.696 37
I4525 0 4525 1.31105e-05
R5431 4525 4526 1.728 0.8 13.824 37
I4526 0 4526 1.28631e-05
R5432 4526 4527 1.68 0.8 13.44 37
I4527 0 4527 1.33579e-05
R5433 4527 4528 1.68 0.8 13.44 37
I4528 0 4528 1.23684e-05
R5434 4528 4529 1.728 0.8 13.824 37
I4529 0 4529 1.24921e-05
R5435 4529 4530 1.664 0.8 13.312 37
I4530 0 4530 1.23684e-05
R5436 4530 0 0.1 49.28 49.28 37
*seg: 454
R5437 0 4531 0.1 49.28 49.28 37
R5438 4535 4545 6.16 0.8 49.28 37
I4531 0 4531 1.29868e-05
R5439 4531 4532 1.68 0.8 13.44 37
I4532 0 4532 1.23684e-05
R5440 4532 4533 1.68 0.8 13.44 37
I4533 0 4533 1.33579e-05
R5441 4533 4534 1.664 0.8 13.312 37
I4534 0 4534 1.26158e-05
R5442 4534 4535 1.712 0.8 13.696 37
I4535 0 4535 1.33579e-05
R5443 4535 4536 1.6 0.8 12.8 37
I4536 0 4536 1.24921e-05
R5444 4536 4537 1.664 0.8 13.312 37
I4537 0 4537 1.32342e-05
R5445 4537 4538 1.664 0.8 13.312 37
I4538 0 4538 1.33579e-05
R5446 4538 4539 1.616 0.8 12.928 37
I4539 0 4539 1.34816e-05
R5447 4539 4540 1.616 0.8 12.928 37
I4540 0 4540 1.23684e-05
R5448 4540 0 0.1 49.28 49.28 37
*seg: 455
R5449 0 4541 0.1 49.28 49.28 37
R5450 4545 4555 6.16 0.8 49.28 37
I4541 0 4541 1.34816e-05
R5451 4541 4542 1.696 0.8 13.568 37
I4542 0 4542 1.28631e-05
R5452 4542 4543 1.712 0.8 13.696 37
I4543 0 4543 1.31105e-05
R5453 4543 4544 1.728 0.8 13.824 37
I4544 0 4544 1.24921e-05
R5454 4544 4545 1.68 0.8 13.44 37
I4545 0 4545 1.32342e-05
R5455 4545 4546 1.68 0.8 13.44 37
I4546 0 4546 1.34816e-05
R5456 4546 4547 1.728 0.8 13.824 37
I4547 0 4547 1.29868e-05
R5457 4547 4548 1.744 0.8 13.952 37
I4548 0 4548 1.29868e-05
R5458 4548 4549 1.712 0.8 13.696 37
I4549 0 4549 1.34816e-05
R5459 4549 4550 1.664 0.8 13.312 37
I4550 0 4550 1.23684e-05
R5460 4550 0 0.1 49.28 49.28 37
*seg: 456
R5461 0 4551 0.1 49.28 49.28 37
R5462 4555 4565 6.16 0.8 49.28 37
I4551 0 4551 1.24921e-05
R5463 4551 4552 1.696 0.8 13.568 37
I4552 0 4552 1.34816e-05
R5464 4552 4553 1.696 0.8 13.568 37
I4553 0 4553 1.28631e-05
R5465 4553 4554 1.632 0.8 13.056 37
I4554 0 4554 1.29868e-05
R5466 4554 4555 1.648 0.8 13.184 37
I4555 0 4555 1.32342e-05
R5467 4555 4556 1.728 0.8 13.824 37
I4556 0 4556 1.33579e-05
R5468 4556 4557 1.664 0.8 13.312 37
I4557 0 4557 1.24921e-05
R5469 4557 4558 1.728 0.8 13.824 37
I4558 0 4558 1.29868e-05
R5470 4558 4559 1.6 0.8 12.8 37
I4559 0 4559 1.24921e-05
R5471 4559 4560 1.696 0.8 13.568 37
I4560 0 4560 1.23684e-05
R5472 4560 0 0.1 49.28 49.28 37
*seg: 457
R5473 0 4561 0.1 49.28 49.28 37
R5474 4565 4575 6.16 0.8 49.28 37
I4561 0 4561 1.34816e-05
R5475 4561 4562 1.648 0.8 13.184 37
I4562 0 4562 1.34816e-05
R5476 4562 4563 1.616 0.8 12.928 37
I4563 0 4563 1.34816e-05
R5477 4563 4564 1.696 0.8 13.568 37
I4564 0 4564 1.24921e-05
R5478 4564 4565 1.664 0.8 13.312 37
I4565 0 4565 1.23684e-05
R5479 4565 4566 1.632 0.8 13.056 37
I4566 0 4566 1.34816e-05
R5480 4566 4567 1.68 0.8 13.44 37
I4567 0 4567 1.29868e-05
R5481 4567 4568 1.744 0.8 13.952 37
I4568 0 4568 1.23684e-05
R5482 4568 4569 1.728 0.8 13.824 37
I4569 0 4569 1.24921e-05
R5483 4569 4570 1.728 0.8 13.824 37
I4570 0 4570 1.23684e-05
R5484 4570 0 0.1 49.28 49.28 37
*seg: 458
R5485 0 4571 0.1 49.28 49.28 37
R5486 4575 4585 6.16 0.8 49.28 37
I4571 0 4571 1.34816e-05
R5487 4571 4572 1.632 0.8 13.056 37
I4572 0 4572 1.31105e-05
R5488 4572 4573 1.648 0.8 13.184 37
I4573 0 4573 1.29868e-05
R5489 4573 4574 1.648 0.8 13.184 37
I4574 0 4574 1.29868e-05
R5490 4574 4575 1.664 0.8 13.312 37
I4575 0 4575 1.32342e-05
R5491 4575 4576 1.744 0.8 13.952 37
I4576 0 4576 1.27395e-05
R5492 4576 4577 1.6 0.8 12.8 37
I4577 0 4577 1.32342e-05
R5493 4577 4578 1.728 0.8 13.824 37
I4578 0 4578 1.33579e-05
R5494 4578 4579 1.728 0.8 13.824 37
I4579 0 4579 1.26158e-05
R5495 4579 4580 1.68 0.8 13.44 37
I4580 0 4580 1.23684e-05
R5496 4580 0 0.1 49.28 49.28 37
*seg: 459
R5497 0 4581 0.1 49.28 49.28 37
R5498 4585 4595 6.16 0.8 49.28 37
I4581 0 4581 1.24921e-05
R5499 4581 4582 1.712 0.8 13.696 37
I4582 0 4582 1.33579e-05
R5500 4582 4583 1.664 0.8 13.312 37
I4583 0 4583 1.33579e-05
R5501 4583 4584 1.728 0.8 13.824 37
I4584 0 4584 1.24921e-05
R5502 4584 4585 1.68 0.8 13.44 37
I4585 0 4585 1.26158e-05
R5503 4585 4586 1.616 0.8 12.928 37
I4586 0 4586 1.32342e-05
R5504 4586 4587 1.696 0.8 13.568 37
I4587 0 4587 1.27395e-05
R5505 4587 4588 1.6 0.8 12.8 37
I4588 0 4588 1.33579e-05
R5506 4588 4589 1.696 0.8 13.568 37
I4589 0 4589 1.23684e-05
R5507 4589 4590 1.632 0.8 13.056 37
I4590 0 4590 1.23684e-05
R5508 4590 0 0.1 49.28 49.28 37
*seg: 460
R5509 0 4591 0.1 49.28 49.28 37
R5510 4595 4605 6.16 0.8 49.28 37
I4591 0 4591 1.31105e-05
R5511 4591 4592 1.712 0.8 13.696 37
I4592 0 4592 1.34816e-05
R5512 4592 4593 1.6 0.8 12.8 37
I4593 0 4593 1.34816e-05
R5513 4593 4594 1.632 0.8 13.056 37
I4594 0 4594 1.32342e-05
R5514 4594 4595 1.648 0.8 13.184 37
I4595 0 4595 1.31105e-05
R5515 4595 4596 1.744 0.8 13.952 37
I4596 0 4596 1.29868e-05
R5516 4596 4597 1.728 0.8 13.824 37
I4597 0 4597 1.26158e-05
R5517 4597 4598 1.744 0.8 13.952 37
I4598 0 4598 1.26158e-05
R5518 4598 4599 1.744 0.8 13.952 37
I4599 0 4599 1.28631e-05
R5519 4599 4600 1.728 0.8 13.824 37
I4600 0 4600 1.23684e-05
R5520 4600 0 0.1 49.28 49.28 37
*seg: 461
R5521 0 4601 0.1 49.28 49.28 37
R5522 4605 4615 6.16 0.8 49.28 37
I4601 0 4601 1.31105e-05
R5523 4601 4602 1.712 0.8 13.696 37
I4602 0 4602 1.32342e-05
R5524 4602 4603 1.648 0.8 13.184 37
I4603 0 4603 1.27395e-05
R5525 4603 4604 1.68 0.8 13.44 37
I4604 0 4604 1.29868e-05
R5526 4604 4605 1.664 0.8 13.312 37
I4605 0 4605 1.24921e-05
R5527 4605 4606 1.648 0.8 13.184 37
I4606 0 4606 1.32342e-05
R5528 4606 4607 1.616 0.8 12.928 37
I4607 0 4607 1.24921e-05
R5529 4607 4608 1.712 0.8 13.696 37
I4608 0 4608 1.23684e-05
R5530 4608 4609 1.664 0.8 13.312 37
I4609 0 4609 1.29868e-05
R5531 4609 4610 1.744 0.8 13.952 37
I4610 0 4610 1.23684e-05
R5532 4610 0 0.1 49.28 49.28 37
*seg: 462
R5533 0 4611 0.1 49.28 49.28 37
R5534 4615 4625 6.16 0.8 49.28 37
I4611 0 4611 1.33579e-05
R5535 4611 4612 1.68 0.8 13.44 37
I4612 0 4612 1.24921e-05
R5536 4612 4613 1.712 0.8 13.696 37
I4613 0 4613 1.27395e-05
R5537 4613 4614 1.744 0.8 13.952 37
I4614 0 4614 1.31105e-05
R5538 4614 4615 1.728 0.8 13.824 37
I4615 0 4615 1.27395e-05
R5539 4615 4616 1.744 0.8 13.952 37
I4616 0 4616 1.28631e-05
R5540 4616 4617 1.632 0.8 13.056 37
I4617 0 4617 1.28631e-05
R5541 4617 4618 1.696 0.8 13.568 37
I4618 0 4618 1.33579e-05
R5542 4618 4619 1.664 0.8 13.312 37
I4619 0 4619 1.31105e-05
R5543 4619 4620 1.744 0.8 13.952 37
I4620 0 4620 1.23684e-05
R5544 4620 0 0.1 49.28 49.28 37
*seg: 463
R5545 0 4621 0.1 49.28 49.28 37
R5546 4625 4635 6.16 0.8 49.28 37
I4621 0 4621 1.26158e-05
R5547 4621 4622 1.632 0.8 13.056 37
I4622 0 4622 1.26158e-05
R5548 4622 4623 1.664 0.8 13.312 37
I4623 0 4623 1.33579e-05
R5549 4623 4624 1.616 0.8 12.928 37
I4624 0 4624 1.29868e-05
R5550 4624 4625 1.616 0.8 12.928 37
I4625 0 4625 1.33579e-05
R5551 4625 4626 1.68 0.8 13.44 37
I4626 0 4626 1.24921e-05
R5552 4626 4627 1.728 0.8 13.824 37
I4627 0 4627 1.27395e-05
R5553 4627 4628 1.728 0.8 13.824 37
I4628 0 4628 1.29868e-05
R5554 4628 4629 1.664 0.8 13.312 37
I4629 0 4629 1.28631e-05
R5555 4629 4630 1.712 0.8 13.696 37
I4630 0 4630 1.23684e-05
R5556 4630 0 0.1 49.28 49.28 37
*seg: 464
R5557 0 4631 0.1 49.28 49.28 37
R5558 4635 4645 6.16 0.8 49.28 37
I4631 0 4631 1.32342e-05
R5559 4631 4632 1.728 0.8 13.824 37
I4632 0 4632 1.24921e-05
R5560 4632 4633 1.632 0.8 13.056 37
I4633 0 4633 1.31105e-05
R5561 4633 4634 1.696 0.8 13.568 37
I4634 0 4634 1.27395e-05
R5562 4634 4635 1.744 0.8 13.952 37
I4635 0 4635 1.29868e-05
R5563 4635 4636 1.696 0.8 13.568 37
I4636 0 4636 1.28631e-05
R5564 4636 4637 1.616 0.8 12.928 37
I4637 0 4637 1.29868e-05
R5565 4637 4638 1.616 0.8 12.928 37
I4638 0 4638 1.24921e-05
R5566 4638 4639 1.616 0.8 12.928 37
I4639 0 4639 1.29868e-05
R5567 4639 4640 1.632 0.8 13.056 37
I4640 0 4640 1.23684e-05
R5568 4640 0 0.1 49.28 49.28 37
*seg: 465
R5569 0 4641 0.1 49.28 49.28 37
R5570 4645 4655 6.16 0.8 49.28 37
I4641 0 4641 1.26158e-05
R5571 4641 4642 1.664 0.8 13.312 37
I4642 0 4642 1.32342e-05
R5572 4642 4643 1.616 0.8 12.928 37
I4643 0 4643 1.26158e-05
R5573 4643 4644 1.744 0.8 13.952 37
I4644 0 4644 1.26158e-05
R5574 4644 4645 1.616 0.8 12.928 37
I4645 0 4645 1.24921e-05
R5575 4645 4646 1.6 0.8 12.8 37
I4646 0 4646 1.23684e-05
R5576 4646 4647 1.616 0.8 12.928 37
I4647 0 4647 1.27395e-05
R5577 4647 4648 1.744 0.8 13.952 37
I4648 0 4648 1.33579e-05
R5578 4648 4649 1.6 0.8 12.8 37
I4649 0 4649 1.24921e-05
R5579 4649 4650 1.712 0.8 13.696 37
I4650 0 4650 1.23684e-05
R5580 4650 0 0.1 49.28 49.28 37
*seg: 466
R5581 0 4651 0.1 49.28 49.28 37
R5582 4655 4665 6.16 0.8 49.28 37
I4651 0 4651 1.27395e-05
R5583 4651 4652 1.632 0.8 13.056 37
I4652 0 4652 1.27395e-05
R5584 4652 4653 1.728 0.8 13.824 37
I4653 0 4653 1.29868e-05
R5585 4653 4654 1.696 0.8 13.568 37
I4654 0 4654 1.28631e-05
R5586 4654 4655 1.744 0.8 13.952 37
I4655 0 4655 1.31105e-05
R5587 4655 4656 1.712 0.8 13.696 37
I4656 0 4656 1.24921e-05
R5588 4656 4657 1.6 0.8 12.8 37
I4657 0 4657 1.27395e-05
R5589 4657 4658 1.6 0.8 12.8 37
I4658 0 4658 1.24921e-05
R5590 4658 4659 1.68 0.8 13.44 37
I4659 0 4659 1.32342e-05
R5591 4659 4660 1.696 0.8 13.568 37
I4660 0 4660 1.23684e-05
R5592 4660 0 0.1 49.28 49.28 37
*seg: 467
R5593 0 4661 0.1 49.28 49.28 37
R5594 4665 4675 6.16 0.8 49.28 37
I4661 0 4661 1.29868e-05
R5595 4661 4662 1.728 0.8 13.824 37
I4662 0 4662 1.26158e-05
R5596 4662 4663 1.6 0.8 12.8 37
I4663 0 4663 1.33579e-05
R5597 4663 4664 1.728 0.8 13.824 37
I4664 0 4664 1.28631e-05
R5598 4664 4665 1.664 0.8 13.312 37
I4665 0 4665 1.26158e-05
R5599 4665 4666 1.648 0.8 13.184 37
I4666 0 4666 1.27395e-05
R5600 4666 4667 1.712 0.8 13.696 37
I4667 0 4667 1.34816e-05
R5601 4667 4668 1.744 0.8 13.952 37
I4668 0 4668 1.26158e-05
R5602 4668 4669 1.744 0.8 13.952 37
I4669 0 4669 1.27395e-05
R5603 4669 4670 1.632 0.8 13.056 37
I4670 0 4670 1.23684e-05
R5604 4670 0 0.1 49.28 49.28 37
*seg: 468
R5605 0 4671 0.1 49.28 49.28 37
R5606 4675 4685 6.16 0.8 49.28 37
I4671 0 4671 1.24921e-05
R5607 4671 4672 1.648 0.8 13.184 37
I4672 0 4672 1.29868e-05
R5608 4672 4673 1.744 0.8 13.952 37
I4673 0 4673 1.23684e-05
R5609 4673 4674 1.616 0.8 12.928 37
I4674 0 4674 1.26158e-05
R5610 4674 4675 1.744 0.8 13.952 37
I4675 0 4675 1.33579e-05
R5611 4675 4676 1.68 0.8 13.44 37
I4676 0 4676 1.26158e-05
R5612 4676 4677 1.68 0.8 13.44 37
I4677 0 4677 1.34816e-05
R5613 4677 4678 1.728 0.8 13.824 37
I4678 0 4678 1.24921e-05
R5614 4678 4679 1.616 0.8 12.928 37
I4679 0 4679 1.31105e-05
R5615 4679 4680 1.744 0.8 13.952 37
I4680 0 4680 1.23684e-05
R5616 4680 0 0.1 49.28 49.28 37
*seg: 469
R5617 0 4681 0.1 49.28 49.28 37
R5618 4685 4695 6.16 0.8 49.28 37
I4681 0 4681 1.29868e-05
R5619 4681 4682 1.6 0.8 12.8 37
I4682 0 4682 1.32342e-05
R5620 4682 4683 1.712 0.8 13.696 37
I4683 0 4683 1.27395e-05
R5621 4683 4684 1.632 0.8 13.056 37
I4684 0 4684 1.24921e-05
R5622 4684 4685 1.6 0.8 12.8 37
I4685 0 4685 1.34816e-05
R5623 4685 4686 1.616 0.8 12.928 37
I4686 0 4686 1.31105e-05
R5624 4686 4687 1.712 0.8 13.696 37
I4687 0 4687 1.29868e-05
R5625 4687 4688 1.616 0.8 12.928 37
I4688 0 4688 1.33579e-05
R5626 4688 4689 1.68 0.8 13.44 37
I4689 0 4689 1.23684e-05
R5627 4689 4690 1.696 0.8 13.568 37
I4690 0 4690 1.23684e-05
R5628 4690 0 0.1 49.28 49.28 37
*seg: 470
R5629 0 4691 0.1 49.28 49.28 37
R5630 4695 4705 6.16 0.8 49.28 37
I4691 0 4691 1.23684e-05
R5631 4691 4692 1.68 0.8 13.44 37
I4692 0 4692 1.33579e-05
R5632 4692 4693 1.744 0.8 13.952 37
I4693 0 4693 1.34816e-05
R5633 4693 4694 1.648 0.8 13.184 37
I4694 0 4694 1.24921e-05
R5634 4694 4695 1.6 0.8 12.8 37
I4695 0 4695 1.23684e-05
R5635 4695 4696 1.744 0.8 13.952 37
I4696 0 4696 1.31105e-05
R5636 4696 4697 1.648 0.8 13.184 37
I4697 0 4697 1.28631e-05
R5637 4697 4698 1.68 0.8 13.44 37
I4698 0 4698 1.33579e-05
R5638 4698 4699 1.744 0.8 13.952 37
I4699 0 4699 1.31105e-05
R5639 4699 4700 1.616 0.8 12.928 37
I4700 0 4700 1.23684e-05
R5640 4700 0 0.1 49.28 49.28 37
*seg: 471
R5641 0 4701 0.1 49.28 49.28 37
R5642 4705 4715 6.16 0.8 49.28 37
I4701 0 4701 1.29868e-05
R5643 4701 4702 1.68 0.8 13.44 37
I4702 0 4702 1.23684e-05
R5644 4702 4703 1.712 0.8 13.696 37
I4703 0 4703 1.34816e-05
R5645 4703 4704 1.616 0.8 12.928 37
I4704 0 4704 1.33579e-05
R5646 4704 4705 1.664 0.8 13.312 37
I4705 0 4705 1.24921e-05
R5647 4705 4706 1.728 0.8 13.824 37
I4706 0 4706 1.27395e-05
R5648 4706 4707 1.664 0.8 13.312 37
I4707 0 4707 1.34816e-05
R5649 4707 4708 1.712 0.8 13.696 37
I4708 0 4708 1.26158e-05
R5650 4708 4709 1.728 0.8 13.824 37
I4709 0 4709 1.24921e-05
R5651 4709 4710 1.696 0.8 13.568 37
I4710 0 4710 1.23684e-05
R5652 4710 0 0.1 49.28 49.28 37
*seg: 472
R5653 0 4711 0.1 49.28 49.28 37
R5654 4715 4725 6.16 0.8 49.28 37
I4711 0 4711 1.24921e-05
R5655 4711 4712 1.632 0.8 13.056 37
I4712 0 4712 1.23684e-05
R5656 4712 4713 1.664 0.8 13.312 37
I4713 0 4713 1.32342e-05
R5657 4713 4714 1.68 0.8 13.44 37
I4714 0 4714 1.33579e-05
R5658 4714 4715 1.728 0.8 13.824 37
I4715 0 4715 1.31105e-05
R5659 4715 4716 1.712 0.8 13.696 37
I4716 0 4716 1.27395e-05
R5660 4716 4717 1.648 0.8 13.184 37
I4717 0 4717 1.31105e-05
R5661 4717 4718 1.728 0.8 13.824 37
I4718 0 4718 1.28631e-05
R5662 4718 4719 1.728 0.8 13.824 37
I4719 0 4719 1.27395e-05
R5663 4719 4720 1.664 0.8 13.312 37
I4720 0 4720 1.23684e-05
R5664 4720 0 0.1 49.28 49.28 37
*seg: 473
R5665 0 4721 0.1 49.28 49.28 37
R5666 4725 4735 6.16 0.8 49.28 37
I4721 0 4721 1.34816e-05
R5667 4721 4722 1.664 0.8 13.312 37
I4722 0 4722 1.31105e-05
R5668 4722 4723 1.6 0.8 12.8 37
I4723 0 4723 1.33579e-05
R5669 4723 4724 1.728 0.8 13.824 37
I4724 0 4724 1.26158e-05
R5670 4724 4725 1.728 0.8 13.824 37
I4725 0 4725 1.23684e-05
R5671 4725 4726 1.744 0.8 13.952 37
I4726 0 4726 1.24921e-05
R5672 4726 4727 1.728 0.8 13.824 37
I4727 0 4727 1.31105e-05
R5673 4727 4728 1.616 0.8 12.928 37
I4728 0 4728 1.31105e-05
R5674 4728 4729 1.632 0.8 13.056 37
I4729 0 4729 1.26158e-05
R5675 4729 4730 1.728 0.8 13.824 37
I4730 0 4730 1.23684e-05
R5676 4730 0 0.1 49.28 49.28 37
*seg: 474
R5677 0 4731 0.1 49.28 49.28 37
R5678 4735 4745 6.16 0.8 49.28 37
I4731 0 4731 1.32342e-05
R5679 4731 4732 1.6 0.8 12.8 37
I4732 0 4732 1.28631e-05
R5680 4732 4733 1.616 0.8 12.928 37
I4733 0 4733 1.26158e-05
R5681 4733 4734 1.68 0.8 13.44 37
I4734 0 4734 1.33579e-05
R5682 4734 4735 1.664 0.8 13.312 37
I4735 0 4735 1.24921e-05
R5683 4735 4736 1.68 0.8 13.44 37
I4736 0 4736 1.23684e-05
R5684 4736 4737 1.616 0.8 12.928 37
I4737 0 4737 1.24921e-05
R5685 4737 4738 1.648 0.8 13.184 37
I4738 0 4738 1.23684e-05
R5686 4738 4739 1.648 0.8 13.184 37
I4739 0 4739 1.24921e-05
R5687 4739 4740 1.68 0.8 13.44 37
I4740 0 4740 1.23684e-05
R5688 4740 0 0.1 49.28 49.28 37
*seg: 475
R5689 0 4741 0.1 49.28 49.28 37
R5690 4745 4755 6.16 0.8 49.28 37
I4741 0 4741 1.24921e-05
R5691 4741 4742 1.664 0.8 13.312 37
I4742 0 4742 1.24921e-05
R5692 4742 4743 1.648 0.8 13.184 37
I4743 0 4743 1.29868e-05
R5693 4743 4744 1.616 0.8 12.928 37
I4744 0 4744 1.28631e-05
R5694 4744 4745 1.68 0.8 13.44 37
I4745 0 4745 1.33579e-05
R5695 4745 4746 1.744 0.8 13.952 37
I4746 0 4746 1.31105e-05
R5696 4746 4747 1.616 0.8 12.928 37
I4747 0 4747 1.27395e-05
R5697 4747 4748 1.664 0.8 13.312 37
I4748 0 4748 1.29868e-05
R5698 4748 4749 1.616 0.8 12.928 37
I4749 0 4749 1.27395e-05
R5699 4749 4750 1.632 0.8 13.056 37
I4750 0 4750 1.23684e-05
R5700 4750 0 0.1 49.28 49.28 37
*seg: 476
R5701 0 4751 0.1 49.28 49.28 37
R5702 4755 4765 6.16 0.8 49.28 37
I4751 0 4751 1.28631e-05
R5703 4751 4752 1.648 0.8 13.184 37
I4752 0 4752 1.27395e-05
R5704 4752 4753 1.616 0.8 12.928 37
I4753 0 4753 1.26158e-05
R5705 4753 4754 1.68 0.8 13.44 37
I4754 0 4754 1.32342e-05
R5706 4754 4755 1.712 0.8 13.696 37
I4755 0 4755 1.33579e-05
R5707 4755 4756 1.696 0.8 13.568 37
I4756 0 4756 1.32342e-05
R5708 4756 4757 1.728 0.8 13.824 37
I4757 0 4757 1.23684e-05
R5709 4757 4758 1.632 0.8 13.056 37
I4758 0 4758 1.33579e-05
R5710 4758 4759 1.68 0.8 13.44 37
I4759 0 4759 1.27395e-05
R5711 4759 4760 1.712 0.8 13.696 37
I4760 0 4760 1.23684e-05
R5712 4760 0 0.1 49.28 49.28 37
*seg: 477
R5713 0 4761 0.1 49.28 49.28 37
R5714 4765 4775 6.16 0.8 49.28 37
I4761 0 4761 1.24921e-05
R5715 4761 4762 1.68 0.8 13.44 37
I4762 0 4762 1.34816e-05
R5716 4762 4763 1.744 0.8 13.952 37
I4763 0 4763 1.34816e-05
R5717 4763 4764 1.616 0.8 12.928 37
I4764 0 4764 1.26158e-05
R5718 4764 4765 1.712 0.8 13.696 37
I4765 0 4765 1.34816e-05
R5719 4765 4766 1.712 0.8 13.696 37
I4766 0 4766 1.24921e-05
R5720 4766 4767 1.664 0.8 13.312 37
I4767 0 4767 1.24921e-05
R5721 4767 4768 1.6 0.8 12.8 37
I4768 0 4768 1.28631e-05
R5722 4768 4769 1.744 0.8 13.952 37
I4769 0 4769 1.29868e-05
R5723 4769 4770 1.68 0.8 13.44 37
I4770 0 4770 1.23684e-05
R5724 4770 0 0.1 49.28 49.28 37
*seg: 478
R5725 0 4771 0.1 49.28 49.28 37
R5726 4775 4785 6.16 0.8 49.28 37
I4771 0 4771 1.32342e-05
R5727 4771 4772 1.696 0.8 13.568 37
I4772 0 4772 1.26158e-05
R5728 4772 4773 1.728 0.8 13.824 37
I4773 0 4773 1.26158e-05
R5729 4773 4774 1.744 0.8 13.952 37
I4774 0 4774 1.28631e-05
R5730 4774 4775 1.664 0.8 13.312 37
I4775 0 4775 1.27395e-05
R5731 4775 4776 1.648 0.8 13.184 37
I4776 0 4776 1.29868e-05
R5732 4776 4777 1.744 0.8 13.952 37
I4777 0 4777 1.32342e-05
R5733 4777 4778 1.696 0.8 13.568 37
I4778 0 4778 1.27395e-05
R5734 4778 4779 1.632 0.8 13.056 37
I4779 0 4779 1.32342e-05
R5735 4779 4780 1.696 0.8 13.568 37
I4780 0 4780 1.23684e-05
R5736 4780 0 0.1 49.28 49.28 37
*seg: 479
R5737 0 4781 0.1 49.28 49.28 37
R5738 4785 4795 6.16 0.8 49.28 37
I4781 0 4781 1.29868e-05
R5739 4781 4782 1.632 0.8 13.056 37
I4782 0 4782 1.29868e-05
R5740 4782 4783 1.728 0.8 13.824 37
I4783 0 4783 1.24921e-05
R5741 4783 4784 1.728 0.8 13.824 37
I4784 0 4784 1.32342e-05
R5742 4784 4785 1.728 0.8 13.824 37
I4785 0 4785 1.28631e-05
R5743 4785 4786 1.68 0.8 13.44 37
I4786 0 4786 1.32342e-05
R5744 4786 4787 1.744 0.8 13.952 37
I4787 0 4787 1.29868e-05
R5745 4787 4788 1.728 0.8 13.824 37
I4788 0 4788 1.27395e-05
R5746 4788 4789 1.632 0.8 13.056 37
I4789 0 4789 1.33579e-05
R5747 4789 4790 1.712 0.8 13.696 37
I4790 0 4790 1.23684e-05
R5748 4790 0 0.1 49.28 49.28 37
*seg: 480
R5749 0 4791 0.1 49.28 49.28 37
R5750 4795 4805 6.16 0.8 49.28 37
I4791 0 4791 1.33579e-05
R5751 4791 4792 1.664 0.8 13.312 37
I4792 0 4792 1.24921e-05
R5752 4792 4793 1.712 0.8 13.696 37
I4793 0 4793 1.28631e-05
R5753 4793 4794 1.632 0.8 13.056 37
I4794 0 4794 1.29868e-05
R5754 4794 4795 1.712 0.8 13.696 37
I4795 0 4795 1.23684e-05
R5755 4795 4796 1.664 0.8 13.312 37
I4796 0 4796 1.34816e-05
R5756 4796 4797 1.616 0.8 12.928 37
I4797 0 4797 1.34816e-05
R5757 4797 4798 1.6 0.8 12.8 37
I4798 0 4798 1.29868e-05
R5758 4798 4799 1.648 0.8 13.184 37
I4799 0 4799 1.28631e-05
R5759 4799 4800 1.728 0.8 13.824 37
I4800 0 4800 1.23684e-05
R5760 4800 0 0.1 49.28 49.28 37
*seg: 481
R5761 0 4801 0.1 49.28 49.28 37
R5762 4805 4815 6.16 0.8 49.28 37
I4801 0 4801 1.24921e-05
R5763 4801 4802 1.728 0.8 13.824 37
I4802 0 4802 1.23684e-05
R5764 4802 4803 1.744 0.8 13.952 37
I4803 0 4803 1.32342e-05
R5765 4803 4804 1.616 0.8 12.928 37
I4804 0 4804 1.31105e-05
R5766 4804 4805 1.728 0.8 13.824 37
I4805 0 4805 1.27395e-05
R5767 4805 4806 1.6 0.8 12.8 37
I4806 0 4806 1.34816e-05
R5768 4806 4807 1.632 0.8 13.056 37
I4807 0 4807 1.29868e-05
R5769 4807 4808 1.648 0.8 13.184 37
I4808 0 4808 1.27395e-05
R5770 4808 4809 1.696 0.8 13.568 37
I4809 0 4809 1.33579e-05
R5771 4809 4810 1.632 0.8 13.056 37
I4810 0 4810 1.23684e-05
R5772 4810 0 0.1 49.28 49.28 37
*seg: 482
R5773 0 4811 0.1 49.28 49.28 37
R5774 4815 4825 6.16 0.8 49.28 37
I4811 0 4811 1.31105e-05
R5775 4811 4812 1.616 0.8 12.928 37
I4812 0 4812 1.23684e-05
R5776 4812 4813 1.648 0.8 13.184 37
I4813 0 4813 1.31105e-05
R5777 4813 4814 1.744 0.8 13.952 37
I4814 0 4814 1.24921e-05
R5778 4814 4815 1.712 0.8 13.696 37
I4815 0 4815 1.32342e-05
R5779 4815 4816 1.648 0.8 13.184 37
I4816 0 4816 1.32342e-05
R5780 4816 4817 1.616 0.8 12.928 37
I4817 0 4817 1.23684e-05
R5781 4817 4818 1.696 0.8 13.568 37
I4818 0 4818 1.28631e-05
R5782 4818 4819 1.664 0.8 13.312 37
I4819 0 4819 1.27395e-05
R5783 4819 4820 1.632 0.8 13.056 37
I4820 0 4820 1.23684e-05
R5784 4820 0 0.1 49.28 49.28 37
*seg: 483
R5785 0 4821 0.1 49.28 49.28 37
R5786 4825 4835 6.16 0.8 49.28 37
I4821 0 4821 1.31105e-05
R5787 4821 4822 1.696 0.8 13.568 37
I4822 0 4822 1.33579e-05
R5788 4822 4823 1.6 0.8 12.8 37
I4823 0 4823 1.29868e-05
R5789 4823 4824 1.6 0.8 12.8 37
I4824 0 4824 1.27395e-05
R5790 4824 4825 1.696 0.8 13.568 37
I4825 0 4825 1.32342e-05
R5791 4825 4826 1.712 0.8 13.696 37
I4826 0 4826 1.33579e-05
R5792 4826 4827 1.616 0.8 12.928 37
I4827 0 4827 1.33579e-05
R5793 4827 4828 1.712 0.8 13.696 37
I4828 0 4828 1.23684e-05
R5794 4828 4829 1.728 0.8 13.824 37
I4829 0 4829 1.26158e-05
R5795 4829 4830 1.616 0.8 12.928 37
I4830 0 4830 1.23684e-05
R5796 4830 0 0.1 49.28 49.28 37
*seg: 484
R5797 0 4831 0.1 49.28 49.28 37
R5798 4835 4845 6.16 0.8 49.28 37
I4831 0 4831 1.23684e-05
R5799 4831 4832 1.6 0.8 12.8 37
I4832 0 4832 1.24921e-05
R5800 4832 4833 1.712 0.8 13.696 37
I4833 0 4833 1.31105e-05
R5801 4833 4834 1.632 0.8 13.056 37
I4834 0 4834 1.32342e-05
R5802 4834 4835 1.696 0.8 13.568 37
I4835 0 4835 1.29868e-05
R5803 4835 4836 1.664 0.8 13.312 37
I4836 0 4836 1.26158e-05
R5804 4836 4837 1.696 0.8 13.568 37
I4837 0 4837 1.28631e-05
R5805 4837 4838 1.648 0.8 13.184 37
I4838 0 4838 1.24921e-05
R5806 4838 4839 1.648 0.8 13.184 37
I4839 0 4839 1.27395e-05
R5807 4839 4840 1.712 0.8 13.696 37
I4840 0 4840 1.23684e-05
R5808 4840 0 0.1 49.28 49.28 37
*seg: 485
R5809 0 4841 0.1 49.28 49.28 37
R5810 4845 4855 6.16 0.8 49.28 37
I4841 0 4841 1.32342e-05
R5811 4841 4842 1.664 0.8 13.312 37
I4842 0 4842 1.23684e-05
R5812 4842 4843 1.68 0.8 13.44 37
I4843 0 4843 1.31105e-05
R5813 4843 4844 1.664 0.8 13.312 37
I4844 0 4844 1.26158e-05
R5814 4844 4845 1.712 0.8 13.696 37
I4845 0 4845 1.27395e-05
R5815 4845 4846 1.712 0.8 13.696 37
I4846 0 4846 1.24921e-05
R5816 4846 4847 1.744 0.8 13.952 37
I4847 0 4847 1.24921e-05
R5817 4847 4848 1.696 0.8 13.568 37
I4848 0 4848 1.27395e-05
R5818 4848 4849 1.648 0.8 13.184 37
I4849 0 4849 1.32342e-05
R5819 4849 4850 1.632 0.8 13.056 37
I4850 0 4850 1.23684e-05
R5820 4850 0 0.1 49.28 49.28 37
*seg: 486
R5821 0 4851 0.1 49.28 49.28 37
R5822 4855 4865 6.16 0.8 49.28 37
I4851 0 4851 1.26158e-05
R5823 4851 4852 1.744 0.8 13.952 37
I4852 0 4852 1.31105e-05
R5824 4852 4853 1.648 0.8 13.184 37
I4853 0 4853 1.34816e-05
R5825 4853 4854 1.712 0.8 13.696 37
I4854 0 4854 1.34816e-05
R5826 4854 4855 1.712 0.8 13.696 37
I4855 0 4855 1.28631e-05
R5827 4855 4856 1.68 0.8 13.44 37
I4856 0 4856 1.29868e-05
R5828 4856 4857 1.664 0.8 13.312 37
I4857 0 4857 1.33579e-05
R5829 4857 4858 1.696 0.8 13.568 37
I4858 0 4858 1.26158e-05
R5830 4858 4859 1.712 0.8 13.696 37
I4859 0 4859 1.24921e-05
R5831 4859 4860 1.712 0.8 13.696 37
I4860 0 4860 1.23684e-05
R5832 4860 0 0.1 49.28 49.28 37
*seg: 487
R5833 0 4861 0.1 49.28 49.28 37
R5834 4865 4875 6.16 0.8 49.28 37
I4861 0 4861 1.32342e-05
R5835 4861 4862 1.744 0.8 13.952 37
I4862 0 4862 1.34816e-05
R5836 4862 4863 1.648 0.8 13.184 37
I4863 0 4863 1.29868e-05
R5837 4863 4864 1.744 0.8 13.952 37
I4864 0 4864 1.33579e-05
R5838 4864 4865 1.6 0.8 12.8 37
I4865 0 4865 1.33579e-05
R5839 4865 4866 1.68 0.8 13.44 37
I4866 0 4866 1.27395e-05
R5840 4866 4867 1.6 0.8 12.8 37
I4867 0 4867 1.28631e-05
R5841 4867 4868 1.712 0.8 13.696 37
I4868 0 4868 1.34816e-05
R5842 4868 4869 1.664 0.8 13.312 37
I4869 0 4869 1.28631e-05
R5843 4869 4870 1.712 0.8 13.696 37
I4870 0 4870 1.23684e-05
R5844 4870 0 0.1 49.28 49.28 37
*seg: 488
R5845 0 4871 0.1 49.28 49.28 37
R5846 4875 4885 6.16 0.8 49.28 37
I4871 0 4871 1.34816e-05
R5847 4871 4872 1.632 0.8 13.056 37
I4872 0 4872 1.26158e-05
R5848 4872 4873 1.68 0.8 13.44 37
I4873 0 4873 1.26158e-05
R5849 4873 4874 1.664 0.8 13.312 37
I4874 0 4874 1.33579e-05
R5850 4874 4875 1.728 0.8 13.824 37
I4875 0 4875 1.27395e-05
R5851 4875 4876 1.68 0.8 13.44 37
I4876 0 4876 1.32342e-05
R5852 4876 4877 1.664 0.8 13.312 37
I4877 0 4877 1.31105e-05
R5853 4877 4878 1.648 0.8 13.184 37
I4878 0 4878 1.23684e-05
R5854 4878 4879 1.712 0.8 13.696 37
I4879 0 4879 1.27395e-05
R5855 4879 4880 1.696 0.8 13.568 37
I4880 0 4880 1.23684e-05
R5856 4880 0 0.1 49.28 49.28 37
*seg: 489
R5857 0 4881 0.1 49.28 49.28 37
R5858 4885 4895 6.16 0.8 49.28 37
I4881 0 4881 1.24921e-05
R5859 4881 4882 1.632 0.8 13.056 37
I4882 0 4882 1.27395e-05
R5860 4882 4883 1.744 0.8 13.952 37
I4883 0 4883 1.23684e-05
R5861 4883 4884 1.632 0.8 13.056 37
I4884 0 4884 1.31105e-05
R5862 4884 4885 1.68 0.8 13.44 37
I4885 0 4885 1.29868e-05
R5863 4885 4886 1.616 0.8 12.928 37
I4886 0 4886 1.32342e-05
R5864 4886 4887 1.744 0.8 13.952 37
I4887 0 4887 1.34816e-05
R5865 4887 4888 1.648 0.8 13.184 37
I4888 0 4888 1.28631e-05
R5866 4888 4889 1.68 0.8 13.44 37
I4889 0 4889 1.29868e-05
R5867 4889 4890 1.744 0.8 13.952 37
I4890 0 4890 1.23684e-05
R5868 4890 0 0.1 49.28 49.28 37
*seg: 490
R5869 0 4891 0.1 49.28 49.28 37
R5870 4895 4905 6.16 0.8 49.28 37
I4891 0 4891 1.31105e-05
R5871 4891 4892 1.744 0.8 13.952 37
I4892 0 4892 1.24921e-05
R5872 4892 4893 1.696 0.8 13.568 37
I4893 0 4893 1.31105e-05
R5873 4893 4894 1.696 0.8 13.568 37
I4894 0 4894 1.31105e-05
R5874 4894 4895 1.664 0.8 13.312 37
I4895 0 4895 1.33579e-05
R5875 4895 4896 1.744 0.8 13.952 37
I4896 0 4896 1.27395e-05
R5876 4896 4897 1.728 0.8 13.824 37
I4897 0 4897 1.32342e-05
R5877 4897 4898 1.712 0.8 13.696 37
I4898 0 4898 1.26158e-05
R5878 4898 4899 1.712 0.8 13.696 37
I4899 0 4899 1.23684e-05
R5879 4899 4900 1.696 0.8 13.568 37
I4900 0 4900 1.23684e-05
R5880 4900 0 0.1 49.28 49.28 37
*seg: 491
R5881 0 4901 0.1 49.28 49.28 37
R5882 4905 4915 6.16 0.8 49.28 37
I4901 0 4901 1.27395e-05
R5883 4901 4902 1.68 0.8 13.44 37
I4902 0 4902 1.27395e-05
R5884 4902 4903 1.664 0.8 13.312 37
I4903 0 4903 1.33579e-05
R5885 4903 4904 1.6 0.8 12.8 37
I4904 0 4904 1.29868e-05
R5886 4904 4905 1.728 0.8 13.824 37
I4905 0 4905 1.26158e-05
R5887 4905 4906 1.728 0.8 13.824 37
I4906 0 4906 1.31105e-05
R5888 4906 4907 1.664 0.8 13.312 37
I4907 0 4907 1.27395e-05
R5889 4907 4908 1.616 0.8 12.928 37
I4908 0 4908 1.24921e-05
R5890 4908 4909 1.728 0.8 13.824 37
I4909 0 4909 1.31105e-05
R5891 4909 4910 1.664 0.8 13.312 37
I4910 0 4910 1.23684e-05
R5892 4910 0 0.1 49.28 49.28 37
*seg: 492
R5893 0 4911 0.1 49.28 49.28 37
R5894 4915 4925 6.16 0.8 49.28 37
I4911 0 4911 1.27395e-05
R5895 4911 4912 1.616 0.8 12.928 37
I4912 0 4912 1.29868e-05
R5896 4912 4913 1.664 0.8 13.312 37
I4913 0 4913 1.33579e-05
R5897 4913 4914 1.712 0.8 13.696 37
I4914 0 4914 1.23684e-05
R5898 4914 4915 1.68 0.8 13.44 37
I4915 0 4915 1.31105e-05
R5899 4915 4916 1.712 0.8 13.696 37
I4916 0 4916 1.23684e-05
R5900 4916 4917 1.728 0.8 13.824 37
I4917 0 4917 1.31105e-05
R5901 4917 4918 1.6 0.8 12.8 37
I4918 0 4918 1.29868e-05
R5902 4918 4919 1.68 0.8 13.44 37
I4919 0 4919 1.32342e-05
R5903 4919 4920 1.648 0.8 13.184 37
I4920 0 4920 1.23684e-05
R5904 4920 0 0.1 49.28 49.28 37
*seg: 493
R5905 0 4921 0.1 49.28 49.28 37
R5906 4925 4935 6.16 0.8 49.28 37
I4921 0 4921 1.34816e-05
R5907 4921 4922 1.712 0.8 13.696 37
I4922 0 4922 1.27395e-05
R5908 4922 4923 1.68 0.8 13.44 37
I4923 0 4923 1.33579e-05
R5909 4923 4924 1.68 0.8 13.44 37
I4924 0 4924 1.26158e-05
R5910 4924 4925 1.728 0.8 13.824 37
I4925 0 4925 1.26158e-05
R5911 4925 4926 1.728 0.8 13.824 37
I4926 0 4926 1.26158e-05
R5912 4926 4927 1.664 0.8 13.312 37
I4927 0 4927 1.34816e-05
R5913 4927 4928 1.728 0.8 13.824 37
I4928 0 4928 1.24921e-05
R5914 4928 4929 1.744 0.8 13.952 37
I4929 0 4929 1.26158e-05
R5915 4929 4930 1.68 0.8 13.44 37
I4930 0 4930 1.23684e-05
R5916 4930 0 0.1 49.28 49.28 37
*seg: 494
R5917 0 4931 0.1 49.28 49.28 37
R5918 4935 4945 6.16 0.8 49.28 37
I4931 0 4931 1.31105e-05
R5919 4931 4932 1.744 0.8 13.952 37
I4932 0 4932 1.29868e-05
R5920 4932 4933 1.728 0.8 13.824 37
I4933 0 4933 1.28631e-05
R5921 4933 4934 1.696 0.8 13.568 37
I4934 0 4934 1.29868e-05
R5922 4934 4935 1.696 0.8 13.568 37
I4935 0 4935 1.28631e-05
R5923 4935 4936 1.68 0.8 13.44 37
I4936 0 4936 1.33579e-05
R5924 4936 4937 1.68 0.8 13.44 37
I4937 0 4937 1.34816e-05
R5925 4937 4938 1.696 0.8 13.568 37
I4938 0 4938 1.29868e-05
R5926 4938 4939 1.664 0.8 13.312 37
I4939 0 4939 1.32342e-05
R5927 4939 4940 1.664 0.8 13.312 37
I4940 0 4940 1.23684e-05
R5928 4940 0 0.1 49.28 49.28 37
*seg: 495
R5929 0 4941 0.1 49.28 49.28 37
R5930 4945 4955 6.16 0.8 49.28 37
I4941 0 4941 1.23684e-05
R5931 4941 4942 1.648 0.8 13.184 37
I4942 0 4942 1.34816e-05
R5932 4942 4943 1.728 0.8 13.824 37
I4943 0 4943 1.28631e-05
R5933 4943 4944 1.648 0.8 13.184 37
I4944 0 4944 1.27395e-05
R5934 4944 4945 1.712 0.8 13.696 37
I4945 0 4945 1.32342e-05
R5935 4945 4946 1.648 0.8 13.184 37
I4946 0 4946 1.33579e-05
R5936 4946 4947 1.728 0.8 13.824 37
I4947 0 4947 1.31105e-05
R5937 4947 4948 1.632 0.8 13.056 37
I4948 0 4948 1.24921e-05
R5938 4948 4949 1.664 0.8 13.312 37
I4949 0 4949 1.29868e-05
R5939 4949 4950 1.648 0.8 13.184 37
I4950 0 4950 1.23684e-05
R5940 4950 0 0.1 49.28 49.28 37
*seg: 496
R5941 0 4951 0.1 49.28 49.28 37
R5942 4955 4965 6.16 0.8 49.28 37
I4951 0 4951 1.23684e-05
R5943 4951 4952 1.6 0.8 12.8 37
I4952 0 4952 1.34816e-05
R5944 4952 4953 1.616 0.8 12.928 37
I4953 0 4953 1.27395e-05
R5945 4953 4954 1.712 0.8 13.696 37
I4954 0 4954 1.32342e-05
R5946 4954 4955 1.616 0.8 12.928 37
I4955 0 4955 1.27395e-05
R5947 4955 4956 1.696 0.8 13.568 37
I4956 0 4956 1.28631e-05
R5948 4956 4957 1.68 0.8 13.44 37
I4957 0 4957 1.28631e-05
R5949 4957 4958 1.648 0.8 13.184 37
I4958 0 4958 1.31105e-05
R5950 4958 4959 1.696 0.8 13.568 37
I4959 0 4959 1.32342e-05
R5951 4959 4960 1.632 0.8 13.056 37
I4960 0 4960 1.23684e-05
R5952 4960 0 0.1 49.28 49.28 37
*seg: 497
R5953 0 4961 0.1 49.28 49.28 37
R5954 4965 4975 6.16 0.8 49.28 37
I4961 0 4961 1.33579e-05
R5955 4961 4962 1.744 0.8 13.952 37
I4962 0 4962 1.28631e-05
R5956 4962 4963 1.744 0.8 13.952 37
I4963 0 4963 1.23684e-05
R5957 4963 4964 1.6 0.8 12.8 37
I4964 0 4964 1.23684e-05
R5958 4964 4965 1.632 0.8 13.056 37
I4965 0 4965 1.34816e-05
R5959 4965 4966 1.68 0.8 13.44 37
I4966 0 4966 1.31105e-05
R5960 4966 4967 1.696 0.8 13.568 37
I4967 0 4967 1.34816e-05
R5961 4967 4968 1.68 0.8 13.44 37
I4968 0 4968 1.27395e-05
R5962 4968 4969 1.6 0.8 12.8 37
I4969 0 4969 1.23684e-05
R5963 4969 4970 1.632 0.8 13.056 37
I4970 0 4970 1.23684e-05
R5964 4970 0 0.1 49.28 49.28 37
*seg: 498
R5965 0 4971 0.1 49.28 49.28 37
R5966 4975 4985 6.16 0.8 49.28 37
I4971 0 4971 1.27395e-05
R5967 4971 4972 1.696 0.8 13.568 37
I4972 0 4972 1.31105e-05
R5968 4972 4973 1.632 0.8 13.056 37
I4973 0 4973 1.34816e-05
R5969 4973 4974 1.712 0.8 13.696 37
I4974 0 4974 1.28631e-05
R5970 4974 4975 1.68 0.8 13.44 37
I4975 0 4975 1.27395e-05
R5971 4975 4976 1.68 0.8 13.44 37
I4976 0 4976 1.23684e-05
R5972 4976 4977 1.616 0.8 12.928 37
I4977 0 4977 1.24921e-05
R5973 4977 4978 1.648 0.8 13.184 37
I4978 0 4978 1.33579e-05
R5974 4978 4979 1.616 0.8 12.928 37
I4979 0 4979 1.33579e-05
R5975 4979 4980 1.664 0.8 13.312 37
I4980 0 4980 1.23684e-05
R5976 4980 0 0.1 49.28 49.28 37
*seg: 499
R5977 0 4981 0.1 49.28 49.28 37
R5978 4985 4995 6.16 0.8 49.28 37
I4981 0 4981 1.26158e-05
R5979 4981 4982 1.648 0.8 13.184 37
I4982 0 4982 1.28631e-05
R5980 4982 4983 1.6 0.8 12.8 37
I4983 0 4983 1.32342e-05
R5981 4983 4984 1.616 0.8 12.928 37
I4984 0 4984 1.34816e-05
R5982 4984 4985 1.696 0.8 13.568 37
I4985 0 4985 1.31105e-05
R5983 4985 4986 1.616 0.8 12.928 37
I4986 0 4986 1.24921e-05
R5984 4986 4987 1.632 0.8 13.056 37
I4987 0 4987 1.28631e-05
R5985 4987 4988 1.648 0.8 13.184 37
I4988 0 4988 1.28631e-05
R5986 4988 4989 1.6 0.8 12.8 37
I4989 0 4989 1.29868e-05
R5987 4989 4990 1.632 0.8 13.056 37
I4990 0 4990 1.23684e-05
R5988 4990 0 0.1 49.28 49.28 37
*seg: 500
R5989 0 4991 0.1 49.28 49.28 37
R5990 4995 5005 6.16 0.8 49.28 37
I4991 0 4991 1.32342e-05
R5991 4991 4992 1.648 0.8 13.184 37
I4992 0 4992 1.28631e-05
R5992 4992 4993 1.616 0.8 12.928 37
I4993 0 4993 1.23684e-05
R5993 4993 4994 1.6 0.8 12.8 37
I4994 0 4994 1.23684e-05
R5994 4994 4995 1.664 0.8 13.312 37
I4995 0 4995 1.23684e-05
R5995 4995 4996 1.68 0.8 13.44 37
I4996 0 4996 1.26158e-05
R5996 4996 4997 1.648 0.8 13.184 37
I4997 0 4997 1.31105e-05
R5997 4997 4998 1.696 0.8 13.568 37
I4998 0 4998 1.26158e-05
R5998 4998 4999 1.728 0.8 13.824 37
I4999 0 4999 1.29868e-05
R5999 4999 5000 1.664 0.8 13.312 37
I5000 0 5000 1.23684e-05
R6000 5000 0 0.1 49.28 49.28 37
*seg: 501
R6001 0 5001 0.1 49.28 49.28 37
R6002 5005 5015 6.16 0.8 49.28 37
I5001 0 5001 1.29868e-05
R6003 5001 5002 1.632 0.8 13.056 37
I5002 0 5002 1.33579e-05
R6004 5002 5003 1.712 0.8 13.696 37
I5003 0 5003 1.28631e-05
R6005 5003 5004 1.616 0.8 12.928 37
I5004 0 5004 1.29868e-05
R6006 5004 5005 1.744 0.8 13.952 37
I5005 0 5005 1.32342e-05
R6007 5005 5006 1.616 0.8 12.928 37
I5006 0 5006 1.31105e-05
R6008 5006 5007 1.712 0.8 13.696 37
I5007 0 5007 1.24921e-05
R6009 5007 5008 1.648 0.8 13.184 37
I5008 0 5008 1.24921e-05
R6010 5008 5009 1.632 0.8 13.056 37
I5009 0 5009 1.26158e-05
R6011 5009 5010 1.712 0.8 13.696 37
I5010 0 5010 1.23684e-05
R6012 5010 0 0.1 49.28 49.28 37
*seg: 502
R6013 0 5011 0.1 49.28 49.28 37
R6014 5015 5025 6.16 0.8 49.28 37
I5011 0 5011 1.26158e-05
R6015 5011 5012 1.744 0.8 13.952 37
I5012 0 5012 1.28631e-05
R6016 5012 5013 1.616 0.8 12.928 37
I5013 0 5013 1.23684e-05
R6017 5013 5014 1.728 0.8 13.824 37
I5014 0 5014 1.29868e-05
R6018 5014 5015 1.696 0.8 13.568 37
I5015 0 5015 1.24921e-05
R6019 5015 5016 1.744 0.8 13.952 37
I5016 0 5016 1.24921e-05
R6020 5016 5017 1.696 0.8 13.568 37
I5017 0 5017 1.34816e-05
R6021 5017 5018 1.632 0.8 13.056 37
I5018 0 5018 1.28631e-05
R6022 5018 5019 1.648 0.8 13.184 37
I5019 0 5019 1.28631e-05
R6023 5019 5020 1.616 0.8 12.928 37
I5020 0 5020 1.23684e-05
R6024 5020 0 0.1 49.28 49.28 37
*seg: 503
R6025 0 5021 0.1 49.28 49.28 37
R6026 5025 5035 6.16 0.8 49.28 37
I5021 0 5021 1.27395e-05
R6027 5021 5022 1.744 0.8 13.952 37
I5022 0 5022 1.26158e-05
R6028 5022 5023 1.632 0.8 13.056 37
I5023 0 5023 1.29868e-05
R6029 5023 5024 1.712 0.8 13.696 37
I5024 0 5024 1.29868e-05
R6030 5024 5025 1.616 0.8 12.928 37
I5025 0 5025 1.34816e-05
R6031 5025 5026 1.616 0.8 12.928 37
I5026 0 5026 1.34816e-05
R6032 5026 5027 1.696 0.8 13.568 37
I5027 0 5027 1.24921e-05
R6033 5027 5028 1.6 0.8 12.8 37
I5028 0 5028 1.31105e-05
R6034 5028 5029 1.712 0.8 13.696 37
I5029 0 5029 1.29868e-05
R6035 5029 5030 1.744 0.8 13.952 37
I5030 0 5030 1.23684e-05
R6036 5030 0 0.1 49.28 49.28 37
*seg: 504
R6037 0 5031 0.1 49.28 49.28 37
R6038 5035 5045 6.16 0.8 49.28 37
I5031 0 5031 1.23684e-05
R6039 5031 5032 1.632 0.8 13.056 37
I5032 0 5032 1.34816e-05
R6040 5032 5033 1.744 0.8 13.952 37
I5033 0 5033 1.26158e-05
R6041 5033 5034 1.648 0.8 13.184 37
I5034 0 5034 1.28631e-05
R6042 5034 5035 1.616 0.8 12.928 37
I5035 0 5035 1.24921e-05
R6043 5035 5036 1.664 0.8 13.312 37
I5036 0 5036 1.26158e-05
R6044 5036 5037 1.696 0.8 13.568 37
I5037 0 5037 1.31105e-05
R6045 5037 5038 1.728 0.8 13.824 37
I5038 0 5038 1.31105e-05
R6046 5038 5039 1.664 0.8 13.312 37
I5039 0 5039 1.33579e-05
R6047 5039 5040 1.648 0.8 13.184 37
I5040 0 5040 1.23684e-05
R6048 5040 0 0.1 49.28 49.28 37
*seg: 505
R6049 0 5041 0.1 49.28 49.28 37
R6050 5045 5055 6.16 0.8 49.28 37
I5041 0 5041 1.23684e-05
R6051 5041 5042 1.68 0.8 13.44 37
I5042 0 5042 1.27395e-05
R6052 5042 5043 1.616 0.8 12.928 37
I5043 0 5043 1.27395e-05
R6053 5043 5044 1.648 0.8 13.184 37
I5044 0 5044 1.34816e-05
R6054 5044 5045 1.616 0.8 12.928 37
I5045 0 5045 1.32342e-05
R6055 5045 5046 1.696 0.8 13.568 37
I5046 0 5046 1.31105e-05
R6056 5046 5047 1.6 0.8 12.8 37
I5047 0 5047 1.27395e-05
R6057 5047 5048 1.648 0.8 13.184 37
I5048 0 5048 1.27395e-05
R6058 5048 5049 1.68 0.8 13.44 37
I5049 0 5049 1.33579e-05
R6059 5049 5050 1.648 0.8 13.184 37
I5050 0 5050 1.23684e-05
R6060 5050 0 0.1 49.28 49.28 37
*seg: 506
R6061 0 5051 0.1 49.28 49.28 37
R6062 5055 5065 6.16 0.8 49.28 37
I5051 0 5051 1.29868e-05
R6063 5051 5052 1.744 0.8 13.952 37
I5052 0 5052 1.31105e-05
R6064 5052 5053 1.6 0.8 12.8 37
I5053 0 5053 1.33579e-05
R6065 5053 5054 1.6 0.8 12.8 37
I5054 0 5054 1.24921e-05
R6066 5054 5055 1.68 0.8 13.44 37
I5055 0 5055 1.34816e-05
R6067 5055 5056 1.6 0.8 12.8 37
I5056 0 5056 1.32342e-05
R6068 5056 5057 1.664 0.8 13.312 37
I5057 0 5057 1.34816e-05
R6069 5057 5058 1.696 0.8 13.568 37
I5058 0 5058 1.23684e-05
R6070 5058 5059 1.664 0.8 13.312 37
I5059 0 5059 1.32342e-05
R6071 5059 5060 1.616 0.8 12.928 37
I5060 0 5060 1.23684e-05
R6072 5060 0 0.1 49.28 49.28 37
*seg: 507
R6073 0 5061 0.1 49.28 49.28 37
R6074 5065 5075 6.16 0.8 49.28 37
I5061 0 5061 1.34816e-05
R6075 5061 5062 1.616 0.8 12.928 37
I5062 0 5062 1.32342e-05
R6076 5062 5063 1.68 0.8 13.44 37
I5063 0 5063 1.28631e-05
R6077 5063 5064 1.696 0.8 13.568 37
I5064 0 5064 1.24921e-05
R6078 5064 5065 1.664 0.8 13.312 37
I5065 0 5065 1.33579e-05
R6079 5065 5066 1.664 0.8 13.312 37
I5066 0 5066 1.34816e-05
R6080 5066 5067 1.616 0.8 12.928 37
I5067 0 5067 1.29868e-05
R6081 5067 5068 1.616 0.8 12.928 37
I5068 0 5068 1.28631e-05
R6082 5068 5069 1.616 0.8 12.928 37
I5069 0 5069 1.28631e-05
R6083 5069 5070 1.696 0.8 13.568 37
I5070 0 5070 1.23684e-05
R6084 5070 0 0.1 49.28 49.28 37
*seg: 508
R6085 0 5071 0.1 49.28 49.28 37
R6086 5075 5085 6.16 0.8 49.28 37
I5071 0 5071 1.26158e-05
R6087 5071 5072 1.648 0.8 13.184 37
I5072 0 5072 1.26158e-05
R6088 5072 5073 1.696 0.8 13.568 37
I5073 0 5073 1.32342e-05
R6089 5073 5074 1.68 0.8 13.44 37
I5074 0 5074 1.28631e-05
R6090 5074 5075 1.664 0.8 13.312 37
I5075 0 5075 1.28631e-05
R6091 5075 5076 1.664 0.8 13.312 37
I5076 0 5076 1.26158e-05
R6092 5076 5077 1.664 0.8 13.312 37
I5077 0 5077 1.31105e-05
R6093 5077 5078 1.616 0.8 12.928 37
I5078 0 5078 1.28631e-05
R6094 5078 5079 1.632 0.8 13.056 37
I5079 0 5079 1.32342e-05
R6095 5079 5080 1.696 0.8 13.568 37
I5080 0 5080 1.23684e-05
R6096 5080 0 0.1 49.28 49.28 37
*seg: 509
R6097 0 5081 0.1 49.28 49.28 37
R6098 5085 5095 6.16 0.8 49.28 37
I5081 0 5081 1.27395e-05
R6099 5081 5082 1.6 0.8 12.8 37
I5082 0 5082 1.26158e-05
R6100 5082 5083 1.664 0.8 13.312 37
I5083 0 5083 1.31105e-05
R6101 5083 5084 1.648 0.8 13.184 37
I5084 0 5084 1.23684e-05
R6102 5084 5085 1.744 0.8 13.952 37
I5085 0 5085 1.32342e-05
R6103 5085 5086 1.664 0.8 13.312 37
I5086 0 5086 1.31105e-05
R6104 5086 5087 1.648 0.8 13.184 37
I5087 0 5087 1.32342e-05
R6105 5087 5088 1.728 0.8 13.824 37
I5088 0 5088 1.33579e-05
R6106 5088 5089 1.664 0.8 13.312 37
I5089 0 5089 1.29868e-05
R6107 5089 5090 1.632 0.8 13.056 37
I5090 0 5090 1.23684e-05
R6108 5090 0 0.1 49.28 49.28 37
*seg: 510
R6109 0 5091 0.1 49.28 49.28 37
R6110 5095 5105 6.16 0.8 49.28 37
I5091 0 5091 1.26158e-05
R6111 5091 5092 1.616 0.8 12.928 37
I5092 0 5092 1.33579e-05
R6112 5092 5093 1.616 0.8 12.928 37
I5093 0 5093 1.26158e-05
R6113 5093 5094 1.648 0.8 13.184 37
I5094 0 5094 1.32342e-05
R6114 5094 5095 1.6 0.8 12.8 37
I5095 0 5095 1.27395e-05
R6115 5095 5096 1.616 0.8 12.928 37
I5096 0 5096 1.28631e-05
R6116 5096 5097 1.6 0.8 12.8 37
I5097 0 5097 1.26158e-05
R6117 5097 5098 1.6 0.8 12.8 37
I5098 0 5098 1.28631e-05
R6118 5098 5099 1.648 0.8 13.184 37
I5099 0 5099 1.34816e-05
R6119 5099 5100 1.648 0.8 13.184 37
I5100 0 5100 1.23684e-05
R6120 5100 0 0.1 49.28 49.28 37
*seg: 511
R6121 0 5101 0.1 49.28 49.28 37
R6122 5105 5115 6.16 0.8 49.28 37
I5101 0 5101 1.23684e-05
R6123 5101 5102 1.728 0.8 13.824 37
I5102 0 5102 1.27395e-05
R6124 5102 5103 1.712 0.8 13.696 37
I5103 0 5103 1.26158e-05
R6125 5103 5104 1.616 0.8 12.928 37
I5104 0 5104 1.31105e-05
R6126 5104 5105 1.744 0.8 13.952 37
I5105 0 5105 1.23684e-05
R6127 5105 5106 1.744 0.8 13.952 37
I5106 0 5106 1.26158e-05
R6128 5106 5107 1.712 0.8 13.696 37
I5107 0 5107 1.31105e-05
R6129 5107 5108 1.712 0.8 13.696 37
I5108 0 5108 1.28631e-05
R6130 5108 5109 1.6 0.8 12.8 37
I5109 0 5109 1.29868e-05
R6131 5109 5110 1.6 0.8 12.8 37
I5110 0 5110 1.23684e-05
R6132 5110 0 0.1 49.28 49.28 37
*seg: 512
R6133 0 5111 0.1 49.28 49.28 37
R6134 5115 5125 6.16 0.8 49.28 37
I5111 0 5111 1.28631e-05
R6135 5111 5112 1.632 0.8 13.056 37
I5112 0 5112 1.29868e-05
R6136 5112 5113 1.6 0.8 12.8 37
I5113 0 5113 1.28631e-05
R6137 5113 5114 1.616 0.8 12.928 37
I5114 0 5114 1.32342e-05
R6138 5114 5115 1.632 0.8 13.056 37
I5115 0 5115 1.32342e-05
R6139 5115 5116 1.6 0.8 12.8 37
I5116 0 5116 1.24921e-05
R6140 5116 5117 1.632 0.8 13.056 37
I5117 0 5117 1.28631e-05
R6141 5117 5118 1.712 0.8 13.696 37
I5118 0 5118 1.34816e-05
R6142 5118 5119 1.744 0.8 13.952 37
I5119 0 5119 1.27395e-05
R6143 5119 5120 1.696 0.8 13.568 37
I5120 0 5120 1.23684e-05
R6144 5120 0 0.1 49.28 49.28 37
*seg: 513
R6145 0 5121 0.1 49.28 49.28 37
R6146 5125 5135 6.16 0.8 49.28 37
I5121 0 5121 1.28631e-05
R6147 5121 5122 1.712 0.8 13.696 37
I5122 0 5122 1.31105e-05
R6148 5122 5123 1.712 0.8 13.696 37
I5123 0 5123 1.28631e-05
R6149 5123 5124 1.712 0.8 13.696 37
I5124 0 5124 1.29868e-05
R6150 5124 5125 1.648 0.8 13.184 37
I5125 0 5125 1.27395e-05
R6151 5125 5126 1.664 0.8 13.312 37
I5126 0 5126 1.24921e-05
R6152 5126 5127 1.68 0.8 13.44 37
I5127 0 5127 1.32342e-05
R6153 5127 5128 1.6 0.8 12.8 37
I5128 0 5128 1.34816e-05
R6154 5128 5129 1.648 0.8 13.184 37
I5129 0 5129 1.28631e-05
R6155 5129 5130 1.68 0.8 13.44 37
I5130 0 5130 1.23684e-05
R6156 5130 0 0.1 49.28 49.28 37
*seg: 514
R6157 0 5131 0.1 49.28 49.28 37
R6158 5135 5145 6.16 0.8 49.28 37
I5131 0 5131 1.34816e-05
R6159 5131 5132 1.648 0.8 13.184 37
I5132 0 5132 1.24921e-05
R6160 5132 5133 1.744 0.8 13.952 37
I5133 0 5133 1.29868e-05
R6161 5133 5134 1.728 0.8 13.824 37
I5134 0 5134 1.32342e-05
R6162 5134 5135 1.6 0.8 12.8 37
I5135 0 5135 1.28631e-05
R6163 5135 5136 1.744 0.8 13.952 37
I5136 0 5136 1.27395e-05
R6164 5136 5137 1.6 0.8 12.8 37
I5137 0 5137 1.27395e-05
R6165 5137 5138 1.744 0.8 13.952 37
I5138 0 5138 1.27395e-05
R6166 5138 5139 1.616 0.8 12.928 37
I5139 0 5139 1.29868e-05
R6167 5139 5140 1.616 0.8 12.928 37
I5140 0 5140 1.23684e-05
R6168 5140 0 0.1 49.28 49.28 37
*seg: 515
R6169 0 5141 0.1 49.28 49.28 37
R6170 5145 5155 6.16 0.8 49.28 37
I5141 0 5141 1.24921e-05
R6171 5141 5142 1.744 0.8 13.952 37
I5142 0 5142 1.26158e-05
R6172 5142 5143 1.664 0.8 13.312 37
I5143 0 5143 1.27395e-05
R6173 5143 5144 1.632 0.8 13.056 37
I5144 0 5144 1.34816e-05
R6174 5144 5145 1.664 0.8 13.312 37
I5145 0 5145 1.24921e-05
R6175 5145 5146 1.632 0.8 13.056 37
I5146 0 5146 1.24921e-05
R6176 5146 5147 1.712 0.8 13.696 37
I5147 0 5147 1.34816e-05
R6177 5147 5148 1.6 0.8 12.8 37
I5148 0 5148 1.32342e-05
R6178 5148 5149 1.712 0.8 13.696 37
I5149 0 5149 1.29868e-05
R6179 5149 5150 1.632 0.8 13.056 37
I5150 0 5150 1.23684e-05
R6180 5150 0 0.1 49.28 49.28 37
*seg: 516
R6181 0 5151 0.1 49.28 49.28 37
R6182 5155 5165 6.16 0.8 49.28 37
I5151 0 5151 1.26158e-05
R6183 5151 5152 1.728 0.8 13.824 37
I5152 0 5152 1.26158e-05
R6184 5152 5153 1.696 0.8 13.568 37
I5153 0 5153 1.23684e-05
R6185 5153 5154 1.68 0.8 13.44 37
I5154 0 5154 1.26158e-05
R6186 5154 5155 1.6 0.8 12.8 37
I5155 0 5155 1.27395e-05
R6187 5155 5156 1.696 0.8 13.568 37
I5156 0 5156 1.32342e-05
R6188 5156 5157 1.648 0.8 13.184 37
I5157 0 5157 1.28631e-05
R6189 5157 5158 1.616 0.8 12.928 37
I5158 0 5158 1.24921e-05
R6190 5158 5159 1.616 0.8 12.928 37
I5159 0 5159 1.32342e-05
R6191 5159 5160 1.632 0.8 13.056 37
I5160 0 5160 1.23684e-05
R6192 5160 0 0.1 49.28 49.28 37
*seg: 517
R6193 0 5161 0.1 49.28 49.28 37
R6194 5165 5175 6.16 0.8 49.28 37
I5161 0 5161 1.32342e-05
R6195 5161 5162 1.648 0.8 13.184 37
I5162 0 5162 1.28631e-05
R6196 5162 5163 1.616 0.8 12.928 37
I5163 0 5163 1.26158e-05
R6197 5163 5164 1.68 0.8 13.44 37
I5164 0 5164 1.31105e-05
R6198 5164 5165 1.632 0.8 13.056 37
I5165 0 5165 1.26158e-05
R6199 5165 5166 1.664 0.8 13.312 37
I5166 0 5166 1.29868e-05
R6200 5166 5167 1.744 0.8 13.952 37
I5167 0 5167 1.33579e-05
R6201 5167 5168 1.632 0.8 13.056 37
I5168 0 5168 1.31105e-05
R6202 5168 5169 1.632 0.8 13.056 37
I5169 0 5169 1.28631e-05
R6203 5169 5170 1.664 0.8 13.312 37
I5170 0 5170 1.23684e-05
R6204 5170 0 0.1 49.28 49.28 37
*seg: 518
R6205 0 5171 0.1 49.28 49.28 37
R6206 5175 5185 6.16 0.8 49.28 37
I5171 0 5171 1.32342e-05
R6207 5171 5172 1.68 0.8 13.44 37
I5172 0 5172 1.23684e-05
R6208 5172 5173 1.664 0.8 13.312 37
I5173 0 5173 1.24921e-05
R6209 5173 5174 1.648 0.8 13.184 37
I5174 0 5174 1.27395e-05
R6210 5174 5175 1.6 0.8 12.8 37
I5175 0 5175 1.32342e-05
R6211 5175 5176 1.648 0.8 13.184 37
I5176 0 5176 1.28631e-05
R6212 5176 5177 1.664 0.8 13.312 37
I5177 0 5177 1.24921e-05
R6213 5177 5178 1.68 0.8 13.44 37
I5178 0 5178 1.34816e-05
R6214 5178 5179 1.712 0.8 13.696 37
I5179 0 5179 1.26158e-05
R6215 5179 5180 1.696 0.8 13.568 37
I5180 0 5180 1.23684e-05
R6216 5180 0 0.1 49.28 49.28 37
*seg: 519
R6217 0 5181 0.1 49.28 49.28 37
R6218 5185 5195 6.16 0.8 49.28 37
I5181 0 5181 1.28631e-05
R6219 5181 5182 1.712 0.8 13.696 37
I5182 0 5182 1.24921e-05
R6220 5182 5183 1.6 0.8 12.8 37
I5183 0 5183 1.24921e-05
R6221 5183 5184 1.728 0.8 13.824 37
I5184 0 5184 1.33579e-05
R6222 5184 5185 1.616 0.8 12.928 37
I5185 0 5185 1.33579e-05
R6223 5185 5186 1.728 0.8 13.824 37
I5186 0 5186 1.28631e-05
R6224 5186 5187 1.6 0.8 12.8 37
I5187 0 5187 1.33579e-05
R6225 5187 5188 1.616 0.8 12.928 37
I5188 0 5188 1.34816e-05
R6226 5188 5189 1.68 0.8 13.44 37
I5189 0 5189 1.31105e-05
R6227 5189 5190 1.648 0.8 13.184 37
I5190 0 5190 1.23684e-05
R6228 5190 0 0.1 49.28 49.28 37
*seg: 520
R6229 0 5191 0.1 49.28 49.28 37
R6230 5195 5205 6.16 0.8 49.28 37
I5191 0 5191 1.27395e-05
R6231 5191 5192 1.696 0.8 13.568 37
I5192 0 5192 1.26158e-05
R6232 5192 5193 1.744 0.8 13.952 37
I5193 0 5193 1.32342e-05
R6233 5193 5194 1.728 0.8 13.824 37
I5194 0 5194 1.32342e-05
R6234 5194 5195 1.664 0.8 13.312 37
I5195 0 5195 1.32342e-05
R6235 5195 5196 1.744 0.8 13.952 37
I5196 0 5196 1.29868e-05
R6236 5196 5197 1.696 0.8 13.568 37
I5197 0 5197 1.24921e-05
R6237 5197 5198 1.744 0.8 13.952 37
I5198 0 5198 1.29868e-05
R6238 5198 5199 1.648 0.8 13.184 37
I5199 0 5199 1.34816e-05
R6239 5199 5200 1.696 0.8 13.568 37
I5200 0 5200 1.23684e-05
R6240 5200 0 0.1 49.28 49.28 37
*seg: 521
R6241 0 5201 0.1 49.28 49.28 37
R6242 5205 5215 6.16 0.8 49.28 37
I5201 0 5201 1.27395e-05
R6243 5201 5202 1.728 0.8 13.824 37
I5202 0 5202 1.24921e-05
R6244 5202 5203 1.728 0.8 13.824 37
I5203 0 5203 1.29868e-05
R6245 5203 5204 1.648 0.8 13.184 37
I5204 0 5204 1.29868e-05
R6246 5204 5205 1.6 0.8 12.8 37
I5205 0 5205 1.32342e-05
R6247 5205 5206 1.696 0.8 13.568 37
I5206 0 5206 1.32342e-05
R6248 5206 5207 1.648 0.8 13.184 37
I5207 0 5207 1.31105e-05
R6249 5207 5208 1.6 0.8 12.8 37
I5208 0 5208 1.26158e-05
R6250 5208 5209 1.68 0.8 13.44 37
I5209 0 5209 1.31105e-05
R6251 5209 5210 1.616 0.8 12.928 37
I5210 0 5210 1.23684e-05
R6252 5210 0 0.1 49.28 49.28 37
*seg: 522
R6253 0 5211 0.1 49.28 49.28 37
R6254 5215 5225 6.16 0.8 49.28 37
I5211 0 5211 1.24921e-05
R6255 5211 5212 1.728 0.8 13.824 37
I5212 0 5212 1.34816e-05
R6256 5212 5213 1.6 0.8 12.8 37
I5213 0 5213 1.34816e-05
R6257 5213 5214 1.728 0.8 13.824 37
I5214 0 5214 1.27395e-05
R6258 5214 5215 1.632 0.8 13.056 37
I5215 0 5215 1.28631e-05
R6259 5215 5216 1.696 0.8 13.568 37
I5216 0 5216 1.29868e-05
R6260 5216 5217 1.744 0.8 13.952 37
I5217 0 5217 1.31105e-05
R6261 5217 5218 1.6 0.8 12.8 37
I5218 0 5218 1.23684e-05
R6262 5218 5219 1.616 0.8 12.928 37
I5219 0 5219 1.28631e-05
R6263 5219 5220 1.728 0.8 13.824 37
I5220 0 5220 1.23684e-05
R6264 5220 0 0.1 49.28 49.28 37
*seg: 523
R6265 0 5221 0.1 49.28 49.28 37
R6266 5225 5235 6.16 0.8 49.28 37
I5221 0 5221 1.24921e-05
R6267 5221 5222 1.68 0.8 13.44 37
I5222 0 5222 1.28631e-05
R6268 5222 5223 1.728 0.8 13.824 37
I5223 0 5223 1.29868e-05
R6269 5223 5224 1.664 0.8 13.312 37
I5224 0 5224 1.33579e-05
R6270 5224 5225 1.648 0.8 13.184 37
I5225 0 5225 1.26158e-05
R6271 5225 5226 1.712 0.8 13.696 37
I5226 0 5226 1.28631e-05
R6272 5226 5227 1.616 0.8 12.928 37
I5227 0 5227 1.32342e-05
R6273 5227 5228 1.68 0.8 13.44 37
I5228 0 5228 1.32342e-05
R6274 5228 5229 1.616 0.8 12.928 37
I5229 0 5229 1.24921e-05
R6275 5229 5230 1.616 0.8 12.928 37
I5230 0 5230 1.23684e-05
R6276 5230 0 0.1 49.28 49.28 37
*seg: 524
R6277 0 5231 0.1 49.28 49.28 37
R6278 5235 5245 6.16 0.8 49.28 37
I5231 0 5231 1.32342e-05
R6279 5231 5232 1.68 0.8 13.44 37
I5232 0 5232 1.26158e-05
R6280 5232 5233 1.728 0.8 13.824 37
I5233 0 5233 1.33579e-05
R6281 5233 5234 1.744 0.8 13.952 37
I5234 0 5234 1.29868e-05
R6282 5234 5235 1.68 0.8 13.44 37
I5235 0 5235 1.34816e-05
R6283 5235 5236 1.744 0.8 13.952 37
I5236 0 5236 1.28631e-05
R6284 5236 5237 1.648 0.8 13.184 37
I5237 0 5237 1.34816e-05
R6285 5237 5238 1.68 0.8 13.44 37
I5238 0 5238 1.32342e-05
R6286 5238 5239 1.68 0.8 13.44 37
I5239 0 5239 1.24921e-05
R6287 5239 5240 1.648 0.8 13.184 37
I5240 0 5240 1.23684e-05
R6288 5240 0 0.1 49.28 49.28 37
*seg: 525
R6289 0 5241 0.1 49.28 49.28 37
R6290 5245 5255 6.16 0.8 49.28 37
I5241 0 5241 1.23684e-05
R6291 5241 5242 1.744 0.8 13.952 37
I5242 0 5242 1.28631e-05
R6292 5242 5243 1.616 0.8 12.928 37
I5243 0 5243 1.29868e-05
R6293 5243 5244 1.728 0.8 13.824 37
I5244 0 5244 1.34816e-05
R6294 5244 5245 1.632 0.8 13.056 37
I5245 0 5245 1.31105e-05
R6295 5245 5246 1.696 0.8 13.568 37
I5246 0 5246 1.24921e-05
R6296 5246 5247 1.648 0.8 13.184 37
I5247 0 5247 1.28631e-05
R6297 5247 5248 1.68 0.8 13.44 37
I5248 0 5248 1.24921e-05
R6298 5248 5249 1.728 0.8 13.824 37
I5249 0 5249 1.28631e-05
R6299 5249 5250 1.648 0.8 13.184 37
I5250 0 5250 1.23684e-05
R6300 5250 0 0.1 49.28 49.28 37
*seg: 526
R6301 0 5251 0.1 49.28 49.28 37
R6302 5255 5265 6.16 0.8 49.28 37
I5251 0 5251 1.31105e-05
R6303 5251 5252 1.712 0.8 13.696 37
I5252 0 5252 1.34816e-05
R6304 5252 5253 1.664 0.8 13.312 37
I5253 0 5253 1.34816e-05
R6305 5253 5254 1.616 0.8 12.928 37
I5254 0 5254 1.26158e-05
R6306 5254 5255 1.664 0.8 13.312 37
I5255 0 5255 1.34816e-05
R6307 5255 5256 1.616 0.8 12.928 37
I5256 0 5256 1.27395e-05
R6308 5256 5257 1.728 0.8 13.824 37
I5257 0 5257 1.33579e-05
R6309 5257 5258 1.648 0.8 13.184 37
I5258 0 5258 1.33579e-05
R6310 5258 5259 1.616 0.8 12.928 37
I5259 0 5259 1.28631e-05
R6311 5259 5260 1.6 0.8 12.8 37
I5260 0 5260 1.23684e-05
R6312 5260 0 0.1 49.28 49.28 37
*seg: 527
R6313 0 5261 0.1 49.28 49.28 37
R6314 5265 5275 6.16 0.8 49.28 37
I5261 0 5261 1.27395e-05
R6315 5261 5262 1.632 0.8 13.056 37
I5262 0 5262 1.24921e-05
R6316 5262 5263 1.648 0.8 13.184 37
I5263 0 5263 1.32342e-05
R6317 5263 5264 1.744 0.8 13.952 37
I5264 0 5264 1.26158e-05
R6318 5264 5265 1.696 0.8 13.568 37
I5265 0 5265 1.34816e-05
R6319 5265 5266 1.616 0.8 12.928 37
I5266 0 5266 1.32342e-05
R6320 5266 5267 1.696 0.8 13.568 37
I5267 0 5267 1.29868e-05
R6321 5267 5268 1.6 0.8 12.8 37
I5268 0 5268 1.33579e-05
R6322 5268 5269 1.728 0.8 13.824 37
I5269 0 5269 1.27395e-05
R6323 5269 5270 1.648 0.8 13.184 37
I5270 0 5270 1.23684e-05
R6324 5270 0 0.1 49.28 49.28 37
*seg: 528
R6325 0 5271 0.1 49.28 49.28 37
R6326 5275 5285 6.16 0.8 49.28 37
I5271 0 5271 1.26158e-05
R6327 5271 5272 1.648 0.8 13.184 37
I5272 0 5272 1.31105e-05
R6328 5272 5273 1.712 0.8 13.696 37
I5273 0 5273 1.24921e-05
R6329 5273 5274 1.6 0.8 12.8 37
I5274 0 5274 1.24921e-05
R6330 5274 5275 1.648 0.8 13.184 37
I5275 0 5275 1.32342e-05
R6331 5275 5276 1.6 0.8 12.8 37
I5276 0 5276 1.29868e-05
R6332 5276 5277 1.728 0.8 13.824 37
I5277 0 5277 1.26158e-05
R6333 5277 5278 1.696 0.8 13.568 37
I5278 0 5278 1.24921e-05
R6334 5278 5279 1.712 0.8 13.696 37
I5279 0 5279 1.24921e-05
R6335 5279 5280 1.664 0.8 13.312 37
I5280 0 5280 1.23684e-05
R6336 5280 0 0.1 49.28 49.28 37
*seg: 529
R6337 0 5281 0.1 49.28 49.28 37
R6338 5285 5295 6.16 0.8 49.28 37
I5281 0 5281 1.28631e-05
R6339 5281 5282 1.728 0.8 13.824 37
I5282 0 5282 1.29868e-05
R6340 5282 5283 1.664 0.8 13.312 37
I5283 0 5283 1.29868e-05
R6341 5283 5284 1.744 0.8 13.952 37
I5284 0 5284 1.24921e-05
R6342 5284 5285 1.6 0.8 12.8 37
I5285 0 5285 1.33579e-05
R6343 5285 5286 1.616 0.8 12.928 37
I5286 0 5286 1.26158e-05
R6344 5286 5287 1.744 0.8 13.952 37
I5287 0 5287 1.33579e-05
R6345 5287 5288 1.632 0.8 13.056 37
I5288 0 5288 1.27395e-05
R6346 5288 5289 1.616 0.8 12.928 37
I5289 0 5289 1.29868e-05
R6347 5289 5290 1.616 0.8 12.928 37
I5290 0 5290 1.23684e-05
R6348 5290 0 0.1 49.28 49.28 37
*seg: 530
R6349 0 5291 0.1 49.28 49.28 37
R6350 5295 5305 6.16 0.8 49.28 37
I5291 0 5291 1.24921e-05
R6351 5291 5292 1.664 0.8 13.312 37
I5292 0 5292 1.33579e-05
R6352 5292 5293 1.744 0.8 13.952 37
I5293 0 5293 1.31105e-05
R6353 5293 5294 1.632 0.8 13.056 37
I5294 0 5294 1.27395e-05
R6354 5294 5295 1.632 0.8 13.056 37
I5295 0 5295 1.34816e-05
R6355 5295 5296 1.744 0.8 13.952 37
I5296 0 5296 1.33579e-05
R6356 5296 5297 1.632 0.8 13.056 37
I5297 0 5297 1.24921e-05
R6357 5297 5298 1.6 0.8 12.8 37
I5298 0 5298 1.33579e-05
R6358 5298 5299 1.632 0.8 13.056 37
I5299 0 5299 1.34816e-05
R6359 5299 5300 1.616 0.8 12.928 37
I5300 0 5300 1.23684e-05
R6360 5300 0 0.1 49.28 49.28 37
*seg: 531
R6361 0 5301 0.1 49.28 49.28 37
R6362 5305 5315 6.16 0.8 49.28 37
I5301 0 5301 1.32342e-05
R6363 5301 5302 1.664 0.8 13.312 37
I5302 0 5302 1.32342e-05
R6364 5302 5303 1.696 0.8 13.568 37
I5303 0 5303 1.31105e-05
R6365 5303 5304 1.744 0.8 13.952 37
I5304 0 5304 1.29868e-05
R6366 5304 5305 1.744 0.8 13.952 37
I5305 0 5305 1.23684e-05
R6367 5305 5306 1.712 0.8 13.696 37
I5306 0 5306 1.26158e-05
R6368 5306 5307 1.616 0.8 12.928 37
I5307 0 5307 1.24921e-05
R6369 5307 5308 1.712 0.8 13.696 37
I5308 0 5308 1.23684e-05
R6370 5308 5309 1.68 0.8 13.44 37
I5309 0 5309 1.24921e-05
R6371 5309 5310 1.616 0.8 12.928 37
I5310 0 5310 1.23684e-05
R6372 5310 0 0.1 49.28 49.28 37
*seg: 532
R6373 0 5311 0.1 49.28 49.28 37
R6374 5315 5325 6.16 0.8 49.28 37
I5311 0 5311 1.34816e-05
R6375 5311 5312 1.648 0.8 13.184 37
I5312 0 5312 1.28631e-05
R6376 5312 5313 1.696 0.8 13.568 37
I5313 0 5313 1.23684e-05
R6377 5313 5314 1.68 0.8 13.44 37
I5314 0 5314 1.32342e-05
R6378 5314 5315 1.632 0.8 13.056 37
I5315 0 5315 1.29868e-05
R6379 5315 5316 1.648 0.8 13.184 37
I5316 0 5316 1.33579e-05
R6380 5316 5317 1.68 0.8 13.44 37
I5317 0 5317 1.32342e-05
R6381 5317 5318 1.664 0.8 13.312 37
I5318 0 5318 1.31105e-05
R6382 5318 5319 1.696 0.8 13.568 37
I5319 0 5319 1.29868e-05
R6383 5319 5320 1.728 0.8 13.824 37
I5320 0 5320 1.23684e-05
R6384 5320 0 0.1 49.28 49.28 37
*seg: 533
R6385 0 5321 0.1 49.28 49.28 37
R6386 5325 5335 6.16 0.8 49.28 37
I5321 0 5321 1.32342e-05
R6387 5321 5322 1.648 0.8 13.184 37
I5322 0 5322 1.33579e-05
R6388 5322 5323 1.6 0.8 12.8 37
I5323 0 5323 1.31105e-05
R6389 5323 5324 1.648 0.8 13.184 37
I5324 0 5324 1.28631e-05
R6390 5324 5325 1.744 0.8 13.952 37
I5325 0 5325 1.28631e-05
R6391 5325 5326 1.728 0.8 13.824 37
I5326 0 5326 1.27395e-05
R6392 5326 5327 1.632 0.8 13.056 37
I5327 0 5327 1.33579e-05
R6393 5327 5328 1.728 0.8 13.824 37
I5328 0 5328 1.26158e-05
R6394 5328 5329 1.68 0.8 13.44 37
I5329 0 5329 1.26158e-05
R6395 5329 5330 1.632 0.8 13.056 37
I5330 0 5330 1.23684e-05
R6396 5330 0 0.1 49.28 49.28 37
*seg: 534
R6397 0 5331 0.1 49.28 49.28 37
R6398 5335 5345 6.16 0.8 49.28 37
I5331 0 5331 1.24921e-05
R6399 5331 5332 1.6 0.8 12.8 37
I5332 0 5332 1.26158e-05
R6400 5332 5333 1.6 0.8 12.8 37
I5333 0 5333 1.27395e-05
R6401 5333 5334 1.6 0.8 12.8 37
I5334 0 5334 1.29868e-05
R6402 5334 5335 1.632 0.8 13.056 37
I5335 0 5335 1.24921e-05
R6403 5335 5336 1.632 0.8 13.056 37
I5336 0 5336 1.33579e-05
R6404 5336 5337 1.728 0.8 13.824 37
I5337 0 5337 1.27395e-05
R6405 5337 5338 1.616 0.8 12.928 37
I5338 0 5338 1.29868e-05
R6406 5338 5339 1.6 0.8 12.8 37
I5339 0 5339 1.33579e-05
R6407 5339 5340 1.728 0.8 13.824 37
I5340 0 5340 1.23684e-05
R6408 5340 0 0.1 49.28 49.28 37
*seg: 535
R6409 0 5341 0.1 49.28 49.28 37
R6410 5345 5355 6.16 0.8 49.28 37
I5341 0 5341 1.33579e-05
R6411 5341 5342 1.632 0.8 13.056 37
I5342 0 5342 1.28631e-05
R6412 5342 5343 1.712 0.8 13.696 37
I5343 0 5343 1.32342e-05
R6413 5343 5344 1.632 0.8 13.056 37
I5344 0 5344 1.26158e-05
R6414 5344 5345 1.712 0.8 13.696 37
I5345 0 5345 1.27395e-05
R6415 5345 5346 1.648 0.8 13.184 37
I5346 0 5346 1.24921e-05
R6416 5346 5347 1.6 0.8 12.8 37
I5347 0 5347 1.27395e-05
R6417 5347 5348 1.744 0.8 13.952 37
I5348 0 5348 1.31105e-05
R6418 5348 5349 1.6 0.8 12.8 37
I5349 0 5349 1.34816e-05
R6419 5349 5350 1.744 0.8 13.952 37
I5350 0 5350 1.23684e-05
R6420 5350 0 0.1 49.28 49.28 37
*seg: 536
R6421 0 5351 0.1 49.28 49.28 37
R6422 5355 5365 6.16 0.8 49.28 37
I5351 0 5351 1.28631e-05
R6423 5351 5352 1.712 0.8 13.696 37
I5352 0 5352 1.29868e-05
R6424 5352 5353 1.616 0.8 12.928 37
I5353 0 5353 1.34816e-05
R6425 5353 5354 1.744 0.8 13.952 37
I5354 0 5354 1.24921e-05
R6426 5354 5355 1.68 0.8 13.44 37
I5355 0 5355 1.24921e-05
R6427 5355 5356 1.664 0.8 13.312 37
I5356 0 5356 1.28631e-05
R6428 5356 5357 1.744 0.8 13.952 37
I5357 0 5357 1.33579e-05
R6429 5357 5358 1.648 0.8 13.184 37
I5358 0 5358 1.28631e-05
R6430 5358 5359 1.712 0.8 13.696 37
I5359 0 5359 1.23684e-05
R6431 5359 5360 1.728 0.8 13.824 37
I5360 0 5360 1.23684e-05
R6432 5360 0 0.1 49.28 49.28 37
*seg: 537
R6433 0 5361 0.1 49.28 49.28 37
R6434 5365 5375 6.16 0.8 49.28 37
I5361 0 5361 1.23684e-05
R6435 5361 5362 1.648 0.8 13.184 37
I5362 0 5362 1.24921e-05
R6436 5362 5363 1.728 0.8 13.824 37
I5363 0 5363 1.32342e-05
R6437 5363 5364 1.68 0.8 13.44 37
I5364 0 5364 1.23684e-05
R6438 5364 5365 1.664 0.8 13.312 37
I5365 0 5365 1.29868e-05
R6439 5365 5366 1.744 0.8 13.952 37
I5366 0 5366 1.26158e-05
R6440 5366 5367 1.648 0.8 13.184 37
I5367 0 5367 1.28631e-05
R6441 5367 5368 1.6 0.8 12.8 37
I5368 0 5368 1.24921e-05
R6442 5368 5369 1.68 0.8 13.44 37
I5369 0 5369 1.33579e-05
R6443 5369 5370 1.728 0.8 13.824 37
I5370 0 5370 1.23684e-05
R6444 5370 0 0.1 49.28 49.28 37
*seg: 538
R6445 0 5371 0.1 49.28 49.28 37
R6446 5375 5385 6.16 0.8 49.28 37
I5371 0 5371 1.28631e-05
R6447 5371 5372 1.728 0.8 13.824 37
I5372 0 5372 1.28631e-05
R6448 5372 5373 1.696 0.8 13.568 37
I5373 0 5373 1.24921e-05
R6449 5373 5374 1.616 0.8 12.928 37
I5374 0 5374 1.29868e-05
R6450 5374 5375 1.632 0.8 13.056 37
I5375 0 5375 1.33579e-05
R6451 5375 5376 1.744 0.8 13.952 37
I5376 0 5376 1.27395e-05
R6452 5376 5377 1.712 0.8 13.696 37
I5377 0 5377 1.32342e-05
R6453 5377 5378 1.616 0.8 12.928 37
I5378 0 5378 1.24921e-05
R6454 5378 5379 1.6 0.8 12.8 37
I5379 0 5379 1.27395e-05
R6455 5379 5380 1.68 0.8 13.44 37
I5380 0 5380 1.23684e-05
R6456 5380 0 0.1 49.28 49.28 37
*seg: 539
R6457 0 5381 0.1 49.28 49.28 37
R6458 5385 5395 6.16 0.8 49.28 37
I5381 0 5381 1.33579e-05
R6459 5381 5382 1.6 0.8 12.8 37
I5382 0 5382 1.23684e-05
R6460 5382 5383 1.648 0.8 13.184 37
I5383 0 5383 1.24921e-05
R6461 5383 5384 1.632 0.8 13.056 37
I5384 0 5384 1.28631e-05
R6462 5384 5385 1.696 0.8 13.568 37
I5385 0 5385 1.24921e-05
R6463 5385 5386 1.632 0.8 13.056 37
I5386 0 5386 1.28631e-05
R6464 5386 5387 1.696 0.8 13.568 37
I5387 0 5387 1.33579e-05
R6465 5387 5388 1.712 0.8 13.696 37
I5388 0 5388 1.29868e-05
R6466 5388 5389 1.712 0.8 13.696 37
I5389 0 5389 1.34816e-05
R6467 5389 5390 1.664 0.8 13.312 37
I5390 0 5390 1.23684e-05
R6468 5390 0 0.1 49.28 49.28 37
*seg: 540
R6469 0 5391 0.1 49.28 49.28 37
R6470 5395 5405 6.16 0.8 49.28 37
I5391 0 5391 1.34816e-05
R6471 5391 5392 1.648 0.8 13.184 37
I5392 0 5392 1.24921e-05
R6472 5392 5393 1.664 0.8 13.312 37
I5393 0 5393 1.28631e-05
R6473 5393 5394 1.712 0.8 13.696 37
I5394 0 5394 1.29868e-05
R6474 5394 5395 1.616 0.8 12.928 37
I5395 0 5395 1.23684e-05
R6475 5395 5396 1.6 0.8 12.8 37
I5396 0 5396 1.34816e-05
R6476 5396 5397 1.712 0.8 13.696 37
I5397 0 5397 1.24921e-05
R6477 5397 5398 1.696 0.8 13.568 37
I5398 0 5398 1.28631e-05
R6478 5398 5399 1.68 0.8 13.44 37
I5399 0 5399 1.33579e-05
R6479 5399 5400 1.6 0.8 12.8 37
I5400 0 5400 1.23684e-05
R6480 5400 0 0.1 49.28 49.28 37
*seg: 541
R6481 0 5401 0.1 49.28 49.28 37
R6482 5405 5415 6.16 0.8 49.28 37
I5401 0 5401 1.28631e-05
R6483 5401 5402 1.616 0.8 12.928 37
I5402 0 5402 1.32342e-05
R6484 5402 5403 1.632 0.8 13.056 37
I5403 0 5403 1.33579e-05
R6485 5403 5404 1.648 0.8 13.184 37
I5404 0 5404 1.26158e-05
R6486 5404 5405 1.616 0.8 12.928 37
I5405 0 5405 1.34816e-05
R6487 5405 5406 1.744 0.8 13.952 37
I5406 0 5406 1.23684e-05
R6488 5406 5407 1.696 0.8 13.568 37
I5407 0 5407 1.26158e-05
R6489 5407 5408 1.696 0.8 13.568 37
I5408 0 5408 1.31105e-05
R6490 5408 5409 1.696 0.8 13.568 37
I5409 0 5409 1.24921e-05
R6491 5409 5410 1.712 0.8 13.696 37
I5410 0 5410 1.23684e-05
R6492 5410 0 0.1 49.28 49.28 37
*seg: 542
R6493 0 5411 0.1 49.28 49.28 37
R6494 5415 5425 6.16 0.8 49.28 37
I5411 0 5411 1.29868e-05
R6495 5411 5412 1.712 0.8 13.696 37
I5412 0 5412 1.32342e-05
R6496 5412 5413 1.696 0.8 13.568 37
I5413 0 5413 1.27395e-05
R6497 5413 5414 1.6 0.8 12.8 37
I5414 0 5414 1.23684e-05
R6498 5414 5415 1.616 0.8 12.928 37
I5415 0 5415 1.28631e-05
R6499 5415 5416 1.68 0.8 13.44 37
I5416 0 5416 1.27395e-05
R6500 5416 5417 1.712 0.8 13.696 37
I5417 0 5417 1.32342e-05
R6501 5417 5418 1.712 0.8 13.696 37
I5418 0 5418 1.23684e-05
R6502 5418 5419 1.616 0.8 12.928 37
I5419 0 5419 1.28631e-05
R6503 5419 5420 1.68 0.8 13.44 37
I5420 0 5420 1.23684e-05
R6504 5420 0 0.1 49.28 49.28 37
*seg: 543
R6505 0 5421 0.1 49.28 49.28 37
R6506 5425 5435 6.16 0.8 49.28 37
I5421 0 5421 1.27395e-05
R6507 5421 5422 1.6 0.8 12.8 37
I5422 0 5422 1.33579e-05
R6508 5422 5423 1.632 0.8 13.056 37
I5423 0 5423 1.24921e-05
R6509 5423 5424 1.696 0.8 13.568 37
I5424 0 5424 1.23684e-05
R6510 5424 5425 1.712 0.8 13.696 37
I5425 0 5425 1.23684e-05
R6511 5425 5426 1.616 0.8 12.928 37
I5426 0 5426 1.34816e-05
R6512 5426 5427 1.696 0.8 13.568 37
I5427 0 5427 1.28631e-05
R6513 5427 5428 1.616 0.8 12.928 37
I5428 0 5428 1.26158e-05
R6514 5428 5429 1.744 0.8 13.952 37
I5429 0 5429 1.27395e-05
R6515 5429 5430 1.744 0.8 13.952 37
I5430 0 5430 1.23684e-05
R6516 5430 0 0.1 49.28 49.28 37
*seg: 544
R6517 0 5431 0.1 49.28 49.28 37
R6518 5435 5445 6.16 0.8 49.28 37
I5431 0 5431 1.26158e-05
R6519 5431 5432 1.616 0.8 12.928 37
I5432 0 5432 1.33579e-05
R6520 5432 5433 1.744 0.8 13.952 37
I5433 0 5433 1.32342e-05
R6521 5433 5434 1.6 0.8 12.8 37
I5434 0 5434 1.26158e-05
R6522 5434 5435 1.68 0.8 13.44 37
I5435 0 5435 1.27395e-05
R6523 5435 5436 1.728 0.8 13.824 37
I5436 0 5436 1.27395e-05
R6524 5436 5437 1.632 0.8 13.056 37
I5437 0 5437 1.27395e-05
R6525 5437 5438 1.632 0.8 13.056 37
I5438 0 5438 1.27395e-05
R6526 5438 5439 1.696 0.8 13.568 37
I5439 0 5439 1.33579e-05
R6527 5439 5440 1.744 0.8 13.952 37
I5440 0 5440 1.23684e-05
R6528 5440 0 0.1 49.28 49.28 37
*seg: 545
R6529 0 5441 0.1 49.28 49.28 37
R6530 5445 5455 6.16 0.8 49.28 37
I5441 0 5441 1.31105e-05
R6531 5441 5442 1.696 0.8 13.568 37
I5442 0 5442 1.28631e-05
R6532 5442 5443 1.648 0.8 13.184 37
I5443 0 5443 1.32342e-05
R6533 5443 5444 1.744 0.8 13.952 37
I5444 0 5444 1.32342e-05
R6534 5444 5445 1.744 0.8 13.952 37
I5445 0 5445 1.23684e-05
R6535 5445 5446 1.68 0.8 13.44 37
I5446 0 5446 1.27395e-05
R6536 5446 5447 1.68 0.8 13.44 37
I5447 0 5447 1.24921e-05
R6537 5447 5448 1.616 0.8 12.928 37
I5448 0 5448 1.24921e-05
R6538 5448 5449 1.68 0.8 13.44 37
I5449 0 5449 1.33579e-05
R6539 5449 5450 1.712 0.8 13.696 37
I5450 0 5450 1.23684e-05
R6540 5450 0 0.1 49.28 49.28 37
*seg: 546
R6541 0 5451 0.1 49.28 49.28 37
R6542 5455 5465 6.16 0.8 49.28 37
I5451 0 5451 1.23684e-05
R6543 5451 5452 1.616 0.8 12.928 37
I5452 0 5452 1.26158e-05
R6544 5452 5453 1.632 0.8 13.056 37
I5453 0 5453 1.28631e-05
R6545 5453 5454 1.712 0.8 13.696 37
I5454 0 5454 1.33579e-05
R6546 5454 5455 1.728 0.8 13.824 37
I5455 0 5455 1.28631e-05
R6547 5455 5456 1.616 0.8 12.928 37
I5456 0 5456 1.29868e-05
R6548 5456 5457 1.664 0.8 13.312 37
I5457 0 5457 1.27395e-05
R6549 5457 5458 1.696 0.8 13.568 37
I5458 0 5458 1.33579e-05
R6550 5458 5459 1.712 0.8 13.696 37
I5459 0 5459 1.28631e-05
R6551 5459 5460 1.6 0.8 12.8 37
I5460 0 5460 1.23684e-05
R6552 5460 0 0.1 49.28 49.28 37
*seg: 547
R6553 0 5461 0.1 49.28 49.28 37
R6554 5465 5475 6.16 0.8 49.28 37
I5461 0 5461 1.23684e-05
R6555 5461 5462 1.648 0.8 13.184 37
I5462 0 5462 1.33579e-05
R6556 5462 5463 1.616 0.8 12.928 37
I5463 0 5463 1.27395e-05
R6557 5463 5464 1.696 0.8 13.568 37
I5464 0 5464 1.26158e-05
R6558 5464 5465 1.744 0.8 13.952 37
I5465 0 5465 1.26158e-05
R6559 5465 5466 1.664 0.8 13.312 37
I5466 0 5466 1.27395e-05
R6560 5466 5467 1.696 0.8 13.568 37
I5467 0 5467 1.29868e-05
R6561 5467 5468 1.616 0.8 12.928 37
I5468 0 5468 1.32342e-05
R6562 5468 5469 1.696 0.8 13.568 37
I5469 0 5469 1.27395e-05
R6563 5469 5470 1.616 0.8 12.928 37
I5470 0 5470 1.23684e-05
R6564 5470 0 0.1 49.28 49.28 37
*seg: 548
R6565 0 5471 0.1 49.28 49.28 37
R6566 5475 5485 6.16 0.8 49.28 37
I5471 0 5471 1.32342e-05
R6567 5471 5472 1.6 0.8 12.8 37
I5472 0 5472 1.27395e-05
R6568 5472 5473 1.664 0.8 13.312 37
I5473 0 5473 1.26158e-05
R6569 5473 5474 1.728 0.8 13.824 37
I5474 0 5474 1.24921e-05
R6570 5474 5475 1.712 0.8 13.696 37
I5475 0 5475 1.24921e-05
R6571 5475 5476 1.616 0.8 12.928 37
I5476 0 5476 1.29868e-05
R6572 5476 5477 1.696 0.8 13.568 37
I5477 0 5477 1.24921e-05
R6573 5477 5478 1.616 0.8 12.928 37
I5478 0 5478 1.34816e-05
R6574 5478 5479 1.696 0.8 13.568 37
I5479 0 5479 1.33579e-05
R6575 5479 5480 1.6 0.8 12.8 37
I5480 0 5480 1.23684e-05
R6576 5480 0 0.1 49.28 49.28 37
*seg: 549
R6577 0 5481 0.1 49.28 49.28 37
R6578 5485 5495 6.16 0.8 49.28 37
I5481 0 5481 1.34816e-05
R6579 5481 5482 1.744 0.8 13.952 37
I5482 0 5482 1.28631e-05
R6580 5482 5483 1.616 0.8 12.928 37
I5483 0 5483 1.31105e-05
R6581 5483 5484 1.616 0.8 12.928 37
I5484 0 5484 1.28631e-05
R6582 5484 5485 1.728 0.8 13.824 37
I5485 0 5485 1.34816e-05
R6583 5485 5486 1.632 0.8 13.056 37
I5486 0 5486 1.27395e-05
R6584 5486 5487 1.632 0.8 13.056 37
I5487 0 5487 1.24921e-05
R6585 5487 5488 1.648 0.8 13.184 37
I5488 0 5488 1.24921e-05
R6586 5488 5489 1.6 0.8 12.8 37
I5489 0 5489 1.26158e-05
R6587 5489 5490 1.6 0.8 12.8 37
I5490 0 5490 1.23684e-05
R6588 5490 0 0.1 49.28 49.28 37
*seg: 550
R6589 0 5491 0.1 49.28 49.28 37
R6590 5495 5505 6.16 0.8 49.28 37
I5491 0 5491 1.23684e-05
R6591 5491 5492 1.712 0.8 13.696 37
I5492 0 5492 1.32342e-05
R6592 5492 5493 1.664 0.8 13.312 37
I5493 0 5493 1.34816e-05
R6593 5493 5494 1.632 0.8 13.056 37
I5494 0 5494 1.26158e-05
R6594 5494 5495 1.68 0.8 13.44 37
I5495 0 5495 1.23684e-05
R6595 5495 5496 1.744 0.8 13.952 37
I5496 0 5496 1.23684e-05
R6596 5496 5497 1.68 0.8 13.44 37
I5497 0 5497 1.31105e-05
R6597 5497 5498 1.696 0.8 13.568 37
I5498 0 5498 1.28631e-05
R6598 5498 5499 1.744 0.8 13.952 37
I5499 0 5499 1.29868e-05
R6599 5499 5500 1.744 0.8 13.952 37
I5500 0 5500 1.23684e-05
R6600 5500 0 0.1 49.28 49.28 37
*seg: 551
R6601 0 5501 0.1 49.28 49.28 37
R6602 5505 5515 6.16 0.8 49.28 37
I5501 0 5501 1.24921e-05
R6603 5501 5502 1.632 0.8 13.056 37
I5502 0 5502 1.31105e-05
R6604 5502 5503 1.632 0.8 13.056 37
I5503 0 5503 1.33579e-05
R6605 5503 5504 1.632 0.8 13.056 37
I5504 0 5504 1.29868e-05
R6606 5504 5505 1.68 0.8 13.44 37
I5505 0 5505 1.23684e-05
R6607 5505 5506 1.728 0.8 13.824 37
I5506 0 5506 1.24921e-05
R6608 5506 5507 1.728 0.8 13.824 37
I5507 0 5507 1.27395e-05
R6609 5507 5508 1.744 0.8 13.952 37
I5508 0 5508 1.24921e-05
R6610 5508 5509 1.632 0.8 13.056 37
I5509 0 5509 1.28631e-05
R6611 5509 5510 1.664 0.8 13.312 37
I5510 0 5510 1.23684e-05
R6612 5510 0 0.1 49.28 49.28 37
*seg: 552
R6613 0 5511 0.1 49.28 49.28 37
R6614 5515 5525 6.16 0.8 49.28 37
I5511 0 5511 1.33579e-05
R6615 5511 5512 1.648 0.8 13.184 37
I5512 0 5512 1.28631e-05
R6616 5512 5513 1.728 0.8 13.824 37
I5513 0 5513 1.32342e-05
R6617 5513 5514 1.632 0.8 13.056 37
I5514 0 5514 1.33579e-05
R6618 5514 5515 1.68 0.8 13.44 37
I5515 0 5515 1.34816e-05
R6619 5515 5516 1.616 0.8 12.928 37
I5516 0 5516 1.34816e-05
R6620 5516 5517 1.696 0.8 13.568 37
I5517 0 5517 1.27395e-05
R6621 5517 5518 1.712 0.8 13.696 37
I5518 0 5518 1.23684e-05
R6622 5518 5519 1.616 0.8 12.928 37
I5519 0 5519 1.23684e-05
R6623 5519 5520 1.664 0.8 13.312 37
I5520 0 5520 1.23684e-05
R6624 5520 0 0.1 49.28 49.28 37
*seg: 553
R6625 0 5521 0.1 49.28 49.28 37
R6626 5525 5535 6.16 0.8 49.28 37
I5521 0 5521 1.34816e-05
R6627 5521 5522 1.6 0.8 12.8 37
I5522 0 5522 1.33579e-05
R6628 5522 5523 1.648 0.8 13.184 37
I5523 0 5523 1.27395e-05
R6629 5523 5524 1.712 0.8 13.696 37
I5524 0 5524 1.29868e-05
R6630 5524 5525 1.6 0.8 12.8 37
I5525 0 5525 1.32342e-05
R6631 5525 5526 1.6 0.8 12.8 37
I5526 0 5526 1.34816e-05
R6632 5526 5527 1.696 0.8 13.568 37
I5527 0 5527 1.28631e-05
R6633 5527 5528 1.648 0.8 13.184 37
I5528 0 5528 1.31105e-05
R6634 5528 5529 1.712 0.8 13.696 37
I5529 0 5529 1.31105e-05
R6635 5529 5530 1.712 0.8 13.696 37
I5530 0 5530 1.23684e-05
R6636 5530 0 0.1 49.28 49.28 37
*seg: 554
R6637 0 5531 0.1 49.28 49.28 37
R6638 5535 5545 6.16 0.8 49.28 37
I5531 0 5531 1.33579e-05
R6639 5531 5532 1.6 0.8 12.8 37
I5532 0 5532 1.32342e-05
R6640 5532 5533 1.744 0.8 13.952 37
I5533 0 5533 1.24921e-05
R6641 5533 5534 1.6 0.8 12.8 37
I5534 0 5534 1.32342e-05
R6642 5534 5535 1.696 0.8 13.568 37
I5535 0 5535 1.26158e-05
R6643 5535 5536 1.616 0.8 12.928 37
I5536 0 5536 1.29868e-05
R6644 5536 5537 1.712 0.8 13.696 37
I5537 0 5537 1.27395e-05
R6645 5537 5538 1.648 0.8 13.184 37
I5538 0 5538 1.28631e-05
R6646 5538 5539 1.68 0.8 13.44 37
I5539 0 5539 1.31105e-05
R6647 5539 5540 1.6 0.8 12.8 37
I5540 0 5540 1.23684e-05
R6648 5540 0 0.1 49.28 49.28 37
*seg: 555
R6649 0 5541 0.1 49.28 49.28 37
R6650 5545 5555 6.16 0.8 49.28 37
I5541 0 5541 1.31105e-05
R6651 5541 5542 1.68 0.8 13.44 37
I5542 0 5542 1.33579e-05
R6652 5542 5543 1.648 0.8 13.184 37
I5543 0 5543 1.34816e-05
R6653 5543 5544 1.6 0.8 12.8 37
I5544 0 5544 1.28631e-05
R6654 5544 5545 1.616 0.8 12.928 37
I5545 0 5545 1.29868e-05
R6655 5545 5546 1.696 0.8 13.568 37
I5546 0 5546 1.33579e-05
R6656 5546 5547 1.664 0.8 13.312 37
I5547 0 5547 1.31105e-05
R6657 5547 5548 1.616 0.8 12.928 37
I5548 0 5548 1.23684e-05
R6658 5548 5549 1.712 0.8 13.696 37
I5549 0 5549 1.29868e-05
R6659 5549 5550 1.728 0.8 13.824 37
I5550 0 5550 1.23684e-05
R6660 5550 0 0.1 49.28 49.28 37
*seg: 556
R6661 0 5551 0.1 49.28 49.28 37
R6662 5555 5565 6.16 0.8 49.28 37
I5551 0 5551 1.24921e-05
R6663 5551 5552 1.648 0.8 13.184 37
I5552 0 5552 1.24921e-05
R6664 5552 5553 1.664 0.8 13.312 37
I5553 0 5553 1.27395e-05
R6665 5553 5554 1.728 0.8 13.824 37
I5554 0 5554 1.31105e-05
R6666 5554 5555 1.648 0.8 13.184 37
I5555 0 5555 1.27395e-05
R6667 5555 5556 1.664 0.8 13.312 37
I5556 0 5556 1.27395e-05
R6668 5556 5557 1.616 0.8 12.928 37
I5557 0 5557 1.27395e-05
R6669 5557 5558 1.632 0.8 13.056 37
I5558 0 5558 1.29868e-05
R6670 5558 5559 1.712 0.8 13.696 37
I5559 0 5559 1.34816e-05
R6671 5559 5560 1.744 0.8 13.952 37
I5560 0 5560 1.23684e-05
R6672 5560 0 0.1 49.28 49.28 37
*seg: 557
R6673 0 5561 0.1 49.28 49.28 37
R6674 5565 5575 6.16 0.8 49.28 37
I5561 0 5561 1.32342e-05
R6675 5561 5562 1.696 0.8 13.568 37
I5562 0 5562 1.23684e-05
R6676 5562 5563 1.632 0.8 13.056 37
I5563 0 5563 1.23684e-05
R6677 5563 5564 1.744 0.8 13.952 37
I5564 0 5564 1.29868e-05
R6678 5564 5565 1.6 0.8 12.8 37
I5565 0 5565 1.31105e-05
R6679 5565 5566 1.6 0.8 12.8 37
I5566 0 5566 1.28631e-05
R6680 5566 5567 1.68 0.8 13.44 37
I5567 0 5567 1.34816e-05
R6681 5567 5568 1.728 0.8 13.824 37
I5568 0 5568 1.28631e-05
R6682 5568 5569 1.68 0.8 13.44 37
I5569 0 5569 1.34816e-05
R6683 5569 5570 1.728 0.8 13.824 37
I5570 0 5570 1.23684e-05
R6684 5570 0 0.1 49.28 49.28 37
*seg: 558
R6685 0 5571 0.1 49.28 49.28 37
R6686 5575 5585 6.16 0.8 49.28 37
I5571 0 5571 1.29868e-05
R6687 5571 5572 1.728 0.8 13.824 37
I5572 0 5572 1.31105e-05
R6688 5572 5573 1.616 0.8 12.928 37
I5573 0 5573 1.31105e-05
R6689 5573 5574 1.712 0.8 13.696 37
I5574 0 5574 1.26158e-05
R6690 5574 5575 1.696 0.8 13.568 37
I5575 0 5575 1.31105e-05
R6691 5575 5576 1.616 0.8 12.928 37
I5576 0 5576 1.24921e-05
R6692 5576 5577 1.696 0.8 13.568 37
I5577 0 5577 1.23684e-05
R6693 5577 5578 1.6 0.8 12.8 37
I5578 0 5578 1.24921e-05
R6694 5578 5579 1.744 0.8 13.952 37
I5579 0 5579 1.32342e-05
R6695 5579 5580 1.728 0.8 13.824 37
I5580 0 5580 1.23684e-05
R6696 5580 0 0.1 49.28 49.28 37
*seg: 559
R6697 0 5581 0.1 49.28 49.28 37
R6698 5585 5595 6.16 0.8 49.28 37
I5581 0 5581 1.27395e-05
R6699 5581 5582 1.632 0.8 13.056 37
I5582 0 5582 1.34816e-05
R6700 5582 5583 1.648 0.8 13.184 37
I5583 0 5583 1.24921e-05
R6701 5583 5584 1.744 0.8 13.952 37
I5584 0 5584 1.24921e-05
R6702 5584 5585 1.696 0.8 13.568 37
I5585 0 5585 1.28631e-05
R6703 5585 5586 1.664 0.8 13.312 37
I5586 0 5586 1.31105e-05
R6704 5586 5587 1.68 0.8 13.44 37
I5587 0 5587 1.29868e-05
R6705 5587 5588 1.68 0.8 13.44 37
I5588 0 5588 1.34816e-05
R6706 5588 5589 1.728 0.8 13.824 37
I5589 0 5589 1.26158e-05
R6707 5589 5590 1.712 0.8 13.696 37
I5590 0 5590 1.23684e-05
R6708 5590 0 0.1 49.28 49.28 37
*seg: 560
R6709 0 5591 0.1 49.28 49.28 37
R6710 5595 5605 6.16 0.8 49.28 37
I5591 0 5591 1.27395e-05
R6711 5591 5592 1.664 0.8 13.312 37
I5592 0 5592 1.31105e-05
R6712 5592 5593 1.6 0.8 12.8 37
I5593 0 5593 1.31105e-05
R6713 5593 5594 1.648 0.8 13.184 37
I5594 0 5594 1.34816e-05
R6714 5594 5595 1.712 0.8 13.696 37
I5595 0 5595 1.24921e-05
R6715 5595 5596 1.696 0.8 13.568 37
I5596 0 5596 1.27395e-05
R6716 5596 5597 1.728 0.8 13.824 37
I5597 0 5597 1.32342e-05
R6717 5597 5598 1.744 0.8 13.952 37
I5598 0 5598 1.23684e-05
R6718 5598 5599 1.696 0.8 13.568 37
I5599 0 5599 1.24921e-05
R6719 5599 5600 1.648 0.8 13.184 37
I5600 0 5600 1.23684e-05
R6720 5600 0 0.1 49.28 49.28 37
*seg: 561
R6721 0 5601 0.1 49.28 49.28 37
R6722 5605 5615 6.16 0.8 49.28 37
I5601 0 5601 1.28631e-05
R6723 5601 5602 1.632 0.8 13.056 37
I5602 0 5602 1.26158e-05
R6724 5602 5603 1.696 0.8 13.568 37
I5603 0 5603 1.29868e-05
R6725 5603 5604 1.68 0.8 13.44 37
I5604 0 5604 1.26158e-05
R6726 5604 5605 1.68 0.8 13.44 37
I5605 0 5605 1.33579e-05
R6727 5605 5606 1.632 0.8 13.056 37
I5606 0 5606 1.24921e-05
R6728 5606 5607 1.744 0.8 13.952 37
I5607 0 5607 1.23684e-05
R6729 5607 5608 1.664 0.8 13.312 37
I5608 0 5608 1.26158e-05
R6730 5608 5609 1.648 0.8 13.184 37
I5609 0 5609 1.29868e-05
R6731 5609 5610 1.744 0.8 13.952 37
I5610 0 5610 1.23684e-05
R6732 5610 0 0.1 49.28 49.28 37
*seg: 562
R6733 0 5611 0.1 49.28 49.28 37
R6734 5615 5625 6.16 0.8 49.28 37
I5611 0 5611 1.33579e-05
R6735 5611 5612 1.68 0.8 13.44 37
I5612 0 5612 1.34816e-05
R6736 5612 5613 1.712 0.8 13.696 37
I5613 0 5613 1.27395e-05
R6737 5613 5614 1.744 0.8 13.952 37
I5614 0 5614 1.23684e-05
R6738 5614 5615 1.712 0.8 13.696 37
I5615 0 5615 1.26158e-05
R6739 5615 5616 1.648 0.8 13.184 37
I5616 0 5616 1.26158e-05
R6740 5616 5617 1.728 0.8 13.824 37
I5617 0 5617 1.32342e-05
R6741 5617 5618 1.664 0.8 13.312 37
I5618 0 5618 1.26158e-05
R6742 5618 5619 1.664 0.8 13.312 37
I5619 0 5619 1.34816e-05
R6743 5619 5620 1.6 0.8 12.8 37
I5620 0 5620 1.23684e-05
R6744 5620 0 0.1 49.28 49.28 37
*seg: 563
R6745 0 5621 0.1 49.28 49.28 37
R6746 5625 5635 6.16 0.8 49.28 37
I5621 0 5621 1.33579e-05
R6747 5621 5622 1.6 0.8 12.8 37
I5622 0 5622 1.29868e-05
R6748 5622 5623 1.616 0.8 12.928 37
I5623 0 5623 1.28631e-05
R6749 5623 5624 1.728 0.8 13.824 37
I5624 0 5624 1.27395e-05
R6750 5624 5625 1.664 0.8 13.312 37
I5625 0 5625 1.23684e-05
R6751 5625 5626 1.696 0.8 13.568 37
I5626 0 5626 1.32342e-05
R6752 5626 5627 1.664 0.8 13.312 37
I5627 0 5627 1.34816e-05
R6753 5627 5628 1.6 0.8 12.8 37
I5628 0 5628 1.33579e-05
R6754 5628 5629 1.68 0.8 13.44 37
I5629 0 5629 1.24921e-05
R6755 5629 5630 1.728 0.8 13.824 37
I5630 0 5630 1.23684e-05
R6756 5630 0 0.1 49.28 49.28 37
*seg: 564
R6757 0 5631 0.1 49.28 49.28 37
R6758 5635 5645 6.16 0.8 49.28 37
I5631 0 5631 1.29868e-05
R6759 5631 5632 1.68 0.8 13.44 37
I5632 0 5632 1.32342e-05
R6760 5632 5633 1.648 0.8 13.184 37
I5633 0 5633 1.26158e-05
R6761 5633 5634 1.728 0.8 13.824 37
I5634 0 5634 1.32342e-05
R6762 5634 5635 1.616 0.8 12.928 37
I5635 0 5635 1.33579e-05
R6763 5635 5636 1.6 0.8 12.8 37
I5636 0 5636 1.29868e-05
R6764 5636 5637 1.696 0.8 13.568 37
I5637 0 5637 1.26158e-05
R6765 5637 5638 1.6 0.8 12.8 37
I5638 0 5638 1.29868e-05
R6766 5638 5639 1.632 0.8 13.056 37
I5639 0 5639 1.27395e-05
R6767 5639 5640 1.6 0.8 12.8 37
I5640 0 5640 1.23684e-05
R6768 5640 0 0.1 49.28 49.28 37
*seg: 565
R6769 0 5641 0.1 49.28 49.28 37
R6770 5645 5655 6.16 0.8 49.28 37
I5641 0 5641 1.24921e-05
R6771 5641 5642 1.728 0.8 13.824 37
I5642 0 5642 1.33579e-05
R6772 5642 5643 1.632 0.8 13.056 37
I5643 0 5643 1.28631e-05
R6773 5643 5644 1.696 0.8 13.568 37
I5644 0 5644 1.23684e-05
R6774 5644 5645 1.712 0.8 13.696 37
I5645 0 5645 1.31105e-05
R6775 5645 5646 1.648 0.8 13.184 37
I5646 0 5646 1.27395e-05
R6776 5646 5647 1.616 0.8 12.928 37
I5647 0 5647 1.26158e-05
R6777 5647 5648 1.712 0.8 13.696 37
I5648 0 5648 1.32342e-05
R6778 5648 5649 1.696 0.8 13.568 37
I5649 0 5649 1.26158e-05
R6779 5649 5650 1.744 0.8 13.952 37
I5650 0 5650 1.23684e-05
R6780 5650 0 0.1 49.28 49.28 37
*seg: 566
R6781 0 5651 0.1 49.28 49.28 37
R6782 5655 5665 6.16 0.8 49.28 37
I5651 0 5651 1.32342e-05
R6783 5651 5652 1.728 0.8 13.824 37
I5652 0 5652 1.23684e-05
R6784 5652 5653 1.664 0.8 13.312 37
I5653 0 5653 1.32342e-05
R6785 5653 5654 1.744 0.8 13.952 37
I5654 0 5654 1.32342e-05
R6786 5654 5655 1.744 0.8 13.952 37
I5655 0 5655 1.28631e-05
R6787 5655 5656 1.632 0.8 13.056 37
I5656 0 5656 1.31105e-05
R6788 5656 5657 1.664 0.8 13.312 37
I5657 0 5657 1.34816e-05
R6789 5657 5658 1.6 0.8 12.8 37
I5658 0 5658 1.31105e-05
R6790 5658 5659 1.728 0.8 13.824 37
I5659 0 5659 1.34816e-05
R6791 5659 5660 1.712 0.8 13.696 37
I5660 0 5660 1.23684e-05
R6792 5660 0 0.1 49.28 49.28 37
*seg: 567
R6793 0 5661 0.1 49.28 49.28 37
R6794 5665 5675 6.16 0.8 49.28 37
I5661 0 5661 1.33579e-05
R6795 5661 5662 1.616 0.8 12.928 37
I5662 0 5662 1.23684e-05
R6796 5662 5663 1.6 0.8 12.8 37
I5663 0 5663 1.31105e-05
R6797 5663 5664 1.648 0.8 13.184 37
I5664 0 5664 1.23684e-05
R6798 5664 5665 1.664 0.8 13.312 37
I5665 0 5665 1.28631e-05
R6799 5665 5666 1.6 0.8 12.8 37
I5666 0 5666 1.29868e-05
R6800 5666 5667 1.712 0.8 13.696 37
I5667 0 5667 1.29868e-05
R6801 5667 5668 1.696 0.8 13.568 37
I5668 0 5668 1.33579e-05
R6802 5668 5669 1.664 0.8 13.312 37
I5669 0 5669 1.29868e-05
R6803 5669 5670 1.68 0.8 13.44 37
I5670 0 5670 1.23684e-05
R6804 5670 0 0.1 49.28 49.28 37
*seg: 568
R6805 0 5671 0.1 49.28 49.28 37
R6806 5675 5685 6.16 0.8 49.28 37
I5671 0 5671 1.28631e-05
R6807 5671 5672 1.632 0.8 13.056 37
I5672 0 5672 1.33579e-05
R6808 5672 5673 1.632 0.8 13.056 37
I5673 0 5673 1.23684e-05
R6809 5673 5674 1.6 0.8 12.8 37
I5674 0 5674 1.29868e-05
R6810 5674 5675 1.648 0.8 13.184 37
I5675 0 5675 1.33579e-05
R6811 5675 5676 1.6 0.8 12.8 37
I5676 0 5676 1.23684e-05
R6812 5676 5677 1.616 0.8 12.928 37
I5677 0 5677 1.23684e-05
R6813 5677 5678 1.632 0.8 13.056 37
I5678 0 5678 1.29868e-05
R6814 5678 5679 1.664 0.8 13.312 37
I5679 0 5679 1.34816e-05
R6815 5679 5680 1.664 0.8 13.312 37
I5680 0 5680 1.23684e-05
R6816 5680 0 0.1 49.28 49.28 37
*seg: 569
R6817 0 5681 0.1 49.28 49.28 37
R6818 5685 5695 6.16 0.8 49.28 37
I5681 0 5681 1.33579e-05
R6819 5681 5682 1.6 0.8 12.8 37
I5682 0 5682 1.24921e-05
R6820 5682 5683 1.744 0.8 13.952 37
I5683 0 5683 1.34816e-05
R6821 5683 5684 1.632 0.8 13.056 37
I5684 0 5684 1.29868e-05
R6822 5684 5685 1.728 0.8 13.824 37
I5685 0 5685 1.26158e-05
R6823 5685 5686 1.68 0.8 13.44 37
I5686 0 5686 1.28631e-05
R6824 5686 5687 1.664 0.8 13.312 37
I5687 0 5687 1.26158e-05
R6825 5687 5688 1.728 0.8 13.824 37
I5688 0 5688 1.33579e-05
R6826 5688 5689 1.648 0.8 13.184 37
I5689 0 5689 1.23684e-05
R6827 5689 5690 1.632 0.8 13.056 37
I5690 0 5690 1.23684e-05
R6828 5690 0 0.1 49.28 49.28 37
*seg: 570
R6829 0 5691 0.1 49.28 49.28 37
R6830 5695 5705 6.16 0.8 49.28 37
I5691 0 5691 1.28631e-05
R6831 5691 5692 1.728 0.8 13.824 37
I5692 0 5692 1.32342e-05
R6832 5692 5693 1.728 0.8 13.824 37
I5693 0 5693 1.26158e-05
R6833 5693 5694 1.696 0.8 13.568 37
I5694 0 5694 1.27395e-05
R6834 5694 5695 1.616 0.8 12.928 37
I5695 0 5695 1.23684e-05
R6835 5695 5696 1.664 0.8 13.312 37
I5696 0 5696 1.23684e-05
R6836 5696 5697 1.696 0.8 13.568 37
I5697 0 5697 1.26158e-05
R6837 5697 5698 1.648 0.8 13.184 37
I5698 0 5698 1.27395e-05
R6838 5698 5699 1.632 0.8 13.056 37
I5699 0 5699 1.33579e-05
R6839 5699 5700 1.648 0.8 13.184 37
I5700 0 5700 1.23684e-05
R6840 5700 0 0.1 49.28 49.28 37
*seg: 571
R6841 0 5701 0.1 49.28 49.28 37
R6842 5705 5715 6.16 0.8 49.28 37
I5701 0 5701 1.29868e-05
R6843 5701 5702 1.616 0.8 12.928 37
I5702 0 5702 1.34816e-05
R6844 5702 5703 1.632 0.8 13.056 37
I5703 0 5703 1.29868e-05
R6845 5703 5704 1.616 0.8 12.928 37
I5704 0 5704 1.28631e-05
R6846 5704 5705 1.744 0.8 13.952 37
I5705 0 5705 1.23684e-05
R6847 5705 5706 1.616 0.8 12.928 37
I5706 0 5706 1.24921e-05
R6848 5706 5707 1.744 0.8 13.952 37
I5707 0 5707 1.33579e-05
R6849 5707 5708 1.664 0.8 13.312 37
I5708 0 5708 1.24921e-05
R6850 5708 5709 1.664 0.8 13.312 37
I5709 0 5709 1.28631e-05
R6851 5709 5710 1.728 0.8 13.824 37
I5710 0 5710 1.23684e-05
R6852 5710 0 0.1 49.28 49.28 37
*seg: 572
R6853 0 5711 0.1 49.28 49.28 37
R6854 5715 5725 6.16 0.8 49.28 37
I5711 0 5711 1.32342e-05
R6855 5711 5712 1.616 0.8 12.928 37
I5712 0 5712 1.34816e-05
R6856 5712 5713 1.68 0.8 13.44 37
I5713 0 5713 1.28631e-05
R6857 5713 5714 1.712 0.8 13.696 37
I5714 0 5714 1.29868e-05
R6858 5714 5715 1.728 0.8 13.824 37
I5715 0 5715 1.28631e-05
R6859 5715 5716 1.712 0.8 13.696 37
I5716 0 5716 1.26158e-05
R6860 5716 5717 1.696 0.8 13.568 37
I5717 0 5717 1.26158e-05
R6861 5717 5718 1.712 0.8 13.696 37
I5718 0 5718 1.32342e-05
R6862 5718 5719 1.696 0.8 13.568 37
I5719 0 5719 1.23684e-05
R6863 5719 5720 1.632 0.8 13.056 37
I5720 0 5720 1.23684e-05
R6864 5720 0 0.1 49.28 49.28 37
*seg: 573
R6865 0 5721 0.1 49.28 49.28 37
R6866 5725 5735 6.16 0.8 49.28 37
I5721 0 5721 1.32342e-05
R6867 5721 5722 1.712 0.8 13.696 37
I5722 0 5722 1.23684e-05
R6868 5722 5723 1.616 0.8 12.928 37
I5723 0 5723 1.34816e-05
R6869 5723 5724 1.712 0.8 13.696 37
I5724 0 5724 1.31105e-05
R6870 5724 5725 1.648 0.8 13.184 37
I5725 0 5725 1.24921e-05
R6871 5725 5726 1.632 0.8 13.056 37
I5726 0 5726 1.31105e-05
R6872 5726 5727 1.696 0.8 13.568 37
I5727 0 5727 1.23684e-05
R6873 5727 5728 1.712 0.8 13.696 37
I5728 0 5728 1.26158e-05
R6874 5728 5729 1.712 0.8 13.696 37
I5729 0 5729 1.28631e-05
R6875 5729 5730 1.648 0.8 13.184 37
I5730 0 5730 1.23684e-05
R6876 5730 0 0.1 49.28 49.28 37
*seg: 574
R6877 0 5731 0.1 49.28 49.28 37
R6878 5735 5745 6.16 0.8 49.28 37
I5731 0 5731 1.26158e-05
R6879 5731 5732 1.728 0.8 13.824 37
I5732 0 5732 1.23684e-05
R6880 5732 5733 1.616 0.8 12.928 37
I5733 0 5733 1.26158e-05
R6881 5733 5734 1.664 0.8 13.312 37
I5734 0 5734 1.34816e-05
R6882 5734 5735 1.744 0.8 13.952 37
I5735 0 5735 1.31105e-05
R6883 5735 5736 1.68 0.8 13.44 37
I5736 0 5736 1.33579e-05
R6884 5736 5737 1.6 0.8 12.8 37
I5737 0 5737 1.34816e-05
R6885 5737 5738 1.632 0.8 13.056 37
I5738 0 5738 1.27395e-05
R6886 5738 5739 1.648 0.8 13.184 37
I5739 0 5739 1.33579e-05
R6887 5739 5740 1.744 0.8 13.952 37
I5740 0 5740 1.23684e-05
R6888 5740 0 0.1 49.28 49.28 37
*seg: 575
R6889 0 5741 0.1 49.28 49.28 37
R6890 5745 5755 6.16 0.8 49.28 37
I5741 0 5741 1.27395e-05
R6891 5741 5742 1.744 0.8 13.952 37
I5742 0 5742 1.26158e-05
R6892 5742 5743 1.648 0.8 13.184 37
I5743 0 5743 1.28631e-05
R6893 5743 5744 1.616 0.8 12.928 37
I5744 0 5744 1.27395e-05
R6894 5744 5745 1.664 0.8 13.312 37
I5745 0 5745 1.24921e-05
R6895 5745 5746 1.6 0.8 12.8 37
I5746 0 5746 1.28631e-05
R6896 5746 5747 1.664 0.8 13.312 37
I5747 0 5747 1.33579e-05
R6897 5747 5748 1.632 0.8 13.056 37
I5748 0 5748 1.29868e-05
R6898 5748 5749 1.68 0.8 13.44 37
I5749 0 5749 1.33579e-05
R6899 5749 5750 1.712 0.8 13.696 37
I5750 0 5750 1.23684e-05
R6900 5750 0 0.1 49.28 49.28 37
*seg: 576
R6901 0 5751 0.1 49.28 49.28 37
R6902 5755 5765 6.16 0.8 49.28 37
I5751 0 5751 1.31105e-05
R6903 5751 5752 1.696 0.8 13.568 37
I5752 0 5752 1.26158e-05
R6904 5752 5753 1.712 0.8 13.696 37
I5753 0 5753 1.32342e-05
R6905 5753 5754 1.712 0.8 13.696 37
I5754 0 5754 1.31105e-05
R6906 5754 5755 1.648 0.8 13.184 37
I5755 0 5755 1.28631e-05
R6907 5755 5756 1.728 0.8 13.824 37
I5756 0 5756 1.32342e-05
R6908 5756 5757 1.728 0.8 13.824 37
I5757 0 5757 1.34816e-05
R6909 5757 5758 1.616 0.8 12.928 37
I5758 0 5758 1.24921e-05
R6910 5758 5759 1.6 0.8 12.8 37
I5759 0 5759 1.33579e-05
R6911 5759 5760 1.744 0.8 13.952 37
I5760 0 5760 1.23684e-05
R6912 5760 0 0.1 49.28 49.28 37
*seg: 577
R6913 0 5761 0.1 49.28 49.28 37
R6914 5765 5775 6.16 0.8 49.28 37
I5761 0 5761 1.26158e-05
R6915 5761 5762 1.6 0.8 12.8 37
I5762 0 5762 1.27395e-05
R6916 5762 5763 1.648 0.8 13.184 37
I5763 0 5763 1.31105e-05
R6917 5763 5764 1.728 0.8 13.824 37
I5764 0 5764 1.26158e-05
R6918 5764 5765 1.728 0.8 13.824 37
I5765 0 5765 1.23684e-05
R6919 5765 5766 1.744 0.8 13.952 37
I5766 0 5766 1.28631e-05
R6920 5766 5767 1.696 0.8 13.568 37
I5767 0 5767 1.32342e-05
R6921 5767 5768 1.744 0.8 13.952 37
I5768 0 5768 1.28631e-05
R6922 5768 5769 1.616 0.8 12.928 37
I5769 0 5769 1.33579e-05
R6923 5769 5770 1.6 0.8 12.8 37
I5770 0 5770 1.23684e-05
R6924 5770 0 0.1 49.28 49.28 37
*seg: 578
R6925 0 5771 0.1 49.28 49.28 37
R6926 5775 5785 6.16 0.8 49.28 37
I5771 0 5771 1.23684e-05
R6927 5771 5772 1.6 0.8 12.8 37
I5772 0 5772 1.32342e-05
R6928 5772 5773 1.664 0.8 13.312 37
I5773 0 5773 1.27395e-05
R6929 5773 5774 1.68 0.8 13.44 37
I5774 0 5774 1.24921e-05
R6930 5774 5775 1.6 0.8 12.8 37
I5775 0 5775 1.33579e-05
R6931 5775 5776 1.68 0.8 13.44 37
I5776 0 5776 1.23684e-05
R6932 5776 5777 1.744 0.8 13.952 37
I5777 0 5777 1.26158e-05
R6933 5777 5778 1.728 0.8 13.824 37
I5778 0 5778 1.27395e-05
R6934 5778 5779 1.728 0.8 13.824 37
I5779 0 5779 1.27395e-05
R6935 5779 5780 1.744 0.8 13.952 37
I5780 0 5780 1.23684e-05
R6936 5780 0 0.1 49.28 49.28 37
*seg: 579
R6937 0 5781 0.1 49.28 49.28 37
R6938 5785 5795 6.16 0.8 49.28 37
I5781 0 5781 1.27395e-05
R6939 5781 5782 1.664 0.8 13.312 37
I5782 0 5782 1.26158e-05
R6940 5782 5783 1.728 0.8 13.824 37
I5783 0 5783 1.32342e-05
R6941 5783 5784 1.696 0.8 13.568 37
I5784 0 5784 1.27395e-05
R6942 5784 5785 1.632 0.8 13.056 37
I5785 0 5785 1.27395e-05
R6943 5785 5786 1.68 0.8 13.44 37
I5786 0 5786 1.28631e-05
R6944 5786 5787 1.648 0.8 13.184 37
I5787 0 5787 1.34816e-05
R6945 5787 5788 1.744 0.8 13.952 37
I5788 0 5788 1.29868e-05
R6946 5788 5789 1.632 0.8 13.056 37
I5789 0 5789 1.32342e-05
R6947 5789 5790 1.712 0.8 13.696 37
I5790 0 5790 1.23684e-05
R6948 5790 0 0.1 49.28 49.28 37
*seg: 580
R6949 0 5791 0.1 49.28 49.28 37
R6950 5795 5805 6.16 0.8 49.28 37
I5791 0 5791 1.33579e-05
R6951 5791 5792 1.6 0.8 12.8 37
I5792 0 5792 1.28631e-05
R6952 5792 5793 1.632 0.8 13.056 37
I5793 0 5793 1.32342e-05
R6953 5793 5794 1.6 0.8 12.8 37
I5794 0 5794 1.23684e-05
R6954 5794 5795 1.632 0.8 13.056 37
I5795 0 5795 1.28631e-05
R6955 5795 5796 1.744 0.8 13.952 37
I5796 0 5796 1.27395e-05
R6956 5796 5797 1.632 0.8 13.056 37
I5797 0 5797 1.27395e-05
R6957 5797 5798 1.744 0.8 13.952 37
I5798 0 5798 1.31105e-05
R6958 5798 5799 1.68 0.8 13.44 37
I5799 0 5799 1.27395e-05
R6959 5799 5800 1.664 0.8 13.312 37
I5800 0 5800 1.23684e-05
R6960 5800 0 0.1 49.28 49.28 37
*seg: 581
R6961 0 5801 0.1 49.28 49.28 37
R6962 5805 5815 6.16 0.8 49.28 37
I5801 0 5801 1.29868e-05
R6963 5801 5802 1.728 0.8 13.824 37
I5802 0 5802 1.31105e-05
R6964 5802 5803 1.616 0.8 12.928 37
I5803 0 5803 1.27395e-05
R6965 5803 5804 1.744 0.8 13.952 37
I5804 0 5804 1.28631e-05
R6966 5804 5805 1.648 0.8 13.184 37
I5805 0 5805 1.32342e-05
R6967 5805 5806 1.664 0.8 13.312 37
I5806 0 5806 1.26158e-05
R6968 5806 5807 1.6 0.8 12.8 37
I5807 0 5807 1.32342e-05
R6969 5807 5808 1.68 0.8 13.44 37
I5808 0 5808 1.26158e-05
R6970 5808 5809 1.616 0.8 12.928 37
I5809 0 5809 1.26158e-05
R6971 5809 5810 1.632 0.8 13.056 37
I5810 0 5810 1.23684e-05
R6972 5810 0 0.1 49.28 49.28 37
*seg: 582
R6973 0 5811 0.1 49.28 49.28 37
R6974 5815 5825 6.16 0.8 49.28 37
I5811 0 5811 1.34816e-05
R6975 5811 5812 1.6 0.8 12.8 37
I5812 0 5812 1.29868e-05
R6976 5812 5813 1.648 0.8 13.184 37
I5813 0 5813 1.33579e-05
R6977 5813 5814 1.664 0.8 13.312 37
I5814 0 5814 1.31105e-05
R6978 5814 5815 1.648 0.8 13.184 37
I5815 0 5815 1.34816e-05
R6979 5815 5816 1.728 0.8 13.824 37
I5816 0 5816 1.24921e-05
R6980 5816 5817 1.728 0.8 13.824 37
I5817 0 5817 1.33579e-05
R6981 5817 5818 1.744 0.8 13.952 37
I5818 0 5818 1.23684e-05
R6982 5818 5819 1.648 0.8 13.184 37
I5819 0 5819 1.33579e-05
R6983 5819 5820 1.696 0.8 13.568 37
I5820 0 5820 1.23684e-05
R6984 5820 0 0.1 49.28 49.28 37
*seg: 583
R6985 0 5821 0.1 49.28 49.28 37
R6986 5825 5835 6.16 0.8 49.28 37
I5821 0 5821 1.33579e-05
R6987 5821 5822 1.696 0.8 13.568 37
I5822 0 5822 1.28631e-05
R6988 5822 5823 1.68 0.8 13.44 37
I5823 0 5823 1.34816e-05
R6989 5823 5824 1.664 0.8 13.312 37
I5824 0 5824 1.33579e-05
R6990 5824 5825 1.712 0.8 13.696 37
I5825 0 5825 1.27395e-05
R6991 5825 5826 1.728 0.8 13.824 37
I5826 0 5826 1.34816e-05
R6992 5826 5827 1.712 0.8 13.696 37
I5827 0 5827 1.34816e-05
R6993 5827 5828 1.696 0.8 13.568 37
I5828 0 5828 1.29868e-05
R6994 5828 5829 1.696 0.8 13.568 37
I5829 0 5829 1.34816e-05
R6995 5829 5830 1.744 0.8 13.952 37
I5830 0 5830 1.23684e-05
R6996 5830 0 0.1 49.28 49.28 37
*seg: 584
R6997 0 5831 0.1 49.28 49.28 37
R6998 5835 5845 6.16 0.8 49.28 37
I5831 0 5831 1.31105e-05
R6999 5831 5832 1.664 0.8 13.312 37
I5832 0 5832 1.32342e-05
R7000 5832 5833 1.6 0.8 12.8 37
I5833 0 5833 1.31105e-05
R7001 5833 5834 1.744 0.8 13.952 37
I5834 0 5834 1.28631e-05
R7002 5834 5835 1.632 0.8 13.056 37
I5835 0 5835 1.32342e-05
R7003 5835 5836 1.632 0.8 13.056 37
I5836 0 5836 1.29868e-05
R7004 5836 5837 1.632 0.8 13.056 37
I5837 0 5837 1.31105e-05
R7005 5837 5838 1.744 0.8 13.952 37
I5838 0 5838 1.27395e-05
R7006 5838 5839 1.744 0.8 13.952 37
I5839 0 5839 1.31105e-05
R7007 5839 5840 1.696 0.8 13.568 37
I5840 0 5840 1.23684e-05
R7008 5840 0 0.1 49.28 49.28 37
*seg: 585
R7009 0 5841 0.1 49.28 49.28 37
R7010 5845 5855 6.16 0.8 49.28 37
I5841 0 5841 1.32342e-05
R7011 5841 5842 1.696 0.8 13.568 37
I5842 0 5842 1.33579e-05
R7012 5842 5843 1.696 0.8 13.568 37
I5843 0 5843 1.27395e-05
R7013 5843 5844 1.744 0.8 13.952 37
I5844 0 5844 1.29868e-05
R7014 5844 5845 1.728 0.8 13.824 37
I5845 0 5845 1.31105e-05
R7015 5845 5846 1.696 0.8 13.568 37
I5846 0 5846 1.24921e-05
R7016 5846 5847 1.6 0.8 12.8 37
I5847 0 5847 1.23684e-05
R7017 5847 5848 1.728 0.8 13.824 37
I5848 0 5848 1.26158e-05
R7018 5848 5849 1.648 0.8 13.184 37
I5849 0 5849 1.24921e-05
R7019 5849 5850 1.616 0.8 12.928 37
I5850 0 5850 1.23684e-05
R7020 5850 0 0.1 49.28 49.28 37
*seg: 586
R7021 0 5851 0.1 49.28 49.28 37
R7022 5855 5865 6.16 0.8 49.28 37
I5851 0 5851 1.27395e-05
R7023 5851 5852 1.68 0.8 13.44 37
I5852 0 5852 1.26158e-05
R7024 5852 5853 1.616 0.8 12.928 37
I5853 0 5853 1.27395e-05
R7025 5853 5854 1.744 0.8 13.952 37
I5854 0 5854 1.31105e-05
R7026 5854 5855 1.648 0.8 13.184 37
I5855 0 5855 1.24921e-05
R7027 5855 5856 1.616 0.8 12.928 37
I5856 0 5856 1.24921e-05
R7028 5856 5857 1.6 0.8 12.8 37
I5857 0 5857 1.28631e-05
R7029 5857 5858 1.712 0.8 13.696 37
I5858 0 5858 1.23684e-05
R7030 5858 5859 1.648 0.8 13.184 37
I5859 0 5859 1.31105e-05
R7031 5859 5860 1.696 0.8 13.568 37
I5860 0 5860 1.23684e-05
R7032 5860 0 0.1 49.28 49.28 37
*seg: 587
R7033 0 5861 0.1 49.28 49.28 37
R7034 5865 5875 6.16 0.8 49.28 37
I5861 0 5861 1.33579e-05
R7035 5861 5862 1.68 0.8 13.44 37
I5862 0 5862 1.29868e-05
R7036 5862 5863 1.696 0.8 13.568 37
I5863 0 5863 1.32342e-05
R7037 5863 5864 1.744 0.8 13.952 37
I5864 0 5864 1.28631e-05
R7038 5864 5865 1.68 0.8 13.44 37
I5865 0 5865 1.32342e-05
R7039 5865 5866 1.616 0.8 12.928 37
I5866 0 5866 1.29868e-05
R7040 5866 5867 1.648 0.8 13.184 37
I5867 0 5867 1.28631e-05
R7041 5867 5868 1.648 0.8 13.184 37
I5868 0 5868 1.34816e-05
R7042 5868 5869 1.632 0.8 13.056 37
I5869 0 5869 1.33579e-05
R7043 5869 5870 1.696 0.8 13.568 37
I5870 0 5870 1.23684e-05
R7044 5870 0 0.1 49.28 49.28 37
*seg: 588
R7045 0 5871 0.1 49.28 49.28 37
R7046 5875 5885 6.16 0.8 49.28 37
I5871 0 5871 1.31105e-05
R7047 5871 5872 1.616 0.8 12.928 37
I5872 0 5872 1.27395e-05
R7048 5872 5873 1.616 0.8 12.928 37
I5873 0 5873 1.23684e-05
R7049 5873 5874 1.6 0.8 12.8 37
I5874 0 5874 1.32342e-05
R7050 5874 5875 1.68 0.8 13.44 37
I5875 0 5875 1.26158e-05
R7051 5875 5876 1.6 0.8 12.8 37
I5876 0 5876 1.33579e-05
R7052 5876 5877 1.6 0.8 12.8 37
I5877 0 5877 1.29868e-05
R7053 5877 5878 1.712 0.8 13.696 37
I5878 0 5878 1.34816e-05
R7054 5878 5879 1.68 0.8 13.44 37
I5879 0 5879 1.31105e-05
R7055 5879 5880 1.616 0.8 12.928 37
I5880 0 5880 1.23684e-05
R7056 5880 0 0.1 49.28 49.28 37
*seg: 589
R7057 0 5881 0.1 49.28 49.28 37
R7058 5885 5895 6.16 0.8 49.28 37
I5881 0 5881 1.24921e-05
R7059 5881 5882 1.648 0.8 13.184 37
I5882 0 5882 1.32342e-05
R7060 5882 5883 1.712 0.8 13.696 37
I5883 0 5883 1.27395e-05
R7061 5883 5884 1.616 0.8 12.928 37
I5884 0 5884 1.23684e-05
R7062 5884 5885 1.696 0.8 13.568 37
I5885 0 5885 1.33579e-05
R7063 5885 5886 1.6 0.8 12.8 37
I5886 0 5886 1.29868e-05
R7064 5886 5887 1.712 0.8 13.696 37
I5887 0 5887 1.29868e-05
R7065 5887 5888 1.744 0.8 13.952 37
I5888 0 5888 1.27395e-05
R7066 5888 5889 1.648 0.8 13.184 37
I5889 0 5889 1.32342e-05
R7067 5889 5890 1.616 0.8 12.928 37
I5890 0 5890 1.23684e-05
R7068 5890 0 0.1 49.28 49.28 37
*seg: 590
R7069 0 5891 0.1 49.28 49.28 37
R7070 5895 5905 6.16 0.8 49.28 37
I5891 0 5891 1.29868e-05
R7071 5891 5892 1.728 0.8 13.824 37
I5892 0 5892 1.31105e-05
R7072 5892 5893 1.744 0.8 13.952 37
I5893 0 5893 1.29868e-05
R7073 5893 5894 1.712 0.8 13.696 37
I5894 0 5894 1.29868e-05
R7074 5894 5895 1.696 0.8 13.568 37
I5895 0 5895 1.23684e-05
R7075 5895 5896 1.632 0.8 13.056 37
I5896 0 5896 1.26158e-05
R7076 5896 5897 1.664 0.8 13.312 37
I5897 0 5897 1.26158e-05
R7077 5897 5898 1.68 0.8 13.44 37
I5898 0 5898 1.31105e-05
R7078 5898 5899 1.6 0.8 12.8 37
I5899 0 5899 1.26158e-05
R7079 5899 5900 1.6 0.8 12.8 37
I5900 0 5900 1.23684e-05
R7080 5900 0 0.1 49.28 49.28 37
*seg: 591
R7081 0 5901 0.1 49.28 49.28 37
R7082 5905 5915 6.16 0.8 49.28 37
I5901 0 5901 1.33579e-05
R7083 5901 5902 1.616 0.8 12.928 37
I5902 0 5902 1.31105e-05
R7084 5902 5903 1.664 0.8 13.312 37
I5903 0 5903 1.31105e-05
R7085 5903 5904 1.728 0.8 13.824 37
I5904 0 5904 1.27395e-05
R7086 5904 5905 1.68 0.8 13.44 37
I5905 0 5905 1.32342e-05
R7087 5905 5906 1.6 0.8 12.8 37
I5906 0 5906 1.34816e-05
R7088 5906 5907 1.6 0.8 12.8 37
I5907 0 5907 1.33579e-05
R7089 5907 5908 1.728 0.8 13.824 37
I5908 0 5908 1.23684e-05
R7090 5908 5909 1.68 0.8 13.44 37
I5909 0 5909 1.29868e-05
R7091 5909 5910 1.664 0.8 13.312 37
I5910 0 5910 1.23684e-05
R7092 5910 0 0.1 49.28 49.28 37
*seg: 592
R7093 0 5911 0.1 49.28 49.28 37
R7094 5915 5925 6.16 0.8 49.28 37
I5911 0 5911 1.23684e-05
R7095 5911 5912 1.744 0.8 13.952 37
I5912 0 5912 1.26158e-05
R7096 5912 5913 1.696 0.8 13.568 37
I5913 0 5913 1.27395e-05
R7097 5913 5914 1.648 0.8 13.184 37
I5914 0 5914 1.24921e-05
R7098 5914 5915 1.664 0.8 13.312 37
I5915 0 5915 1.24921e-05
R7099 5915 5916 1.696 0.8 13.568 37
I5916 0 5916 1.31105e-05
R7100 5916 5917 1.68 0.8 13.44 37
I5917 0 5917 1.23684e-05
R7101 5917 5918 1.648 0.8 13.184 37
I5918 0 5918 1.26158e-05
R7102 5918 5919 1.696 0.8 13.568 37
I5919 0 5919 1.29868e-05
R7103 5919 5920 1.712 0.8 13.696 37
I5920 0 5920 1.23684e-05
R7104 5920 0 0.1 49.28 49.28 37
*seg: 593
R7105 0 5921 0.1 49.28 49.28 37
R7106 5925 5935 6.16 0.8 49.28 37
I5921 0 5921 1.26158e-05
R7107 5921 5922 1.696 0.8 13.568 37
I5922 0 5922 1.27395e-05
R7108 5922 5923 1.696 0.8 13.568 37
I5923 0 5923 1.31105e-05
R7109 5923 5924 1.6 0.8 12.8 37
I5924 0 5924 1.23684e-05
R7110 5924 5925 1.648 0.8 13.184 37
I5925 0 5925 1.28631e-05
R7111 5925 5926 1.616 0.8 12.928 37
I5926 0 5926 1.33579e-05
R7112 5926 5927 1.648 0.8 13.184 37
I5927 0 5927 1.34816e-05
R7113 5927 5928 1.616 0.8 12.928 37
I5928 0 5928 1.26158e-05
R7114 5928 5929 1.712 0.8 13.696 37
I5929 0 5929 1.34816e-05
R7115 5929 5930 1.632 0.8 13.056 37
I5930 0 5930 1.23684e-05
R7116 5930 0 0.1 49.28 49.28 37
*seg: 594
R7117 0 5931 0.1 49.28 49.28 37
R7118 5935 5945 6.16 0.8 49.28 37
I5931 0 5931 1.23684e-05
R7119 5931 5932 1.648 0.8 13.184 37
I5932 0 5932 1.34816e-05
R7120 5932 5933 1.6 0.8 12.8 37
I5933 0 5933 1.26158e-05
R7121 5933 5934 1.632 0.8 13.056 37
I5934 0 5934 1.26158e-05
R7122 5934 5935 1.6 0.8 12.8 37
I5935 0 5935 1.33579e-05
R7123 5935 5936 1.616 0.8 12.928 37
I5936 0 5936 1.24921e-05
R7124 5936 5937 1.68 0.8 13.44 37
I5937 0 5937 1.34816e-05
R7125 5937 5938 1.696 0.8 13.568 37
I5938 0 5938 1.28631e-05
R7126 5938 5939 1.68 0.8 13.44 37
I5939 0 5939 1.31105e-05
R7127 5939 5940 1.712 0.8 13.696 37
I5940 0 5940 1.23684e-05
R7128 5940 0 0.1 49.28 49.28 37
*seg: 595
R7129 0 5941 0.1 49.28 49.28 37
R7130 5945 5955 6.16 0.8 49.28 37
I5941 0 5941 1.32342e-05
R7131 5941 5942 1.6 0.8 12.8 37
I5942 0 5942 1.33579e-05
R7132 5942 5943 1.664 0.8 13.312 37
I5943 0 5943 1.28631e-05
R7133 5943 5944 1.6 0.8 12.8 37
I5944 0 5944 1.26158e-05
R7134 5944 5945 1.648 0.8 13.184 37
I5945 0 5945 1.31105e-05
R7135 5945 5946 1.616 0.8 12.928 37
I5946 0 5946 1.24921e-05
R7136 5946 5947 1.712 0.8 13.696 37
I5947 0 5947 1.28631e-05
R7137 5947 5948 1.744 0.8 13.952 37
I5948 0 5948 1.33579e-05
R7138 5948 5949 1.664 0.8 13.312 37
I5949 0 5949 1.23684e-05
R7139 5949 5950 1.632 0.8 13.056 37
I5950 0 5950 1.23684e-05
R7140 5950 0 0.1 49.28 49.28 37
*seg: 596
R7141 0 5951 0.1 49.28 49.28 37
R7142 5955 5965 6.16 0.8 49.28 37
I5951 0 5951 1.27395e-05
R7143 5951 5952 1.664 0.8 13.312 37
I5952 0 5952 1.23684e-05
R7144 5952 5953 1.632 0.8 13.056 37
I5953 0 5953 1.26158e-05
R7145 5953 5954 1.632 0.8 13.056 37
I5954 0 5954 1.33579e-05
R7146 5954 5955 1.744 0.8 13.952 37
I5955 0 5955 1.29868e-05
R7147 5955 5956 1.712 0.8 13.696 37
I5956 0 5956 1.33579e-05
R7148 5956 5957 1.68 0.8 13.44 37
I5957 0 5957 1.24921e-05
R7149 5957 5958 1.6 0.8 12.8 37
I5958 0 5958 1.31105e-05
R7150 5958 5959 1.632 0.8 13.056 37
I5959 0 5959 1.23684e-05
R7151 5959 5960 1.696 0.8 13.568 37
I5960 0 5960 1.23684e-05
R7152 5960 0 0.1 49.28 49.28 37
*seg: 597
R7153 0 5961 0.1 49.28 49.28 37
R7154 5965 5975 6.16 0.8 49.28 37
I5961 0 5961 1.28631e-05
R7155 5961 5962 1.696 0.8 13.568 37
I5962 0 5962 1.28631e-05
R7156 5962 5963 1.664 0.8 13.312 37
I5963 0 5963 1.33579e-05
R7157 5963 5964 1.68 0.8 13.44 37
I5964 0 5964 1.32342e-05
R7158 5964 5965 1.664 0.8 13.312 37
I5965 0 5965 1.28631e-05
R7159 5965 5966 1.68 0.8 13.44 37
I5966 0 5966 1.31105e-05
R7160 5966 5967 1.68 0.8 13.44 37
I5967 0 5967 1.31105e-05
R7161 5967 5968 1.728 0.8 13.824 37
I5968 0 5968 1.31105e-05
R7162 5968 5969 1.664 0.8 13.312 37
I5969 0 5969 1.26158e-05
R7163 5969 5970 1.664 0.8 13.312 37
I5970 0 5970 1.23684e-05
R7164 5970 0 0.1 49.28 49.28 37
*seg: 598
R7165 0 5971 0.1 49.28 49.28 37
R7166 5975 5985 6.16 0.8 49.28 37
I5971 0 5971 1.33579e-05
R7167 5971 5972 1.744 0.8 13.952 37
I5972 0 5972 1.26158e-05
R7168 5972 5973 1.664 0.8 13.312 37
I5973 0 5973 1.31105e-05
R7169 5973 5974 1.616 0.8 12.928 37
I5974 0 5974 1.34816e-05
R7170 5974 5975 1.664 0.8 13.312 37
I5975 0 5975 1.33579e-05
R7171 5975 5976 1.68 0.8 13.44 37
I5976 0 5976 1.29868e-05
R7172 5976 5977 1.664 0.8 13.312 37
I5977 0 5977 1.32342e-05
R7173 5977 5978 1.648 0.8 13.184 37
I5978 0 5978 1.32342e-05
R7174 5978 5979 1.68 0.8 13.44 37
I5979 0 5979 1.32342e-05
R7175 5979 5980 1.664 0.8 13.312 37
I5980 0 5980 1.23684e-05
R7176 5980 0 0.1 49.28 49.28 37
*seg: 599
R7177 0 5981 0.1 49.28 49.28 37
R7178 5985 5995 6.16 0.8 49.28 37
I5981 0 5981 1.24921e-05
R7179 5981 5982 1.696 0.8 13.568 37
I5982 0 5982 1.32342e-05
R7180 5982 5983 1.728 0.8 13.824 37
I5983 0 5983 1.23684e-05
R7181 5983 5984 1.6 0.8 12.8 37
I5984 0 5984 1.24921e-05
R7182 5984 5985 1.616 0.8 12.928 37
I5985 0 5985 1.32342e-05
R7183 5985 5986 1.616 0.8 12.928 37
I5986 0 5986 1.34816e-05
R7184 5986 5987 1.648 0.8 13.184 37
I5987 0 5987 1.29868e-05
R7185 5987 5988 1.728 0.8 13.824 37
I5988 0 5988 1.29868e-05
R7186 5988 5989 1.728 0.8 13.824 37
I5989 0 5989 1.24921e-05
R7187 5989 5990 1.712 0.8 13.696 37
I5990 0 5990 1.23684e-05
R7188 5990 0 0.1 49.28 49.28 37
*seg: 600
R7189 0 5991 0.1 49.28 49.28 37
R7190 5995 6005 6.16 0.8 49.28 37
I5991 0 5991 1.34816e-05
R7191 5991 5992 1.68 0.8 13.44 37
I5992 0 5992 1.31105e-05
R7192 5992 5993 1.68 0.8 13.44 37
I5993 0 5993 1.33579e-05
R7193 5993 5994 1.632 0.8 13.056 37
I5994 0 5994 1.27395e-05
R7194 5994 5995 1.616 0.8 12.928 37
I5995 0 5995 1.28631e-05
R7195 5995 5996 1.616 0.8 12.928 37
I5996 0 5996 1.32342e-05
R7196 5996 5997 1.728 0.8 13.824 37
I5997 0 5997 1.26158e-05
R7197 5997 5998 1.664 0.8 13.312 37
I5998 0 5998 1.33579e-05
R7198 5998 5999 1.648 0.8 13.184 37
I5999 0 5999 1.31105e-05
R7199 5999 6000 1.648 0.8 13.184 37
I6000 0 6000 1.23684e-05
R7200 6000 0 0.1 49.28 49.28 37
*seg: 601
R7201 0 6001 0.1 49.28 49.28 37
R7202 6005 6015 6.16 0.8 49.28 37
I6001 0 6001 1.26158e-05
R7203 6001 6002 1.616 0.8 12.928 37
I6002 0 6002 1.33579e-05
R7204 6002 6003 1.6 0.8 12.8 37
I6003 0 6003 1.26158e-05
R7205 6003 6004 1.6 0.8 12.8 37
I6004 0 6004 1.34816e-05
R7206 6004 6005 1.696 0.8 13.568 37
I6005 0 6005 1.27395e-05
R7207 6005 6006 1.616 0.8 12.928 37
I6006 0 6006 1.26158e-05
R7208 6006 6007 1.664 0.8 13.312 37
I6007 0 6007 1.34816e-05
R7209 6007 6008 1.616 0.8 12.928 37
I6008 0 6008 1.33579e-05
R7210 6008 6009 1.68 0.8 13.44 37
I6009 0 6009 1.24921e-05
R7211 6009 6010 1.632 0.8 13.056 37
I6010 0 6010 1.23684e-05
R7212 6010 0 0.1 49.28 49.28 37
*seg: 602
R7213 0 6011 0.1 49.28 49.28 37
R7214 6015 6025 6.16 0.8 49.28 37
I6011 0 6011 1.33579e-05
R7215 6011 6012 1.696 0.8 13.568 37
I6012 0 6012 1.28631e-05
R7216 6012 6013 1.616 0.8 12.928 37
I6013 0 6013 1.28631e-05
R7217 6013 6014 1.696 0.8 13.568 37
I6014 0 6014 1.26158e-05
R7218 6014 6015 1.68 0.8 13.44 37
I6015 0 6015 1.27395e-05
R7219 6015 6016 1.728 0.8 13.824 37
I6016 0 6016 1.34816e-05
R7220 6016 6017 1.712 0.8 13.696 37
I6017 0 6017 1.32342e-05
R7221 6017 6018 1.616 0.8 12.928 37
I6018 0 6018 1.28631e-05
R7222 6018 6019 1.648 0.8 13.184 37
I6019 0 6019 1.29868e-05
R7223 6019 6020 1.744 0.8 13.952 37
I6020 0 6020 1.23684e-05
R7224 6020 0 0.1 49.28 49.28 37
*seg: 603
R7225 0 6021 0.1 49.28 49.28 37
R7226 6025 6035 6.16 0.8 49.28 37
I6021 0 6021 1.23684e-05
R7227 6021 6022 1.68 0.8 13.44 37
I6022 0 6022 1.27395e-05
R7228 6022 6023 1.712 0.8 13.696 37
I6023 0 6023 1.33579e-05
R7229 6023 6024 1.616 0.8 12.928 37
I6024 0 6024 1.26158e-05
R7230 6024 6025 1.712 0.8 13.696 37
I6025 0 6025 1.31105e-05
R7231 6025 6026 1.616 0.8 12.928 37
I6026 0 6026 1.31105e-05
R7232 6026 6027 1.712 0.8 13.696 37
I6027 0 6027 1.31105e-05
R7233 6027 6028 1.6 0.8 12.8 37
I6028 0 6028 1.33579e-05
R7234 6028 6029 1.616 0.8 12.928 37
I6029 0 6029 1.29868e-05
R7235 6029 6030 1.712 0.8 13.696 37
I6030 0 6030 1.23684e-05
R7236 6030 0 0.1 49.28 49.28 37
*seg: 604
R7237 0 6031 0.1 49.28 49.28 37
R7238 6035 6045 6.16 0.8 49.28 37
I6031 0 6031 1.34816e-05
R7239 6031 6032 1.696 0.8 13.568 37
I6032 0 6032 1.32342e-05
R7240 6032 6033 1.68 0.8 13.44 37
I6033 0 6033 1.29868e-05
R7241 6033 6034 1.696 0.8 13.568 37
I6034 0 6034 1.28631e-05
R7242 6034 6035 1.6 0.8 12.8 37
I6035 0 6035 1.31105e-05
R7243 6035 6036 1.6 0.8 12.8 37
I6036 0 6036 1.28631e-05
R7244 6036 6037 1.664 0.8 13.312 37
I6037 0 6037 1.33579e-05
R7245 6037 6038 1.728 0.8 13.824 37
I6038 0 6038 1.31105e-05
R7246 6038 6039 1.728 0.8 13.824 37
I6039 0 6039 1.27395e-05
R7247 6039 6040 1.6 0.8 12.8 37
I6040 0 6040 1.23684e-05
R7248 6040 0 0.1 49.28 49.28 37
*seg: 605
R7249 0 6041 0.1 49.28 49.28 37
R7250 6045 6055 6.16 0.8 49.28 37
I6041 0 6041 1.24921e-05
R7251 6041 6042 1.68 0.8 13.44 37
I6042 0 6042 1.33579e-05
R7252 6042 6043 1.744 0.8 13.952 37
I6043 0 6043 1.27395e-05
R7253 6043 6044 1.6 0.8 12.8 37
I6044 0 6044 1.33579e-05
R7254 6044 6045 1.616 0.8 12.928 37
I6045 0 6045 1.27395e-05
R7255 6045 6046 1.6 0.8 12.8 37
I6046 0 6046 1.29868e-05
R7256 6046 6047 1.728 0.8 13.824 37
I6047 0 6047 1.28631e-05
R7257 6047 6048 1.648 0.8 13.184 37
I6048 0 6048 1.27395e-05
R7258 6048 6049 1.712 0.8 13.696 37
I6049 0 6049 1.31105e-05
R7259 6049 6050 1.744 0.8 13.952 37
I6050 0 6050 1.23684e-05
R7260 6050 0 0.1 49.28 49.28 37
*seg: 606
R7261 0 6051 0.1 49.28 49.28 37
R7262 6055 6065 6.16 0.8 49.28 37
I6051 0 6051 1.32342e-05
R7263 6051 6052 1.632 0.8 13.056 37
I6052 0 6052 1.28631e-05
R7264 6052 6053 1.68 0.8 13.44 37
I6053 0 6053 1.29868e-05
R7265 6053 6054 1.664 0.8 13.312 37
I6054 0 6054 1.23684e-05
R7266 6054 6055 1.632 0.8 13.056 37
I6055 0 6055 1.28631e-05
R7267 6055 6056 1.664 0.8 13.312 37
I6056 0 6056 1.34816e-05
R7268 6056 6057 1.6 0.8 12.8 37
I6057 0 6057 1.23684e-05
R7269 6057 6058 1.6 0.8 12.8 37
I6058 0 6058 1.34816e-05
R7270 6058 6059 1.648 0.8 13.184 37
I6059 0 6059 1.28631e-05
R7271 6059 6060 1.696 0.8 13.568 37
I6060 0 6060 1.23684e-05
R7272 6060 0 0.1 49.28 49.28 37
*seg: 607
R7273 0 6061 0.1 49.28 49.28 37
R7274 6065 6075 6.16 0.8 49.28 37
I6061 0 6061 1.28631e-05
R7275 6061 6062 1.68 0.8 13.44 37
I6062 0 6062 1.33579e-05
R7276 6062 6063 1.648 0.8 13.184 37
I6063 0 6063 1.29868e-05
R7277 6063 6064 1.616 0.8 12.928 37
I6064 0 6064 1.23684e-05
R7278 6064 6065 1.712 0.8 13.696 37
I6065 0 6065 1.34816e-05
R7279 6065 6066 1.68 0.8 13.44 37
I6066 0 6066 1.32342e-05
R7280 6066 6067 1.616 0.8 12.928 37
I6067 0 6067 1.33579e-05
R7281 6067 6068 1.648 0.8 13.184 37
I6068 0 6068 1.27395e-05
R7282 6068 6069 1.632 0.8 13.056 37
I6069 0 6069 1.28631e-05
R7283 6069 6070 1.6 0.8 12.8 37
I6070 0 6070 1.23684e-05
R7284 6070 0 0.1 49.28 49.28 37
*seg: 608
R7285 0 6071 0.1 49.28 49.28 37
R7286 6075 6085 6.16 0.8 49.28 37
I6071 0 6071 1.33579e-05
R7287 6071 6072 1.616 0.8 12.928 37
I6072 0 6072 1.27395e-05
R7288 6072 6073 1.6 0.8 12.8 37
I6073 0 6073 1.31105e-05
R7289 6073 6074 1.648 0.8 13.184 37
I6074 0 6074 1.23684e-05
R7290 6074 6075 1.744 0.8 13.952 37
I6075 0 6075 1.32342e-05
R7291 6075 6076 1.6 0.8 12.8 37
I6076 0 6076 1.28631e-05
R7292 6076 6077 1.6 0.8 12.8 37
I6077 0 6077 1.26158e-05
R7293 6077 6078 1.616 0.8 12.928 37
I6078 0 6078 1.32342e-05
R7294 6078 6079 1.68 0.8 13.44 37
I6079 0 6079 1.32342e-05
R7295 6079 6080 1.632 0.8 13.056 37
I6080 0 6080 1.23684e-05
R7296 6080 0 0.1 49.28 49.28 37
*seg: 609
R7297 0 6081 0.1 49.28 49.28 37
R7298 6085 6095 6.16 0.8 49.28 37
I6081 0 6081 1.28631e-05
R7299 6081 6082 1.6 0.8 12.8 37
I6082 0 6082 1.32342e-05
R7300 6082 6083 1.616 0.8 12.928 37
I6083 0 6083 1.32342e-05
R7301 6083 6084 1.728 0.8 13.824 37
I6084 0 6084 1.26158e-05
R7302 6084 6085 1.696 0.8 13.568 37
I6085 0 6085 1.24921e-05
R7303 6085 6086 1.6 0.8 12.8 37
I6086 0 6086 1.31105e-05
R7304 6086 6087 1.6 0.8 12.8 37
I6087 0 6087 1.26158e-05
R7305 6087 6088 1.616 0.8 12.928 37
I6088 0 6088 1.34816e-05
R7306 6088 6089 1.712 0.8 13.696 37
I6089 0 6089 1.33579e-05
R7307 6089 6090 1.728 0.8 13.824 37
I6090 0 6090 1.23684e-05
R7308 6090 0 0.1 49.28 49.28 37
*seg: 610
R7309 0 6091 0.1 49.28 49.28 37
R7310 6095 6105 6.16 0.8 49.28 37
I6091 0 6091 1.23684e-05
R7311 6091 6092 1.664 0.8 13.312 37
I6092 0 6092 1.29868e-05
R7312 6092 6093 1.696 0.8 13.568 37
I6093 0 6093 1.31105e-05
R7313 6093 6094 1.6 0.8 12.8 37
I6094 0 6094 1.33579e-05
R7314 6094 6095 1.744 0.8 13.952 37
I6095 0 6095 1.29868e-05
R7315 6095 6096 1.664 0.8 13.312 37
I6096 0 6096 1.29868e-05
R7316 6096 6097 1.696 0.8 13.568 37
I6097 0 6097 1.27395e-05
R7317 6097 6098 1.664 0.8 13.312 37
I6098 0 6098 1.23684e-05
R7318 6098 6099 1.632 0.8 13.056 37
I6099 0 6099 1.23684e-05
R7319 6099 6100 1.6 0.8 12.8 37
I6100 0 6100 1.23684e-05
R7320 6100 0 0.1 49.28 49.28 37
*seg: 611
R7321 0 6101 0.1 49.28 49.28 37
R7322 6105 6115 6.16 0.8 49.28 37
I6101 0 6101 1.33579e-05
R7323 6101 6102 1.68 0.8 13.44 37
I6102 0 6102 1.27395e-05
R7324 6102 6103 1.616 0.8 12.928 37
I6103 0 6103 1.24921e-05
R7325 6103 6104 1.664 0.8 13.312 37
I6104 0 6104 1.32342e-05
R7326 6104 6105 1.616 0.8 12.928 37
I6105 0 6105 1.31105e-05
R7327 6105 6106 1.744 0.8 13.952 37
I6106 0 6106 1.33579e-05
R7328 6106 6107 1.616 0.8 12.928 37
I6107 0 6107 1.29868e-05
R7329 6107 6108 1.68 0.8 13.44 37
I6108 0 6108 1.24921e-05
R7330 6108 6109 1.728 0.8 13.824 37
I6109 0 6109 1.33579e-05
R7331 6109 6110 1.744 0.8 13.952 37
I6110 0 6110 1.23684e-05
R7332 6110 0 0.1 49.28 49.28 37
*seg: 612
R7333 0 6111 0.1 49.28 49.28 37
R7334 6115 6125 6.16 0.8 49.28 37
I6111 0 6111 1.33579e-05
R7335 6111 6112 1.648 0.8 13.184 37
I6112 0 6112 1.34816e-05
R7336 6112 6113 1.68 0.8 13.44 37
I6113 0 6113 1.31105e-05
R7337 6113 6114 1.712 0.8 13.696 37
I6114 0 6114 1.27395e-05
R7338 6114 6115 1.68 0.8 13.44 37
I6115 0 6115 1.26158e-05
R7339 6115 6116 1.696 0.8 13.568 37
I6116 0 6116 1.23684e-05
R7340 6116 6117 1.664 0.8 13.312 37
I6117 0 6117 1.33579e-05
R7341 6117 6118 1.728 0.8 13.824 37
I6118 0 6118 1.26158e-05
R7342 6118 6119 1.696 0.8 13.568 37
I6119 0 6119 1.33579e-05
R7343 6119 6120 1.664 0.8 13.312 37
I6120 0 6120 1.23684e-05
R7344 6120 0 0.1 49.28 49.28 37
*seg: 613
R7345 0 6121 0.1 49.28 49.28 37
R7346 6125 6135 6.16 0.8 49.28 37
I6121 0 6121 1.34816e-05
R7347 6121 6122 1.728 0.8 13.824 37
I6122 0 6122 1.28631e-05
R7348 6122 6123 1.68 0.8 13.44 37
I6123 0 6123 1.32342e-05
R7349 6123 6124 1.616 0.8 12.928 37
I6124 0 6124 1.24921e-05
R7350 6124 6125 1.648 0.8 13.184 37
I6125 0 6125 1.31105e-05
R7351 6125 6126 1.664 0.8 13.312 37
I6126 0 6126 1.31105e-05
R7352 6126 6127 1.664 0.8 13.312 37
I6127 0 6127 1.29868e-05
R7353 6127 6128 1.6 0.8 12.8 37
I6128 0 6128 1.32342e-05
R7354 6128 6129 1.744 0.8 13.952 37
I6129 0 6129 1.24921e-05
R7355 6129 6130 1.712 0.8 13.696 37
I6130 0 6130 1.23684e-05
R7356 6130 0 0.1 49.28 49.28 37
*seg: 614
R7357 0 6131 0.1 49.28 49.28 37
R7358 6135 6145 6.16 0.8 49.28 37
I6131 0 6131 1.29868e-05
R7359 6131 6132 1.744 0.8 13.952 37
I6132 0 6132 1.34816e-05
R7360 6132 6133 1.696 0.8 13.568 37
I6133 0 6133 1.24921e-05
R7361 6133 6134 1.632 0.8 13.056 37
I6134 0 6134 1.29868e-05
R7362 6134 6135 1.744 0.8 13.952 37
I6135 0 6135 1.28631e-05
R7363 6135 6136 1.6 0.8 12.8 37
I6136 0 6136 1.28631e-05
R7364 6136 6137 1.648 0.8 13.184 37
I6137 0 6137 1.34816e-05
R7365 6137 6138 1.616 0.8 12.928 37
I6138 0 6138 1.24921e-05
R7366 6138 6139 1.664 0.8 13.312 37
I6139 0 6139 1.32342e-05
R7367 6139 6140 1.616 0.8 12.928 37
I6140 0 6140 1.23684e-05
R7368 6140 0 0.1 49.28 49.28 37
*seg: 615
R7369 0 6141 0.1 49.28 49.28 37
R7370 6145 6155 6.16 0.8 49.28 37
I6141 0 6141 1.34816e-05
R7371 6141 6142 1.712 0.8 13.696 37
I6142 0 6142 1.33579e-05
R7372 6142 6143 1.68 0.8 13.44 37
I6143 0 6143 1.32342e-05
R7373 6143 6144 1.664 0.8 13.312 37
I6144 0 6144 1.29868e-05
R7374 6144 6145 1.648 0.8 13.184 37
I6145 0 6145 1.34816e-05
R7375 6145 6146 1.696 0.8 13.568 37
I6146 0 6146 1.33579e-05
R7376 6146 6147 1.728 0.8 13.824 37
I6147 0 6147 1.26158e-05
R7377 6147 6148 1.696 0.8 13.568 37
I6148 0 6148 1.32342e-05
R7378 6148 6149 1.632 0.8 13.056 37
I6149 0 6149 1.24921e-05
R7379 6149 6150 1.744 0.8 13.952 37
I6150 0 6150 1.23684e-05
R7380 6150 0 0.1 49.28 49.28 37
*seg: 616
R7381 0 6151 0.1 49.28 49.28 37
R7382 6155 6165 6.16 0.8 49.28 37
I6151 0 6151 1.33579e-05
R7383 6151 6152 1.68 0.8 13.44 37
I6152 0 6152 1.32342e-05
R7384 6152 6153 1.728 0.8 13.824 37
I6153 0 6153 1.24921e-05
R7385 6153 6154 1.648 0.8 13.184 37
I6154 0 6154 1.23684e-05
R7386 6154 6155 1.616 0.8 12.928 37
I6155 0 6155 1.31105e-05
R7387 6155 6156 1.6 0.8 12.8 37
I6156 0 6156 1.34816e-05
R7388 6156 6157 1.712 0.8 13.696 37
I6157 0 6157 1.32342e-05
R7389 6157 6158 1.664 0.8 13.312 37
I6158 0 6158 1.31105e-05
R7390 6158 6159 1.68 0.8 13.44 37
I6159 0 6159 1.34816e-05
R7391 6159 6160 1.712 0.8 13.696 37
I6160 0 6160 1.23684e-05
R7392 6160 0 0.1 49.28 49.28 37
*seg: 617
R7393 0 6161 0.1 49.28 49.28 37
R7394 6165 6175 6.16 0.8 49.28 37
I6161 0 6161 1.27395e-05
R7395 6161 6162 1.664 0.8 13.312 37
I6162 0 6162 1.29868e-05
R7396 6162 6163 1.744 0.8 13.952 37
I6163 0 6163 1.27395e-05
R7397 6163 6164 1.696 0.8 13.568 37
I6164 0 6164 1.31105e-05
R7398 6164 6165 1.632 0.8 13.056 37
I6165 0 6165 1.28631e-05
R7399 6165 6166 1.712 0.8 13.696 37
I6166 0 6166 1.24921e-05
R7400 6166 6167 1.6 0.8 12.8 37
I6167 0 6167 1.26158e-05
R7401 6167 6168 1.712 0.8 13.696 37
I6168 0 6168 1.24921e-05
R7402 6168 6169 1.616 0.8 12.928 37
I6169 0 6169 1.26158e-05
R7403 6169 6170 1.744 0.8 13.952 37
I6170 0 6170 1.23684e-05
R7404 6170 0 0.1 49.28 49.28 37
*seg: 618
R7405 0 6171 0.1 49.28 49.28 37
R7406 6175 6185 6.16 0.8 49.28 37
I6171 0 6171 1.33579e-05
R7407 6171 6172 1.712 0.8 13.696 37
I6172 0 6172 1.23684e-05
R7408 6172 6173 1.728 0.8 13.824 37
I6173 0 6173 1.24921e-05
R7409 6173 6174 1.68 0.8 13.44 37
I6174 0 6174 1.26158e-05
R7410 6174 6175 1.632 0.8 13.056 37
I6175 0 6175 1.32342e-05
R7411 6175 6176 1.728 0.8 13.824 37
I6176 0 6176 1.33579e-05
R7412 6176 6177 1.696 0.8 13.568 37
I6177 0 6177 1.24921e-05
R7413 6177 6178 1.616 0.8 12.928 37
I6178 0 6178 1.29868e-05
R7414 6178 6179 1.616 0.8 12.928 37
I6179 0 6179 1.34816e-05
R7415 6179 6180 1.648 0.8 13.184 37
I6180 0 6180 1.23684e-05
R7416 6180 0 0.1 49.28 49.28 37
*seg: 619
R7417 0 6181 0.1 49.28 49.28 37
R7418 6185 6195 6.16 0.8 49.28 37
I6181 0 6181 1.32342e-05
R7419 6181 6182 1.632 0.8 13.056 37
I6182 0 6182 1.34816e-05
R7420 6182 6183 1.648 0.8 13.184 37
I6183 0 6183 1.34816e-05
R7421 6183 6184 1.6 0.8 12.8 37
I6184 0 6184 1.34816e-05
R7422 6184 6185 1.744 0.8 13.952 37
I6185 0 6185 1.28631e-05
R7423 6185 6186 1.712 0.8 13.696 37
I6186 0 6186 1.26158e-05
R7424 6186 6187 1.632 0.8 13.056 37
I6187 0 6187 1.24921e-05
R7425 6187 6188 1.68 0.8 13.44 37
I6188 0 6188 1.34816e-05
R7426 6188 6189 1.712 0.8 13.696 37
I6189 0 6189 1.27395e-05
R7427 6189 6190 1.712 0.8 13.696 37
I6190 0 6190 1.23684e-05
R7428 6190 0 0.1 49.28 49.28 37
*seg: 620
R7429 0 6191 0.1 49.28 49.28 37
R7430 6195 6205 6.16 0.8 49.28 37
I6191 0 6191 1.26158e-05
R7431 6191 6192 1.6 0.8 12.8 37
I6192 0 6192 1.23684e-05
R7432 6192 6193 1.632 0.8 13.056 37
I6193 0 6193 1.27395e-05
R7433 6193 6194 1.616 0.8 12.928 37
I6194 0 6194 1.26158e-05
R7434 6194 6195 1.696 0.8 13.568 37
I6195 0 6195 1.34816e-05
R7435 6195 6196 1.744 0.8 13.952 37
I6196 0 6196 1.27395e-05
R7436 6196 6197 1.6 0.8 12.8 37
I6197 0 6197 1.24921e-05
R7437 6197 6198 1.744 0.8 13.952 37
I6198 0 6198 1.27395e-05
R7438 6198 6199 1.696 0.8 13.568 37
I6199 0 6199 1.33579e-05
R7439 6199 6200 1.68 0.8 13.44 37
I6200 0 6200 1.23684e-05
R7440 6200 0 0.1 49.28 49.28 37
*seg: 621
R7441 0 6201 0.1 49.28 49.28 37
R7442 6205 6215 6.16 0.8 49.28 37
I6201 0 6201 1.34816e-05
R7443 6201 6202 1.696 0.8 13.568 37
I6202 0 6202 1.33579e-05
R7444 6202 6203 1.712 0.8 13.696 37
I6203 0 6203 1.29868e-05
R7445 6203 6204 1.728 0.8 13.824 37
I6204 0 6204 1.26158e-05
R7446 6204 6205 1.712 0.8 13.696 37
I6205 0 6205 1.33579e-05
R7447 6205 6206 1.744 0.8 13.952 37
I6206 0 6206 1.26158e-05
R7448 6206 6207 1.68 0.8 13.44 37
I6207 0 6207 1.28631e-05
R7449 6207 6208 1.648 0.8 13.184 37
I6208 0 6208 1.26158e-05
R7450 6208 6209 1.648 0.8 13.184 37
I6209 0 6209 1.27395e-05
R7451 6209 6210 1.6 0.8 12.8 37
I6210 0 6210 1.23684e-05
R7452 6210 0 0.1 49.28 49.28 37
*seg: 622
R7453 0 6211 0.1 49.28 49.28 37
R7454 6215 6225 6.16 0.8 49.28 37
I6211 0 6211 1.31105e-05
R7455 6211 6212 1.728 0.8 13.824 37
I6212 0 6212 1.27395e-05
R7456 6212 6213 1.632 0.8 13.056 37
I6213 0 6213 1.33579e-05
R7457 6213 6214 1.744 0.8 13.952 37
I6214 0 6214 1.24921e-05
R7458 6214 6215 1.648 0.8 13.184 37
I6215 0 6215 1.23684e-05
R7459 6215 6216 1.6 0.8 12.8 37
I6216 0 6216 1.29868e-05
R7460 6216 6217 1.616 0.8 12.928 37
I6217 0 6217 1.27395e-05
R7461 6217 6218 1.664 0.8 13.312 37
I6218 0 6218 1.33579e-05
R7462 6218 6219 1.664 0.8 13.312 37
I6219 0 6219 1.31105e-05
R7463 6219 6220 1.6 0.8 12.8 37
I6220 0 6220 1.23684e-05
R7464 6220 0 0.1 49.28 49.28 37
*seg: 623
R7465 0 6221 0.1 49.28 49.28 37
R7466 6225 6235 6.16 0.8 49.28 37
I6221 0 6221 1.24921e-05
R7467 6221 6222 1.648 0.8 13.184 37
I6222 0 6222 1.28631e-05
R7468 6222 6223 1.664 0.8 13.312 37
I6223 0 6223 1.32342e-05
R7469 6223 6224 1.6 0.8 12.8 37
I6224 0 6224 1.23684e-05
R7470 6224 6225 1.648 0.8 13.184 37
I6225 0 6225 1.29868e-05
R7471 6225 6226 1.744 0.8 13.952 37
I6226 0 6226 1.28631e-05
R7472 6226 6227 1.616 0.8 12.928 37
I6227 0 6227 1.31105e-05
R7473 6227 6228 1.648 0.8 13.184 37
I6228 0 6228 1.34816e-05
R7474 6228 6229 1.6 0.8 12.8 37
I6229 0 6229 1.27395e-05
R7475 6229 6230 1.616 0.8 12.928 37
I6230 0 6230 1.23684e-05
R7476 6230 0 0.1 49.28 49.28 37
*seg: 624
R7477 0 6231 0.1 49.28 49.28 37
R7478 6235 6245 6.16 0.8 49.28 37
I6231 0 6231 1.33579e-05
R7479 6231 6232 1.664 0.8 13.312 37
I6232 0 6232 1.24921e-05
R7480 6232 6233 1.712 0.8 13.696 37
I6233 0 6233 1.29868e-05
R7481 6233 6234 1.6 0.8 12.8 37
I6234 0 6234 1.34816e-05
R7482 6234 6235 1.648 0.8 13.184 37
I6235 0 6235 1.24921e-05
R7483 6235 6236 1.616 0.8 12.928 37
I6236 0 6236 1.24921e-05
R7484 6236 6237 1.744 0.8 13.952 37
I6237 0 6237 1.31105e-05
R7485 6237 6238 1.696 0.8 13.568 37
I6238 0 6238 1.32342e-05
R7486 6238 6239 1.6 0.8 12.8 37
I6239 0 6239 1.27395e-05
R7487 6239 6240 1.6 0.8 12.8 37
I6240 0 6240 1.23684e-05
R7488 6240 0 0.1 49.28 49.28 37
*seg: 625
R7489 0 6241 0.1 49.28 49.28 37
R7490 6245 6255 6.16 0.8 49.28 37
I6241 0 6241 1.26158e-05
R7491 6241 6242 1.712 0.8 13.696 37
I6242 0 6242 1.23684e-05
R7492 6242 6243 1.712 0.8 13.696 37
I6243 0 6243 1.28631e-05
R7493 6243 6244 1.664 0.8 13.312 37
I6244 0 6244 1.29868e-05
R7494 6244 6245 1.648 0.8 13.184 37
I6245 0 6245 1.24921e-05
R7495 6245 6246 1.744 0.8 13.952 37
I6246 0 6246 1.29868e-05
R7496 6246 6247 1.616 0.8 12.928 37
I6247 0 6247 1.23684e-05
R7497 6247 6248 1.696 0.8 13.568 37
I6248 0 6248 1.32342e-05
R7498 6248 6249 1.632 0.8 13.056 37
I6249 0 6249 1.33579e-05
R7499 6249 6250 1.68 0.8 13.44 37
I6250 0 6250 1.23684e-05
R7500 6250 0 0.1 49.28 49.28 37
*seg: 626
R7501 0 6251 0.1 49.28 49.28 37
R7502 6255 6265 6.16 0.8 49.28 37
I6251 0 6251 1.28631e-05
R7503 6251 6252 1.632 0.8 13.056 37
I6252 0 6252 1.29868e-05
R7504 6252 6253 1.616 0.8 12.928 37
I6253 0 6253 1.27395e-05
R7505 6253 6254 1.728 0.8 13.824 37
I6254 0 6254 1.32342e-05
R7506 6254 6255 1.696 0.8 13.568 37
I6255 0 6255 1.27395e-05
R7507 6255 6256 1.632 0.8 13.056 37
I6256 0 6256 1.32342e-05
R7508 6256 6257 1.616 0.8 12.928 37
I6257 0 6257 1.29868e-05
R7509 6257 6258 1.632 0.8 13.056 37
I6258 0 6258 1.26158e-05
R7510 6258 6259 1.696 0.8 13.568 37
I6259 0 6259 1.28631e-05
R7511 6259 6260 1.68 0.8 13.44 37
I6260 0 6260 1.23684e-05
R7512 6260 0 0.1 49.28 49.28 37
*seg: 627
R7513 0 6261 0.1 49.28 49.28 37
R7514 6265 6275 6.16 0.8 49.28 37
I6261 0 6261 1.23684e-05
R7515 6261 6262 1.664 0.8 13.312 37
I6262 0 6262 1.32342e-05
R7516 6262 6263 1.712 0.8 13.696 37
I6263 0 6263 1.32342e-05
R7517 6263 6264 1.744 0.8 13.952 37
I6264 0 6264 1.33579e-05
R7518 6264 6265 1.696 0.8 13.568 37
I6265 0 6265 1.26158e-05
R7519 6265 6266 1.6 0.8 12.8 37
I6266 0 6266 1.33579e-05
R7520 6266 6267 1.712 0.8 13.696 37
I6267 0 6267 1.28631e-05
R7521 6267 6268 1.664 0.8 13.312 37
I6268 0 6268 1.24921e-05
R7522 6268 6269 1.696 0.8 13.568 37
I6269 0 6269 1.32342e-05
R7523 6269 6270 1.664 0.8 13.312 37
I6270 0 6270 1.23684e-05
R7524 6270 0 0.1 49.28 49.28 37
*seg: 628
R7525 0 6271 0.1 49.28 49.28 37
R7526 6275 6285 6.16 0.8 49.28 37
I6271 0 6271 1.34816e-05
R7527 6271 6272 1.6 0.8 12.8 37
I6272 0 6272 1.31105e-05
R7528 6272 6273 1.632 0.8 13.056 37
I6273 0 6273 1.27395e-05
R7529 6273 6274 1.696 0.8 13.568 37
I6274 0 6274 1.29868e-05
R7530 6274 6275 1.664 0.8 13.312 37
I6275 0 6275 1.31105e-05
R7531 6275 6276 1.696 0.8 13.568 37
I6276 0 6276 1.26158e-05
R7532 6276 6277 1.696 0.8 13.568 37
I6277 0 6277 1.34816e-05
R7533 6277 6278 1.616 0.8 12.928 37
I6278 0 6278 1.32342e-05
R7534 6278 6279 1.6 0.8 12.8 37
I6279 0 6279 1.29868e-05
R7535 6279 6280 1.664 0.8 13.312 37
I6280 0 6280 1.23684e-05
R7536 6280 0 0.1 49.28 49.28 37
*seg: 629
R7537 0 6281 0.1 49.28 49.28 37
R7538 6285 6295 6.16 0.8 49.28 37
I6281 0 6281 1.33579e-05
R7539 6281 6282 1.68 0.8 13.44 37
I6282 0 6282 1.31105e-05
R7540 6282 6283 1.616 0.8 12.928 37
I6283 0 6283 1.23684e-05
R7541 6283 6284 1.6 0.8 12.8 37
I6284 0 6284 1.33579e-05
R7542 6284 6285 1.744 0.8 13.952 37
I6285 0 6285 1.29868e-05
R7543 6285 6286 1.68 0.8 13.44 37
I6286 0 6286 1.32342e-05
R7544 6286 6287 1.68 0.8 13.44 37
I6287 0 6287 1.32342e-05
R7545 6287 6288 1.648 0.8 13.184 37
I6288 0 6288 1.26158e-05
R7546 6288 6289 1.664 0.8 13.312 37
I6289 0 6289 1.26158e-05
R7547 6289 6290 1.664 0.8 13.312 37
I6290 0 6290 1.23684e-05
R7548 6290 0 0.1 49.28 49.28 37
*seg: 630
R7549 0 6291 0.1 49.28 49.28 37
R7550 6295 6305 6.16 0.8 49.28 37
I6291 0 6291 1.32342e-05
R7551 6291 6292 1.6 0.8 12.8 37
I6292 0 6292 1.27395e-05
R7552 6292 6293 1.632 0.8 13.056 37
I6293 0 6293 1.34816e-05
R7553 6293 6294 1.68 0.8 13.44 37
I6294 0 6294 1.28631e-05
R7554 6294 6295 1.744 0.8 13.952 37
I6295 0 6295 1.33579e-05
R7555 6295 6296 1.68 0.8 13.44 37
I6296 0 6296 1.29868e-05
R7556 6296 6297 1.664 0.8 13.312 37
I6297 0 6297 1.24921e-05
R7557 6297 6298 1.696 0.8 13.568 37
I6298 0 6298 1.26158e-05
R7558 6298 6299 1.616 0.8 12.928 37
I6299 0 6299 1.27395e-05
R7559 6299 6300 1.664 0.8 13.312 37
I6300 0 6300 1.23684e-05
R7560 6300 0 0.1 49.28 49.28 37
*seg: 631
R7561 0 6301 0.1 49.28 49.28 37
R7562 6305 6315 6.16 0.8 49.28 37
I6301 0 6301 1.32342e-05
R7563 6301 6302 1.712 0.8 13.696 37
I6302 0 6302 1.32342e-05
R7564 6302 6303 1.696 0.8 13.568 37
I6303 0 6303 1.28631e-05
R7565 6303 6304 1.712 0.8 13.696 37
I6304 0 6304 1.27395e-05
R7566 6304 6305 1.68 0.8 13.44 37
I6305 0 6305 1.27395e-05
R7567 6305 6306 1.616 0.8 12.928 37
I6306 0 6306 1.29868e-05
R7568 6306 6307 1.6 0.8 12.8 37
I6307 0 6307 1.31105e-05
R7569 6307 6308 1.712 0.8 13.696 37
I6308 0 6308 1.26158e-05
R7570 6308 6309 1.664 0.8 13.312 37
I6309 0 6309 1.24921e-05
R7571 6309 6310 1.6 0.8 12.8 37
I6310 0 6310 1.23684e-05
R7572 6310 0 0.1 49.28 49.28 37
*seg: 632
R7573 0 6311 0.1 49.28 49.28 37
R7574 6315 6325 6.16 0.8 49.28 37
I6311 0 6311 1.34816e-05
R7575 6311 6312 1.728 0.8 13.824 37
I6312 0 6312 1.23684e-05
R7576 6312 6313 1.728 0.8 13.824 37
I6313 0 6313 1.32342e-05
R7577 6313 6314 1.648 0.8 13.184 37
I6314 0 6314 1.26158e-05
R7578 6314 6315 1.648 0.8 13.184 37
I6315 0 6315 1.32342e-05
R7579 6315 6316 1.68 0.8 13.44 37
I6316 0 6316 1.31105e-05
R7580 6316 6317 1.632 0.8 13.056 37
I6317 0 6317 1.24921e-05
R7581 6317 6318 1.744 0.8 13.952 37
I6318 0 6318 1.31105e-05
R7582 6318 6319 1.744 0.8 13.952 37
I6319 0 6319 1.31105e-05
R7583 6319 6320 1.6 0.8 12.8 37
I6320 0 6320 1.23684e-05
R7584 6320 0 0.1 49.28 49.28 37
*seg: 633
R7585 0 6321 0.1 49.28 49.28 37
R7586 6325 6335 6.16 0.8 49.28 37
I6321 0 6321 1.34816e-05
R7587 6321 6322 1.648 0.8 13.184 37
I6322 0 6322 1.23684e-05
R7588 6322 6323 1.68 0.8 13.44 37
I6323 0 6323 1.29868e-05
R7589 6323 6324 1.648 0.8 13.184 37
I6324 0 6324 1.27395e-05
R7590 6324 6325 1.728 0.8 13.824 37
I6325 0 6325 1.33579e-05
R7591 6325 6326 1.696 0.8 13.568 37
I6326 0 6326 1.23684e-05
R7592 6326 6327 1.664 0.8 13.312 37
I6327 0 6327 1.33579e-05
R7593 6327 6328 1.744 0.8 13.952 37
I6328 0 6328 1.33579e-05
R7594 6328 6329 1.632 0.8 13.056 37
I6329 0 6329 1.31105e-05
R7595 6329 6330 1.616 0.8 12.928 37
I6330 0 6330 1.23684e-05
R7596 6330 0 0.1 49.28 49.28 37
*seg: 634
R7597 0 6331 0.1 49.28 49.28 37
R7598 6335 6345 6.16 0.8 49.28 37
I6331 0 6331 1.29868e-05
R7599 6331 6332 1.664 0.8 13.312 37
I6332 0 6332 1.32342e-05
R7600 6332 6333 1.744 0.8 13.952 37
I6333 0 6333 1.32342e-05
R7601 6333 6334 1.632 0.8 13.056 37
I6334 0 6334 1.23684e-05
R7602 6334 6335 1.68 0.8 13.44 37
I6335 0 6335 1.33579e-05
R7603 6335 6336 1.728 0.8 13.824 37
I6336 0 6336 1.23684e-05
R7604 6336 6337 1.744 0.8 13.952 37
I6337 0 6337 1.23684e-05
R7605 6337 6338 1.744 0.8 13.952 37
I6338 0 6338 1.32342e-05
R7606 6338 6339 1.728 0.8 13.824 37
I6339 0 6339 1.26158e-05
R7607 6339 6340 1.648 0.8 13.184 37
I6340 0 6340 1.23684e-05
R7608 6340 0 0.1 49.28 49.28 37
*seg: 635
R7609 0 6341 0.1 49.28 49.28 37
R7610 6345 6355 6.16 0.8 49.28 37
I6341 0 6341 1.34816e-05
R7611 6341 6342 1.696 0.8 13.568 37
I6342 0 6342 1.31105e-05
R7612 6342 6343 1.616 0.8 12.928 37
I6343 0 6343 1.33579e-05
R7613 6343 6344 1.616 0.8 12.928 37
I6344 0 6344 1.29868e-05
R7614 6344 6345 1.632 0.8 13.056 37
I6345 0 6345 1.27395e-05
R7615 6345 6346 1.6 0.8 12.8 37
I6346 0 6346 1.24921e-05
R7616 6346 6347 1.728 0.8 13.824 37
I6347 0 6347 1.34816e-05
R7617 6347 6348 1.648 0.8 13.184 37
I6348 0 6348 1.23684e-05
R7618 6348 6349 1.664 0.8 13.312 37
I6349 0 6349 1.33579e-05
R7619 6349 6350 1.616 0.8 12.928 37
I6350 0 6350 1.23684e-05
R7620 6350 0 0.1 49.28 49.28 37
*seg: 636
R7621 0 6351 0.1 49.28 49.28 37
R7622 6355 6365 6.16 0.8 49.28 37
I6351 0 6351 1.26158e-05
R7623 6351 6352 1.648 0.8 13.184 37
I6352 0 6352 1.23684e-05
R7624 6352 6353 1.616 0.8 12.928 37
I6353 0 6353 1.32342e-05
R7625 6353 6354 1.744 0.8 13.952 37
I6354 0 6354 1.26158e-05
R7626 6354 6355 1.68 0.8 13.44 37
I6355 0 6355 1.23684e-05
R7627 6355 6356 1.712 0.8 13.696 37
I6356 0 6356 1.24921e-05
R7628 6356 6357 1.744 0.8 13.952 37
I6357 0 6357 1.28631e-05
R7629 6357 6358 1.664 0.8 13.312 37
I6358 0 6358 1.24921e-05
R7630 6358 6359 1.696 0.8 13.568 37
I6359 0 6359 1.31105e-05
R7631 6359 6360 1.6 0.8 12.8 37
I6360 0 6360 1.23684e-05
R7632 6360 0 0.1 49.28 49.28 37
*seg: 637
R7633 0 6361 0.1 49.28 49.28 37
R7634 6365 6375 6.16 0.8 49.28 37
I6361 0 6361 1.28631e-05
R7635 6361 6362 1.68 0.8 13.44 37
I6362 0 6362 1.34816e-05
R7636 6362 6363 1.664 0.8 13.312 37
I6363 0 6363 1.29868e-05
R7637 6363 6364 1.712 0.8 13.696 37
I6364 0 6364 1.27395e-05
R7638 6364 6365 1.664 0.8 13.312 37
I6365 0 6365 1.34816e-05
R7639 6365 6366 1.712 0.8 13.696 37
I6366 0 6366 1.34816e-05
R7640 6366 6367 1.728 0.8 13.824 37
I6367 0 6367 1.34816e-05
R7641 6367 6368 1.728 0.8 13.824 37
I6368 0 6368 1.28631e-05
R7642 6368 6369 1.68 0.8 13.44 37
I6369 0 6369 1.32342e-05
R7643 6369 6370 1.712 0.8 13.696 37
I6370 0 6370 1.23684e-05
R7644 6370 0 0.1 49.28 49.28 37
*seg: 638
R7645 0 6371 0.1 49.28 49.28 37
R7646 6375 6385 6.16 0.8 49.28 37
I6371 0 6371 1.32342e-05
R7647 6371 6372 1.632 0.8 13.056 37
I6372 0 6372 1.32342e-05
R7648 6372 6373 1.712 0.8 13.696 37
I6373 0 6373 1.31105e-05
R7649 6373 6374 1.696 0.8 13.568 37
I6374 0 6374 1.33579e-05
R7650 6374 6375 1.728 0.8 13.824 37
I6375 0 6375 1.27395e-05
R7651 6375 6376 1.696 0.8 13.568 37
I6376 0 6376 1.23684e-05
R7652 6376 6377 1.696 0.8 13.568 37
I6377 0 6377 1.31105e-05
R7653 6377 6378 1.68 0.8 13.44 37
I6378 0 6378 1.27395e-05
R7654 6378 6379 1.68 0.8 13.44 37
I6379 0 6379 1.32342e-05
R7655 6379 6380 1.664 0.8 13.312 37
I6380 0 6380 1.23684e-05
R7656 6380 0 0.1 49.28 49.28 37
*seg: 639
R7657 0 6381 0.1 49.28 49.28 37
R7658 6385 6395 6.16 0.8 49.28 37
I6381 0 6381 1.33579e-05
R7659 6381 6382 1.664 0.8 13.312 37
I6382 0 6382 1.28631e-05
R7660 6382 6383 1.712 0.8 13.696 37
I6383 0 6383 1.28631e-05
R7661 6383 6384 1.648 0.8 13.184 37
I6384 0 6384 1.27395e-05
R7662 6384 6385 1.616 0.8 12.928 37
I6385 0 6385 1.27395e-05
R7663 6385 6386 1.728 0.8 13.824 37
I6386 0 6386 1.32342e-05
R7664 6386 6387 1.6 0.8 12.8 37
I6387 0 6387 1.26158e-05
R7665 6387 6388 1.744 0.8 13.952 37
I6388 0 6388 1.34816e-05
R7666 6388 6389 1.744 0.8 13.952 37
I6389 0 6389 1.23684e-05
R7667 6389 6390 1.696 0.8 13.568 37
I6390 0 6390 1.23684e-05
R7668 6390 0 0.1 49.28 49.28 37
*seg: 640
R7669 0 6391 0.1 49.28 49.28 37
R7670 6395 6405 6.16 0.8 49.28 37
I6391 0 6391 1.26158e-05
R7671 6391 6392 1.744 0.8 13.952 37
I6392 0 6392 1.26158e-05
R7672 6392 6393 1.664 0.8 13.312 37
I6393 0 6393 1.27395e-05
R7673 6393 6394 1.712 0.8 13.696 37
I6394 0 6394 1.32342e-05
R7674 6394 6395 1.712 0.8 13.696 37
I6395 0 6395 1.34816e-05
R7675 6395 6396 1.648 0.8 13.184 37
I6396 0 6396 1.33579e-05
R7676 6396 6397 1.632 0.8 13.056 37
I6397 0 6397 1.32342e-05
R7677 6397 6398 1.616 0.8 12.928 37
I6398 0 6398 1.33579e-05
R7678 6398 6399 1.6 0.8 12.8 37
I6399 0 6399 1.29868e-05
R7679 6399 6400 1.712 0.8 13.696 37
I6400 0 6400 1.23684e-05
R7680 6400 0 0.1 49.28 49.28 37
*seg: 641
R7681 0 6401 0.1 49.28 49.28 37
R7682 6405 6415 6.16 0.8 49.28 37
I6401 0 6401 1.27395e-05
R7683 6401 6402 1.632 0.8 13.056 37
I6402 0 6402 1.31105e-05
R7684 6402 6403 1.744 0.8 13.952 37
I6403 0 6403 1.24921e-05
R7685 6403 6404 1.6 0.8 12.8 37
I6404 0 6404 1.33579e-05
R7686 6404 6405 1.712 0.8 13.696 37
I6405 0 6405 1.34816e-05
R7687 6405 6406 1.6 0.8 12.8 37
I6406 0 6406 1.24921e-05
R7688 6406 6407 1.616 0.8 12.928 37
I6407 0 6407 1.31105e-05
R7689 6407 6408 1.616 0.8 12.928 37
I6408 0 6408 1.29868e-05
R7690 6408 6409 1.6 0.8 12.8 37
I6409 0 6409 1.27395e-05
R7691 6409 6410 1.632 0.8 13.056 37
I6410 0 6410 1.23684e-05
R7692 6410 0 0.1 49.28 49.28 37
*seg: 642
R7693 0 6411 0.1 49.28 49.28 37
R7694 6415 6425 6.16 0.8 49.28 37
I6411 0 6411 1.29868e-05
R7695 6411 6412 1.648 0.8 13.184 37
I6412 0 6412 1.27395e-05
R7696 6412 6413 1.632 0.8 13.056 37
I6413 0 6413 1.27395e-05
R7697 6413 6414 1.728 0.8 13.824 37
I6414 0 6414 1.32342e-05
R7698 6414 6415 1.744 0.8 13.952 37
I6415 0 6415 1.29868e-05
R7699 6415 6416 1.616 0.8 12.928 37
I6416 0 6416 1.23684e-05
R7700 6416 6417 1.616 0.8 12.928 37
I6417 0 6417 1.27395e-05
R7701 6417 6418 1.728 0.8 13.824 37
I6418 0 6418 1.34816e-05
R7702 6418 6419 1.632 0.8 13.056 37
I6419 0 6419 1.29868e-05
R7703 6419 6420 1.632 0.8 13.056 37
I6420 0 6420 1.23684e-05
R7704 6420 0 0.1 49.28 49.28 37
*seg: 643
R7705 0 6421 0.1 49.28 49.28 37
R7706 6425 6435 6.16 0.8 49.28 37
I6421 0 6421 1.32342e-05
R7707 6421 6422 1.696 0.8 13.568 37
I6422 0 6422 1.26158e-05
R7708 6422 6423 1.632 0.8 13.056 37
I6423 0 6423 1.31105e-05
R7709 6423 6424 1.68 0.8 13.44 37
I6424 0 6424 1.32342e-05
R7710 6424 6425 1.664 0.8 13.312 37
I6425 0 6425 1.24921e-05
R7711 6425 6426 1.632 0.8 13.056 37
I6426 0 6426 1.31105e-05
R7712 6426 6427 1.728 0.8 13.824 37
I6427 0 6427 1.29868e-05
R7713 6427 6428 1.712 0.8 13.696 37
I6428 0 6428 1.24921e-05
R7714 6428 6429 1.696 0.8 13.568 37
I6429 0 6429 1.31105e-05
R7715 6429 6430 1.728 0.8 13.824 37
I6430 0 6430 1.23684e-05
R7716 6430 0 0.1 49.28 49.28 37
*seg: 644
R7717 0 6431 0.1 49.28 49.28 37
R7718 6435 6445 6.16 0.8 49.28 37
I6431 0 6431 1.34816e-05
R7719 6431 6432 1.728 0.8 13.824 37
I6432 0 6432 1.26158e-05
R7720 6432 6433 1.632 0.8 13.056 37
I6433 0 6433 1.24921e-05
R7721 6433 6434 1.712 0.8 13.696 37
I6434 0 6434 1.26158e-05
R7722 6434 6435 1.728 0.8 13.824 37
I6435 0 6435 1.33579e-05
R7723 6435 6436 1.6 0.8 12.8 37
I6436 0 6436 1.23684e-05
R7724 6436 6437 1.6 0.8 12.8 37
I6437 0 6437 1.32342e-05
R7725 6437 6438 1.68 0.8 13.44 37
I6438 0 6438 1.27395e-05
R7726 6438 6439 1.744 0.8 13.952 37
I6439 0 6439 1.32342e-05
R7727 6439 6440 1.712 0.8 13.696 37
I6440 0 6440 1.23684e-05
R7728 6440 0 0.1 49.28 49.28 37
*seg: 645
R7729 0 6441 0.1 49.28 49.28 37
R7730 6445 6455 6.16 0.8 49.28 37
I6441 0 6441 1.24921e-05
R7731 6441 6442 1.648 0.8 13.184 37
I6442 0 6442 1.23684e-05
R7732 6442 6443 1.6 0.8 12.8 37
I6443 0 6443 1.34816e-05
R7733 6443 6444 1.68 0.8 13.44 37
I6444 0 6444 1.33579e-05
R7734 6444 6445 1.696 0.8 13.568 37
I6445 0 6445 1.29868e-05
R7735 6445 6446 1.664 0.8 13.312 37
I6446 0 6446 1.33579e-05
R7736 6446 6447 1.712 0.8 13.696 37
I6447 0 6447 1.23684e-05
R7737 6447 6448 1.632 0.8 13.056 37
I6448 0 6448 1.33579e-05
R7738 6448 6449 1.68 0.8 13.44 37
I6449 0 6449 1.29868e-05
R7739 6449 6450 1.664 0.8 13.312 37
I6450 0 6450 1.23684e-05
R7740 6450 0 0.1 49.28 49.28 37
*seg: 646
R7741 0 6451 0.1 49.28 49.28 37
R7742 6455 6465 6.16 0.8 49.28 37
I6451 0 6451 1.33579e-05
R7743 6451 6452 1.6 0.8 12.8 37
I6452 0 6452 1.23684e-05
R7744 6452 6453 1.696 0.8 13.568 37
I6453 0 6453 1.24921e-05
R7745 6453 6454 1.68 0.8 13.44 37
I6454 0 6454 1.31105e-05
R7746 6454 6455 1.728 0.8 13.824 37
I6455 0 6455 1.23684e-05
R7747 6455 6456 1.744 0.8 13.952 37
I6456 0 6456 1.31105e-05
R7748 6456 6457 1.744 0.8 13.952 37
I6457 0 6457 1.28631e-05
R7749 6457 6458 1.728 0.8 13.824 37
I6458 0 6458 1.26158e-05
R7750 6458 6459 1.68 0.8 13.44 37
I6459 0 6459 1.24921e-05
R7751 6459 6460 1.68 0.8 13.44 37
I6460 0 6460 1.23684e-05
R7752 6460 0 0.1 49.28 49.28 37
*seg: 647
R7753 0 6461 0.1 49.28 49.28 37
R7754 6465 6475 6.16 0.8 49.28 37
I6461 0 6461 1.27395e-05
R7755 6461 6462 1.68 0.8 13.44 37
I6462 0 6462 1.24921e-05
R7756 6462 6463 1.648 0.8 13.184 37
I6463 0 6463 1.28631e-05
R7757 6463 6464 1.632 0.8 13.056 37
I6464 0 6464 1.28631e-05
R7758 6464 6465 1.696 0.8 13.568 37
I6465 0 6465 1.33579e-05
R7759 6465 6466 1.744 0.8 13.952 37
I6466 0 6466 1.26158e-05
R7760 6466 6467 1.616 0.8 12.928 37
I6467 0 6467 1.32342e-05
R7761 6467 6468 1.712 0.8 13.696 37
I6468 0 6468 1.26158e-05
R7762 6468 6469 1.6 0.8 12.8 37
I6469 0 6469 1.32342e-05
R7763 6469 6470 1.696 0.8 13.568 37
I6470 0 6470 1.23684e-05
R7764 6470 0 0.1 49.28 49.28 37
*seg: 648
R7765 0 6471 0.1 49.28 49.28 37
R7766 6475 6485 6.16 0.8 49.28 37
I6471 0 6471 1.31105e-05
R7767 6471 6472 1.712 0.8 13.696 37
I6472 0 6472 1.26158e-05
R7768 6472 6473 1.68 0.8 13.44 37
I6473 0 6473 1.34816e-05
R7769 6473 6474 1.696 0.8 13.568 37
I6474 0 6474 1.33579e-05
R7770 6474 6475 1.744 0.8 13.952 37
I6475 0 6475 1.28631e-05
R7771 6475 6476 1.744 0.8 13.952 37
I6476 0 6476 1.31105e-05
R7772 6476 6477 1.6 0.8 12.8 37
I6477 0 6477 1.34816e-05
R7773 6477 6478 1.68 0.8 13.44 37
I6478 0 6478 1.27395e-05
R7774 6478 6479 1.632 0.8 13.056 37
I6479 0 6479 1.33579e-05
R7775 6479 6480 1.696 0.8 13.568 37
I6480 0 6480 1.23684e-05
R7776 6480 0 0.1 49.28 49.28 37
*seg: 649
R7777 0 6481 0.1 49.28 49.28 37
R7778 6485 6495 6.16 0.8 49.28 37
I6481 0 6481 1.24921e-05
R7779 6481 6482 1.664 0.8 13.312 37
I6482 0 6482 1.33579e-05
R7780 6482 6483 1.728 0.8 13.824 37
I6483 0 6483 1.34816e-05
R7781 6483 6484 1.664 0.8 13.312 37
I6484 0 6484 1.33579e-05
R7782 6484 6485 1.632 0.8 13.056 37
I6485 0 6485 1.24921e-05
R7783 6485 6486 1.728 0.8 13.824 37
I6486 0 6486 1.24921e-05
R7784 6486 6487 1.616 0.8 12.928 37
I6487 0 6487 1.29868e-05
R7785 6487 6488 1.68 0.8 13.44 37
I6488 0 6488 1.33579e-05
R7786 6488 6489 1.664 0.8 13.312 37
I6489 0 6489 1.23684e-05
R7787 6489 6490 1.728 0.8 13.824 37
I6490 0 6490 1.23684e-05
R7788 6490 0 0.1 49.28 49.28 37
*seg: 650
R7789 0 6491 0.1 49.28 49.28 37
R7790 6495 6505 6.16 0.8 49.28 37
I6491 0 6491 1.34816e-05
R7791 6491 6492 1.712 0.8 13.696 37
I6492 0 6492 1.34816e-05
R7792 6492 6493 1.696 0.8 13.568 37
I6493 0 6493 1.32342e-05
R7793 6493 6494 1.728 0.8 13.824 37
I6494 0 6494 1.33579e-05
R7794 6494 6495 1.648 0.8 13.184 37
I6495 0 6495 1.28631e-05
R7795 6495 6496 1.696 0.8 13.568 37
I6496 0 6496 1.24921e-05
R7796 6496 6497 1.744 0.8 13.952 37
I6497 0 6497 1.32342e-05
R7797 6497 6498 1.712 0.8 13.696 37
I6498 0 6498 1.23684e-05
R7798 6498 6499 1.696 0.8 13.568 37
I6499 0 6499 1.32342e-05
R7799 6499 6500 1.648 0.8 13.184 37
I6500 0 6500 1.23684e-05
R7800 6500 0 0.1 49.28 49.28 37
*seg: 651
R7801 0 6501 0.1 49.28 49.28 37
R7802 6505 6515 6.16 0.8 49.28 37
I6501 0 6501 1.31105e-05
R7803 6501 6502 1.6 0.8 12.8 37
I6502 0 6502 1.34816e-05
R7804 6502 6503 1.6 0.8 12.8 37
I6503 0 6503 1.34816e-05
R7805 6503 6504 1.712 0.8 13.696 37
I6504 0 6504 1.24921e-05
R7806 6504 6505 1.632 0.8 13.056 37
I6505 0 6505 1.32342e-05
R7807 6505 6506 1.6 0.8 12.8 37
I6506 0 6506 1.28631e-05
R7808 6506 6507 1.664 0.8 13.312 37
I6507 0 6507 1.33579e-05
R7809 6507 6508 1.6 0.8 12.8 37
I6508 0 6508 1.31105e-05
R7810 6508 6509 1.6 0.8 12.8 37
I6509 0 6509 1.33579e-05
R7811 6509 6510 1.712 0.8 13.696 37
I6510 0 6510 1.23684e-05
R7812 6510 0 0.1 49.28 49.28 37
*seg: 652
R7813 0 6511 0.1 49.28 49.28 37
R7814 6515 6525 6.16 0.8 49.28 37
I6511 0 6511 1.23684e-05
R7815 6511 6512 1.616 0.8 12.928 37
I6512 0 6512 1.28631e-05
R7816 6512 6513 1.744 0.8 13.952 37
I6513 0 6513 1.23684e-05
R7817 6513 6514 1.696 0.8 13.568 37
I6514 0 6514 1.28631e-05
R7818 6514 6515 1.744 0.8 13.952 37
I6515 0 6515 1.24921e-05
R7819 6515 6516 1.616 0.8 12.928 37
I6516 0 6516 1.31105e-05
R7820 6516 6517 1.712 0.8 13.696 37
I6517 0 6517 1.24921e-05
R7821 6517 6518 1.728 0.8 13.824 37
I6518 0 6518 1.34816e-05
R7822 6518 6519 1.712 0.8 13.696 37
I6519 0 6519 1.24921e-05
R7823 6519 6520 1.6 0.8 12.8 37
I6520 0 6520 1.23684e-05
R7824 6520 0 0.1 49.28 49.28 37
*seg: 653
R7825 0 6521 0.1 49.28 49.28 37
R7826 6525 6535 6.16 0.8 49.28 37
I6521 0 6521 1.34816e-05
R7827 6521 6522 1.616 0.8 12.928 37
I6522 0 6522 1.27395e-05
R7828 6522 6523 1.632 0.8 13.056 37
I6523 0 6523 1.24921e-05
R7829 6523 6524 1.632 0.8 13.056 37
I6524 0 6524 1.26158e-05
R7830 6524 6525 1.632 0.8 13.056 37
I6525 0 6525 1.28631e-05
R7831 6525 6526 1.696 0.8 13.568 37
I6526 0 6526 1.29868e-05
R7832 6526 6527 1.648 0.8 13.184 37
I6527 0 6527 1.32342e-05
R7833 6527 6528 1.68 0.8 13.44 37
I6528 0 6528 1.27395e-05
R7834 6528 6529 1.744 0.8 13.952 37
I6529 0 6529 1.26158e-05
R7835 6529 6530 1.648 0.8 13.184 37
I6530 0 6530 1.23684e-05
R7836 6530 0 0.1 49.28 49.28 37
*seg: 654
R7837 0 6531 0.1 49.28 49.28 37
R7838 6535 6545 6.16 0.8 49.28 37
I6531 0 6531 1.29868e-05
R7839 6531 6532 1.696 0.8 13.568 37
I6532 0 6532 1.28631e-05
R7840 6532 6533 1.744 0.8 13.952 37
I6533 0 6533 1.34816e-05
R7841 6533 6534 1.696 0.8 13.568 37
I6534 0 6534 1.32342e-05
R7842 6534 6535 1.632 0.8 13.056 37
I6535 0 6535 1.32342e-05
R7843 6535 6536 1.744 0.8 13.952 37
I6536 0 6536 1.28631e-05
R7844 6536 6537 1.696 0.8 13.568 37
I6537 0 6537 1.28631e-05
R7845 6537 6538 1.632 0.8 13.056 37
I6538 0 6538 1.32342e-05
R7846 6538 6539 1.68 0.8 13.44 37
I6539 0 6539 1.31105e-05
R7847 6539 6540 1.712 0.8 13.696 37
I6540 0 6540 1.23684e-05
R7848 6540 0 0.1 49.28 49.28 37
*seg: 655
R7849 0 6541 0.1 49.28 49.28 37
R7850 6545 6555 6.16 0.8 49.28 37
I6541 0 6541 1.34816e-05
R7851 6541 6542 1.712 0.8 13.696 37
I6542 0 6542 1.24921e-05
R7852 6542 6543 1.6 0.8 12.8 37
I6543 0 6543 1.27395e-05
R7853 6543 6544 1.744 0.8 13.952 37
I6544 0 6544 1.23684e-05
R7854 6544 6545 1.6 0.8 12.8 37
I6545 0 6545 1.23684e-05
R7855 6545 6546 1.744 0.8 13.952 37
I6546 0 6546 1.29868e-05
R7856 6546 6547 1.728 0.8 13.824 37
I6547 0 6547 1.33579e-05
R7857 6547 6548 1.68 0.8 13.44 37
I6548 0 6548 1.33579e-05
R7858 6548 6549 1.664 0.8 13.312 37
I6549 0 6549 1.29868e-05
R7859 6549 6550 1.664 0.8 13.312 37
I6550 0 6550 1.23684e-05
R7860 6550 0 0.1 49.28 49.28 37
*seg: 656
R7861 0 6551 0.1 49.28 49.28 37
R7862 6555 6565 6.16 0.8 49.28 37
I6551 0 6551 1.27395e-05
R7863 6551 6552 1.744 0.8 13.952 37
I6552 0 6552 1.27395e-05
R7864 6552 6553 1.664 0.8 13.312 37
I6553 0 6553 1.23684e-05
R7865 6553 6554 1.728 0.8 13.824 37
I6554 0 6554 1.34816e-05
R7866 6554 6555 1.632 0.8 13.056 37
I6555 0 6555 1.32342e-05
R7867 6555 6556 1.6 0.8 12.8 37
I6556 0 6556 1.24921e-05
R7868 6556 6557 1.632 0.8 13.056 37
I6557 0 6557 1.24921e-05
R7869 6557 6558 1.6 0.8 12.8 37
I6558 0 6558 1.31105e-05
R7870 6558 6559 1.664 0.8 13.312 37
I6559 0 6559 1.27395e-05
R7871 6559 6560 1.712 0.8 13.696 37
I6560 0 6560 1.23684e-05
R7872 6560 0 0.1 49.28 49.28 37
*seg: 657
R7873 0 6561 0.1 49.28 49.28 37
R7874 6565 6575 6.16 0.8 49.28 37
I6561 0 6561 1.26158e-05
R7875 6561 6562 1.632 0.8 13.056 37
I6562 0 6562 1.31105e-05
R7876 6562 6563 1.648 0.8 13.184 37
I6563 0 6563 1.28631e-05
R7877 6563 6564 1.664 0.8 13.312 37
I6564 0 6564 1.32342e-05
R7878 6564 6565 1.6 0.8 12.8 37
I6565 0 6565 1.24921e-05
R7879 6565 6566 1.696 0.8 13.568 37
I6566 0 6566 1.33579e-05
R7880 6566 6567 1.616 0.8 12.928 37
I6567 0 6567 1.26158e-05
R7881 6567 6568 1.616 0.8 12.928 37
I6568 0 6568 1.23684e-05
R7882 6568 6569 1.696 0.8 13.568 37
I6569 0 6569 1.29868e-05
R7883 6569 6570 1.696 0.8 13.568 37
I6570 0 6570 1.23684e-05
R7884 6570 0 0.1 49.28 49.28 37
*seg: 658
R7885 0 6571 0.1 49.28 49.28 37
R7886 6575 6585 6.16 0.8 49.28 37
I6571 0 6571 1.32342e-05
R7887 6571 6572 1.696 0.8 13.568 37
I6572 0 6572 1.26158e-05
R7888 6572 6573 1.632 0.8 13.056 37
I6573 0 6573 1.34816e-05
R7889 6573 6574 1.632 0.8 13.056 37
I6574 0 6574 1.26158e-05
R7890 6574 6575 1.712 0.8 13.696 37
I6575 0 6575 1.31105e-05
R7891 6575 6576 1.616 0.8 12.928 37
I6576 0 6576 1.23684e-05
R7892 6576 6577 1.696 0.8 13.568 37
I6577 0 6577 1.29868e-05
R7893 6577 6578 1.664 0.8 13.312 37
I6578 0 6578 1.27395e-05
R7894 6578 6579 1.712 0.8 13.696 37
I6579 0 6579 1.33579e-05
R7895 6579 6580 1.6 0.8 12.8 37
I6580 0 6580 1.23684e-05
R7896 6580 0 0.1 49.28 49.28 37
*seg: 659
R7897 0 6581 0.1 49.28 49.28 37
R7898 6585 6595 6.16 0.8 49.28 37
I6581 0 6581 1.34816e-05
R7899 6581 6582 1.664 0.8 13.312 37
I6582 0 6582 1.27395e-05
R7900 6582 6583 1.712 0.8 13.696 37
I6583 0 6583 1.28631e-05
R7901 6583 6584 1.648 0.8 13.184 37
I6584 0 6584 1.28631e-05
R7902 6584 6585 1.712 0.8 13.696 37
I6585 0 6585 1.28631e-05
R7903 6585 6586 1.68 0.8 13.44 37
I6586 0 6586 1.26158e-05
R7904 6586 6587 1.728 0.8 13.824 37
I6587 0 6587 1.34816e-05
R7905 6587 6588 1.616 0.8 12.928 37
I6588 0 6588 1.33579e-05
R7906 6588 6589 1.616 0.8 12.928 37
I6589 0 6589 1.27395e-05
R7907 6589 6590 1.648 0.8 13.184 37
I6590 0 6590 1.23684e-05
R7908 6590 0 0.1 49.28 49.28 37
*seg: 660
R7909 0 6591 0.1 49.28 49.28 37
R7910 6595 6605 6.16 0.8 49.28 37
I6591 0 6591 1.29868e-05
R7911 6591 6592 1.632 0.8 13.056 37
I6592 0 6592 1.32342e-05
R7912 6592 6593 1.664 0.8 13.312 37
I6593 0 6593 1.24921e-05
R7913 6593 6594 1.632 0.8 13.056 37
I6594 0 6594 1.26158e-05
R7914 6594 6595 1.696 0.8 13.568 37
I6595 0 6595 1.33579e-05
R7915 6595 6596 1.68 0.8 13.44 37
I6596 0 6596 1.23684e-05
R7916 6596 6597 1.744 0.8 13.952 37
I6597 0 6597 1.33579e-05
R7917 6597 6598 1.728 0.8 13.824 37
I6598 0 6598 1.28631e-05
R7918 6598 6599 1.6 0.8 12.8 37
I6599 0 6599 1.28631e-05
R7919 6599 6600 1.616 0.8 12.928 37
I6600 0 6600 1.23684e-05
R7920 6600 0 0.1 49.28 49.28 37
*seg: 661
R7921 0 6601 0.1 49.28 49.28 37
R7922 6605 6615 6.16 0.8 49.28 37
I6601 0 6601 1.32342e-05
R7923 6601 6602 1.712 0.8 13.696 37
I6602 0 6602 1.24921e-05
R7924 6602 6603 1.744 0.8 13.952 37
I6603 0 6603 1.34816e-05
R7925 6603 6604 1.664 0.8 13.312 37
I6604 0 6604 1.28631e-05
R7926 6604 6605 1.632 0.8 13.056 37
I6605 0 6605 1.34816e-05
R7927 6605 6606 1.664 0.8 13.312 37
I6606 0 6606 1.29868e-05
R7928 6606 6607 1.632 0.8 13.056 37
I6607 0 6607 1.26158e-05
R7929 6607 6608 1.728 0.8 13.824 37
I6608 0 6608 1.31105e-05
R7930 6608 6609 1.664 0.8 13.312 37
I6609 0 6609 1.31105e-05
R7931 6609 6610 1.728 0.8 13.824 37
I6610 0 6610 1.23684e-05
R7932 6610 0 0.1 49.28 49.28 37
*seg: 662
R7933 0 6611 0.1 49.28 49.28 37
R7934 6615 6625 6.16 0.8 49.28 37
I6611 0 6611 1.29868e-05
R7935 6611 6612 1.744 0.8 13.952 37
I6612 0 6612 1.31105e-05
R7936 6612 6613 1.68 0.8 13.44 37
I6613 0 6613 1.34816e-05
R7937 6613 6614 1.6 0.8 12.8 37
I6614 0 6614 1.29868e-05
R7938 6614 6615 1.744 0.8 13.952 37
I6615 0 6615 1.27395e-05
R7939 6615 6616 1.648 0.8 13.184 37
I6616 0 6616 1.24921e-05
R7940 6616 6617 1.68 0.8 13.44 37
I6617 0 6617 1.29868e-05
R7941 6617 6618 1.632 0.8 13.056 37
I6618 0 6618 1.33579e-05
R7942 6618 6619 1.616 0.8 12.928 37
I6619 0 6619 1.34816e-05
R7943 6619 6620 1.68 0.8 13.44 37
I6620 0 6620 1.23684e-05
R7944 6620 0 0.1 49.28 49.28 37
*seg: 663
R7945 0 6621 0.1 49.28 49.28 37
R7946 6625 6635 6.16 0.8 49.28 37
I6621 0 6621 1.27395e-05
R7947 6621 6622 1.68 0.8 13.44 37
I6622 0 6622 1.34816e-05
R7948 6622 6623 1.664 0.8 13.312 37
I6623 0 6623 1.29868e-05
R7949 6623 6624 1.696 0.8 13.568 37
I6624 0 6624 1.29868e-05
R7950 6624 6625 1.712 0.8 13.696 37
I6625 0 6625 1.32342e-05
R7951 6625 6626 1.696 0.8 13.568 37
I6626 0 6626 1.33579e-05
R7952 6626 6627 1.632 0.8 13.056 37
I6627 0 6627 1.32342e-05
R7953 6627 6628 1.648 0.8 13.184 37
I6628 0 6628 1.29868e-05
R7954 6628 6629 1.632 0.8 13.056 37
I6629 0 6629 1.28631e-05
R7955 6629 6630 1.696 0.8 13.568 37
I6630 0 6630 1.23684e-05
R7956 6630 0 0.1 49.28 49.28 37
*seg: 664
R7957 0 6631 0.1 49.28 49.28 37
R7958 6635 6645 6.16 0.8 49.28 37
I6631 0 6631 1.23684e-05
R7959 6631 6632 1.632 0.8 13.056 37
I6632 0 6632 1.32342e-05
R7960 6632 6633 1.696 0.8 13.568 37
I6633 0 6633 1.24921e-05
R7961 6633 6634 1.728 0.8 13.824 37
I6634 0 6634 1.33579e-05
R7962 6634 6635 1.728 0.8 13.824 37
I6635 0 6635 1.28631e-05
R7963 6635 6636 1.6 0.8 12.8 37
I6636 0 6636 1.27395e-05
R7964 6636 6637 1.6 0.8 12.8 37
I6637 0 6637 1.28631e-05
R7965 6637 6638 1.664 0.8 13.312 37
I6638 0 6638 1.31105e-05
R7966 6638 6639 1.632 0.8 13.056 37
I6639 0 6639 1.24921e-05
R7967 6639 6640 1.616 0.8 12.928 37
I6640 0 6640 1.23684e-05
R7968 6640 0 0.1 49.28 49.28 37
*seg: 665
R7969 0 6641 0.1 49.28 49.28 37
R7970 6645 6655 6.16 0.8 49.28 37
I6641 0 6641 1.33579e-05
R7971 6641 6642 1.632 0.8 13.056 37
I6642 0 6642 1.29868e-05
R7972 6642 6643 1.744 0.8 13.952 37
I6643 0 6643 1.23684e-05
R7973 6643 6644 1.712 0.8 13.696 37
I6644 0 6644 1.32342e-05
R7974 6644 6645 1.712 0.8 13.696 37
I6645 0 6645 1.29868e-05
R7975 6645 6646 1.68 0.8 13.44 37
I6646 0 6646 1.31105e-05
R7976 6646 6647 1.744 0.8 13.952 37
I6647 0 6647 1.32342e-05
R7977 6647 6648 1.632 0.8 13.056 37
I6648 0 6648 1.32342e-05
R7978 6648 6649 1.6 0.8 12.8 37
I6649 0 6649 1.29868e-05
R7979 6649 6650 1.712 0.8 13.696 37
I6650 0 6650 1.23684e-05
R7980 6650 0 0.1 49.28 49.28 37
*seg: 666
R7981 0 6651 0.1 49.28 49.28 37
R7982 6655 6665 6.16 0.8 49.28 37
I6651 0 6651 1.34816e-05
R7983 6651 6652 1.6 0.8 12.8 37
I6652 0 6652 1.26158e-05
R7984 6652 6653 1.632 0.8 13.056 37
I6653 0 6653 1.34816e-05
R7985 6653 6654 1.632 0.8 13.056 37
I6654 0 6654 1.27395e-05
R7986 6654 6655 1.68 0.8 13.44 37
I6655 0 6655 1.28631e-05
R7987 6655 6656 1.728 0.8 13.824 37
I6656 0 6656 1.24921e-05
R7988 6656 6657 1.68 0.8 13.44 37
I6657 0 6657 1.29868e-05
R7989 6657 6658 1.744 0.8 13.952 37
I6658 0 6658 1.27395e-05
R7990 6658 6659 1.728 0.8 13.824 37
I6659 0 6659 1.24921e-05
R7991 6659 6660 1.6 0.8 12.8 37
I6660 0 6660 1.23684e-05
R7992 6660 0 0.1 49.28 49.28 37
*seg: 667
R7993 0 6661 0.1 49.28 49.28 37
R7994 6665 6675 6.16 0.8 49.28 37
I6661 0 6661 1.26158e-05
R7995 6661 6662 1.632 0.8 13.056 37
I6662 0 6662 1.26158e-05
R7996 6662 6663 1.696 0.8 13.568 37
I6663 0 6663 1.31105e-05
R7997 6663 6664 1.616 0.8 12.928 37
I6664 0 6664 1.28631e-05
R7998 6664 6665 1.632 0.8 13.056 37
I6665 0 6665 1.27395e-05
R7999 6665 6666 1.68 0.8 13.44 37
I6666 0 6666 1.31105e-05
R8000 6666 6667 1.696 0.8 13.568 37
I6667 0 6667 1.23684e-05
R8001 6667 6668 1.744 0.8 13.952 37
I6668 0 6668 1.31105e-05
R8002 6668 6669 1.712 0.8 13.696 37
I6669 0 6669 1.24921e-05
R8003 6669 6670 1.6 0.8 12.8 37
I6670 0 6670 1.23684e-05
R8004 6670 0 0.1 49.28 49.28 37
*seg: 668
R8005 0 6671 0.1 49.28 49.28 37
R8006 6675 6685 6.16 0.8 49.28 37
I6671 0 6671 1.31105e-05
R8007 6671 6672 1.632 0.8 13.056 37
I6672 0 6672 1.23684e-05
R8008 6672 6673 1.728 0.8 13.824 37
I6673 0 6673 1.27395e-05
R8009 6673 6674 1.728 0.8 13.824 37
I6674 0 6674 1.23684e-05
R8010 6674 6675 1.744 0.8 13.952 37
I6675 0 6675 1.23684e-05
R8011 6675 6676 1.728 0.8 13.824 37
I6676 0 6676 1.23684e-05
R8012 6676 6677 1.648 0.8 13.184 37
I6677 0 6677 1.26158e-05
R8013 6677 6678 1.6 0.8 12.8 37
I6678 0 6678 1.26158e-05
R8014 6678 6679 1.664 0.8 13.312 37
I6679 0 6679 1.33579e-05
R8015 6679 6680 1.712 0.8 13.696 37
I6680 0 6680 1.23684e-05
R8016 6680 0 0.1 49.28 49.28 37
*seg: 669
R8017 0 6681 0.1 49.28 49.28 37
R8018 6685 6695 6.16 0.8 49.28 37
I6681 0 6681 1.28631e-05
R8019 6681 6682 1.6 0.8 12.8 37
I6682 0 6682 1.32342e-05
R8020 6682 6683 1.632 0.8 13.056 37
I6683 0 6683 1.26158e-05
R8021 6683 6684 1.728 0.8 13.824 37
I6684 0 6684 1.34816e-05
R8022 6684 6685 1.744 0.8 13.952 37
I6685 0 6685 1.34816e-05
R8023 6685 6686 1.744 0.8 13.952 37
I6686 0 6686 1.33579e-05
R8024 6686 6687 1.712 0.8 13.696 37
I6687 0 6687 1.34816e-05
R8025 6687 6688 1.616 0.8 12.928 37
I6688 0 6688 1.24921e-05
R8026 6688 6689 1.648 0.8 13.184 37
I6689 0 6689 1.33579e-05
R8027 6689 6690 1.696 0.8 13.568 37
I6690 0 6690 1.23684e-05
R8028 6690 0 0.1 49.28 49.28 37
*seg: 670
R8029 0 6691 0.1 49.28 49.28 37
R8030 6695 6705 6.16 0.8 49.28 37
I6691 0 6691 1.31105e-05
R8031 6691 6692 1.696 0.8 13.568 37
I6692 0 6692 1.34816e-05
R8032 6692 6693 1.744 0.8 13.952 37
I6693 0 6693 1.23684e-05
R8033 6693 6694 1.68 0.8 13.44 37
I6694 0 6694 1.24921e-05
R8034 6694 6695 1.632 0.8 13.056 37
I6695 0 6695 1.24921e-05
R8035 6695 6696 1.68 0.8 13.44 37
I6696 0 6696 1.32342e-05
R8036 6696 6697 1.664 0.8 13.312 37
I6697 0 6697 1.27395e-05
R8037 6697 6698 1.744 0.8 13.952 37
I6698 0 6698 1.23684e-05
R8038 6698 6699 1.664 0.8 13.312 37
I6699 0 6699 1.34816e-05
R8039 6699 6700 1.68 0.8 13.44 37
I6700 0 6700 1.23684e-05
R8040 6700 0 0.1 49.28 49.28 37
*seg: 671
R8041 0 6701 0.1 49.28 49.28 37
R8042 6705 6715 6.16 0.8 49.28 37
I6701 0 6701 1.33579e-05
R8043 6701 6702 1.68 0.8 13.44 37
I6702 0 6702 1.23684e-05
R8044 6702 6703 1.648 0.8 13.184 37
I6703 0 6703 1.27395e-05
R8045 6703 6704 1.68 0.8 13.44 37
I6704 0 6704 1.31105e-05
R8046 6704 6705 1.728 0.8 13.824 37
I6705 0 6705 1.34816e-05
R8047 6705 6706 1.744 0.8 13.952 37
I6706 0 6706 1.23684e-05
R8048 6706 6707 1.632 0.8 13.056 37
I6707 0 6707 1.31105e-05
R8049 6707 6708 1.632 0.8 13.056 37
I6708 0 6708 1.31105e-05
R8050 6708 6709 1.648 0.8 13.184 37
I6709 0 6709 1.34816e-05
R8051 6709 6710 1.712 0.8 13.696 37
I6710 0 6710 1.23684e-05
R8052 6710 0 0.1 49.28 49.28 37
*seg: 672
R8053 0 6711 0.1 49.28 49.28 37
R8054 6715 6725 6.16 0.8 49.28 37
I6711 0 6711 1.33579e-05
R8055 6711 6712 1.696 0.8 13.568 37
I6712 0 6712 1.27395e-05
R8056 6712 6713 1.696 0.8 13.568 37
I6713 0 6713 1.28631e-05
R8057 6713 6714 1.616 0.8 12.928 37
I6714 0 6714 1.29868e-05
R8058 6714 6715 1.616 0.8 12.928 37
I6715 0 6715 1.33579e-05
R8059 6715 6716 1.664 0.8 13.312 37
I6716 0 6716 1.23684e-05
R8060 6716 6717 1.68 0.8 13.44 37
I6717 0 6717 1.26158e-05
R8061 6717 6718 1.6 0.8 12.8 37
I6718 0 6718 1.28631e-05
R8062 6718 6719 1.696 0.8 13.568 37
I6719 0 6719 1.31105e-05
R8063 6719 6720 1.632 0.8 13.056 37
I6720 0 6720 1.23684e-05
R8064 6720 0 0.1 49.28 49.28 37
*seg: 673
R8065 0 6721 0.1 49.28 49.28 37
R8066 6725 6735 6.16 0.8 49.28 37
I6721 0 6721 1.27395e-05
R8067 6721 6722 1.632 0.8 13.056 37
I6722 0 6722 1.34816e-05
R8068 6722 6723 1.632 0.8 13.056 37
I6723 0 6723 1.29868e-05
R8069 6723 6724 1.712 0.8 13.696 37
I6724 0 6724 1.34816e-05
R8070 6724 6725 1.744 0.8 13.952 37
I6725 0 6725 1.34816e-05
R8071 6725 6726 1.712 0.8 13.696 37
I6726 0 6726 1.32342e-05
R8072 6726 6727 1.744 0.8 13.952 37
I6727 0 6727 1.31105e-05
R8073 6727 6728 1.712 0.8 13.696 37
I6728 0 6728 1.29868e-05
R8074 6728 6729 1.712 0.8 13.696 37
I6729 0 6729 1.33579e-05
R8075 6729 6730 1.6 0.8 12.8 37
I6730 0 6730 1.23684e-05
R8076 6730 0 0.1 49.28 49.28 37
*seg: 674
R8077 0 6731 0.1 49.28 49.28 37
R8078 6735 6745 6.16 0.8 49.28 37
I6731 0 6731 1.26158e-05
R8079 6731 6732 1.616 0.8 12.928 37
I6732 0 6732 1.26158e-05
R8080 6732 6733 1.6 0.8 12.8 37
I6733 0 6733 1.28631e-05
R8081 6733 6734 1.632 0.8 13.056 37
I6734 0 6734 1.27395e-05
R8082 6734 6735 1.728 0.8 13.824 37
I6735 0 6735 1.31105e-05
R8083 6735 6736 1.696 0.8 13.568 37
I6736 0 6736 1.34816e-05
R8084 6736 6737 1.696 0.8 13.568 37
I6737 0 6737 1.31105e-05
R8085 6737 6738 1.6 0.8 12.8 37
I6738 0 6738 1.23684e-05
R8086 6738 6739 1.6 0.8 12.8 37
I6739 0 6739 1.24921e-05
R8087 6739 6740 1.728 0.8 13.824 37
I6740 0 6740 1.23684e-05
R8088 6740 0 0.1 49.28 49.28 37
*seg: 675
R8089 0 6741 0.1 49.28 49.28 37
R8090 6745 6755 6.16 0.8 49.28 37
I6741 0 6741 1.34816e-05
R8091 6741 6742 1.696 0.8 13.568 37
I6742 0 6742 1.28631e-05
R8092 6742 6743 1.664 0.8 13.312 37
I6743 0 6743 1.34816e-05
R8093 6743 6744 1.6 0.8 12.8 37
I6744 0 6744 1.28631e-05
R8094 6744 6745 1.632 0.8 13.056 37
I6745 0 6745 1.34816e-05
R8095 6745 6746 1.696 0.8 13.568 37
I6746 0 6746 1.27395e-05
R8096 6746 6747 1.664 0.8 13.312 37
I6747 0 6747 1.26158e-05
R8097 6747 6748 1.6 0.8 12.8 37
I6748 0 6748 1.28631e-05
R8098 6748 6749 1.648 0.8 13.184 37
I6749 0 6749 1.34816e-05
R8099 6749 6750 1.6 0.8 12.8 37
I6750 0 6750 1.23684e-05
R8100 6750 0 0.1 49.28 49.28 37
*seg: 676
R8101 0 6751 0.1 49.28 49.28 37
R8102 6755 6765 6.16 0.8 49.28 37
I6751 0 6751 1.27395e-05
R8103 6751 6752 1.616 0.8 12.928 37
I6752 0 6752 1.27395e-05
R8104 6752 6753 1.616 0.8 12.928 37
I6753 0 6753 1.28631e-05
R8105 6753 6754 1.664 0.8 13.312 37
I6754 0 6754 1.34816e-05
R8106 6754 6755 1.728 0.8 13.824 37
I6755 0 6755 1.27395e-05
R8107 6755 6756 1.616 0.8 12.928 37
I6756 0 6756 1.27395e-05
R8108 6756 6757 1.712 0.8 13.696 37
I6757 0 6757 1.27395e-05
R8109 6757 6758 1.632 0.8 13.056 37
I6758 0 6758 1.23684e-05
R8110 6758 6759 1.712 0.8 13.696 37
I6759 0 6759 1.32342e-05
R8111 6759 6760 1.712 0.8 13.696 37
I6760 0 6760 1.23684e-05
R8112 6760 0 0.1 49.28 49.28 37
*seg: 677
R8113 0 6761 0.1 49.28 49.28 37
R8114 6765 6775 6.16 0.8 49.28 37
I6761 0 6761 1.23684e-05
R8115 6761 6762 1.6 0.8 12.8 37
I6762 0 6762 1.23684e-05
R8116 6762 6763 1.664 0.8 13.312 37
I6763 0 6763 1.31105e-05
R8117 6763 6764 1.632 0.8 13.056 37
I6764 0 6764 1.28631e-05
R8118 6764 6765 1.744 0.8 13.952 37
I6765 0 6765 1.33579e-05
R8119 6765 6766 1.712 0.8 13.696 37
I6766 0 6766 1.31105e-05
R8120 6766 6767 1.696 0.8 13.568 37
I6767 0 6767 1.32342e-05
R8121 6767 6768 1.616 0.8 12.928 37
I6768 0 6768 1.23684e-05
R8122 6768 6769 1.712 0.8 13.696 37
I6769 0 6769 1.31105e-05
R8123 6769 6770 1.712 0.8 13.696 37
I6770 0 6770 1.23684e-05
R8124 6770 0 0.1 49.28 49.28 37
*seg: 678
R8125 0 6771 0.1 49.28 49.28 37
R8126 6775 6785 6.16 0.8 49.28 37
I6771 0 6771 1.29868e-05
R8127 6771 6772 1.68 0.8 13.44 37
I6772 0 6772 1.28631e-05
R8128 6772 6773 1.696 0.8 13.568 37
I6773 0 6773 1.29868e-05
R8129 6773 6774 1.68 0.8 13.44 37
I6774 0 6774 1.23684e-05
R8130 6774 6775 1.632 0.8 13.056 37
I6775 0 6775 1.28631e-05
R8131 6775 6776 1.632 0.8 13.056 37
I6776 0 6776 1.27395e-05
R8132 6776 6777 1.712 0.8 13.696 37
I6777 0 6777 1.28631e-05
R8133 6777 6778 1.6 0.8 12.8 37
I6778 0 6778 1.32342e-05
R8134 6778 6779 1.632 0.8 13.056 37
I6779 0 6779 1.34816e-05
R8135 6779 6780 1.68 0.8 13.44 37
I6780 0 6780 1.23684e-05
R8136 6780 0 0.1 49.28 49.28 37
*seg: 679
R8137 0 6781 0.1 49.28 49.28 37
R8138 6785 6795 6.16 0.8 49.28 37
I6781 0 6781 1.24921e-05
R8139 6781 6782 1.664 0.8 13.312 37
I6782 0 6782 1.32342e-05
R8140 6782 6783 1.68 0.8 13.44 37
I6783 0 6783 1.31105e-05
R8141 6783 6784 1.744 0.8 13.952 37
I6784 0 6784 1.34816e-05
R8142 6784 6785 1.696 0.8 13.568 37
I6785 0 6785 1.34816e-05
R8143 6785 6786 1.728 0.8 13.824 37
I6786 0 6786 1.26158e-05
R8144 6786 6787 1.744 0.8 13.952 37
I6787 0 6787 1.29868e-05
R8145 6787 6788 1.664 0.8 13.312 37
I6788 0 6788 1.23684e-05
R8146 6788 6789 1.648 0.8 13.184 37
I6789 0 6789 1.24921e-05
R8147 6789 6790 1.632 0.8 13.056 37
I6790 0 6790 1.23684e-05
R8148 6790 0 0.1 49.28 49.28 37
*seg: 680
R8149 0 6791 0.1 49.28 49.28 37
R8150 6795 6805 6.16 0.8 49.28 37
I6791 0 6791 1.23684e-05
R8151 6791 6792 1.68 0.8 13.44 37
I6792 0 6792 1.32342e-05
R8152 6792 6793 1.696 0.8 13.568 37
I6793 0 6793 1.28631e-05
R8153 6793 6794 1.696 0.8 13.568 37
I6794 0 6794 1.33579e-05
R8154 6794 6795 1.68 0.8 13.44 37
I6795 0 6795 1.27395e-05
R8155 6795 6796 1.664 0.8 13.312 37
I6796 0 6796 1.31105e-05
R8156 6796 6797 1.68 0.8 13.44 37
I6797 0 6797 1.26158e-05
R8157 6797 6798 1.632 0.8 13.056 37
I6798 0 6798 1.29868e-05
R8158 6798 6799 1.68 0.8 13.44 37
I6799 0 6799 1.27395e-05
R8159 6799 6800 1.728 0.8 13.824 37
I6800 0 6800 1.23684e-05
R8160 6800 0 0.1 49.28 49.28 37
*seg: 681
R8161 0 6801 0.1 49.28 49.28 37
R8162 6805 6815 6.16 0.8 49.28 37
I6801 0 6801 1.33579e-05
R8163 6801 6802 1.616 0.8 12.928 37
I6802 0 6802 1.31105e-05
R8164 6802 6803 1.632 0.8 13.056 37
I6803 0 6803 1.34816e-05
R8165 6803 6804 1.616 0.8 12.928 37
I6804 0 6804 1.24921e-05
R8166 6804 6805 1.616 0.8 12.928 37
I6805 0 6805 1.33579e-05
R8167 6805 6806 1.696 0.8 13.568 37
I6806 0 6806 1.34816e-05
R8168 6806 6807 1.744 0.8 13.952 37
I6807 0 6807 1.26158e-05
R8169 6807 6808 1.616 0.8 12.928 37
I6808 0 6808 1.34816e-05
R8170 6808 6809 1.616 0.8 12.928 37
I6809 0 6809 1.26158e-05
R8171 6809 6810 1.68 0.8 13.44 37
I6810 0 6810 1.23684e-05
R8172 6810 0 0.1 49.28 49.28 37
*seg: 682
R8173 0 6811 0.1 49.28 49.28 37
R8174 6815 6825 6.16 0.8 49.28 37
I6811 0 6811 1.31105e-05
R8175 6811 6812 1.696 0.8 13.568 37
I6812 0 6812 1.32342e-05
R8176 6812 6813 1.6 0.8 12.8 37
I6813 0 6813 1.28631e-05
R8177 6813 6814 1.68 0.8 13.44 37
I6814 0 6814 1.32342e-05
R8178 6814 6815 1.696 0.8 13.568 37
I6815 0 6815 1.27395e-05
R8179 6815 6816 1.728 0.8 13.824 37
I6816 0 6816 1.33579e-05
R8180 6816 6817 1.6 0.8 12.8 37
I6817 0 6817 1.24921e-05
R8181 6817 6818 1.712 0.8 13.696 37
I6818 0 6818 1.27395e-05
R8182 6818 6819 1.616 0.8 12.928 37
I6819 0 6819 1.24921e-05
R8183 6819 6820 1.696 0.8 13.568 37
I6820 0 6820 1.23684e-05
R8184 6820 0 0.1 49.28 49.28 37
*seg: 683
R8185 0 6821 0.1 49.28 49.28 37
R8186 6825 6835 6.16 0.8 49.28 37
I6821 0 6821 1.27395e-05
R8187 6821 6822 1.648 0.8 13.184 37
I6822 0 6822 1.24921e-05
R8188 6822 6823 1.632 0.8 13.056 37
I6823 0 6823 1.34816e-05
R8189 6823 6824 1.6 0.8 12.8 37
I6824 0 6824 1.24921e-05
R8190 6824 6825 1.632 0.8 13.056 37
I6825 0 6825 1.32342e-05
R8191 6825 6826 1.68 0.8 13.44 37
I6826 0 6826 1.34816e-05
R8192 6826 6827 1.664 0.8 13.312 37
I6827 0 6827 1.33579e-05
R8193 6827 6828 1.648 0.8 13.184 37
I6828 0 6828 1.33579e-05
R8194 6828 6829 1.6 0.8 12.8 37
I6829 0 6829 1.28631e-05
R8195 6829 6830 1.68 0.8 13.44 37
I6830 0 6830 1.23684e-05
R8196 6830 0 0.1 49.28 49.28 37
*seg: 684
R8197 0 6831 0.1 49.28 49.28 37
R8198 6835 6845 6.16 0.8 49.28 37
I6831 0 6831 1.26158e-05
R8199 6831 6832 1.68 0.8 13.44 37
I6832 0 6832 1.26158e-05
R8200 6832 6833 1.616 0.8 12.928 37
I6833 0 6833 1.24921e-05
R8201 6833 6834 1.648 0.8 13.184 37
I6834 0 6834 1.32342e-05
R8202 6834 6835 1.6 0.8 12.8 37
I6835 0 6835 1.28631e-05
R8203 6835 6836 1.696 0.8 13.568 37
I6836 0 6836 1.32342e-05
R8204 6836 6837 1.632 0.8 13.056 37
I6837 0 6837 1.31105e-05
R8205 6837 6838 1.728 0.8 13.824 37
I6838 0 6838 1.24921e-05
R8206 6838 6839 1.664 0.8 13.312 37
I6839 0 6839 1.29868e-05
R8207 6839 6840 1.712 0.8 13.696 37
I6840 0 6840 1.23684e-05
R8208 6840 0 0.1 49.28 49.28 37
*seg: 685
R8209 0 6841 0.1 49.28 49.28 37
R8210 6845 6855 6.16 0.8 49.28 37
I6841 0 6841 1.24921e-05
R8211 6841 6842 1.744 0.8 13.952 37
I6842 0 6842 1.33579e-05
R8212 6842 6843 1.6 0.8 12.8 37
I6843 0 6843 1.27395e-05
R8213 6843 6844 1.712 0.8 13.696 37
I6844 0 6844 1.29868e-05
R8214 6844 6845 1.616 0.8 12.928 37
I6845 0 6845 1.23684e-05
R8215 6845 6846 1.712 0.8 13.696 37
I6846 0 6846 1.34816e-05
R8216 6846 6847 1.632 0.8 13.056 37
I6847 0 6847 1.32342e-05
R8217 6847 6848 1.648 0.8 13.184 37
I6848 0 6848 1.23684e-05
R8218 6848 6849 1.616 0.8 12.928 37
I6849 0 6849 1.33579e-05
R8219 6849 6850 1.744 0.8 13.952 37
I6850 0 6850 1.23684e-05
R8220 6850 0 0.1 49.28 49.28 37
*seg: 686
R8221 0 6851 0.1 49.28 49.28 37
R8222 6855 6865 6.16 0.8 49.28 37
I6851 0 6851 1.27395e-05
R8223 6851 6852 1.728 0.8 13.824 37
I6852 0 6852 1.26158e-05
R8224 6852 6853 1.696 0.8 13.568 37
I6853 0 6853 1.26158e-05
R8225 6853 6854 1.664 0.8 13.312 37
I6854 0 6854 1.33579e-05
R8226 6854 6855 1.712 0.8 13.696 37
I6855 0 6855 1.23684e-05
R8227 6855 6856 1.616 0.8 12.928 37
I6856 0 6856 1.32342e-05
R8228 6856 6857 1.744 0.8 13.952 37
I6857 0 6857 1.33579e-05
R8229 6857 6858 1.664 0.8 13.312 37
I6858 0 6858 1.28631e-05
R8230 6858 6859 1.68 0.8 13.44 37
I6859 0 6859 1.32342e-05
R8231 6859 6860 1.696 0.8 13.568 37
I6860 0 6860 1.23684e-05
R8232 6860 0 0.1 49.28 49.28 37
*seg: 687
R8233 0 6861 0.1 49.28 49.28 37
R8234 6865 6875 6.16 0.8 49.28 37
I6861 0 6861 1.28631e-05
R8235 6861 6862 1.68 0.8 13.44 37
I6862 0 6862 1.26158e-05
R8236 6862 6863 1.664 0.8 13.312 37
I6863 0 6863 1.33579e-05
R8237 6863 6864 1.616 0.8 12.928 37
I6864 0 6864 1.33579e-05
R8238 6864 6865 1.664 0.8 13.312 37
I6865 0 6865 1.31105e-05
R8239 6865 6866 1.632 0.8 13.056 37
I6866 0 6866 1.24921e-05
R8240 6866 6867 1.744 0.8 13.952 37
I6867 0 6867 1.33579e-05
R8241 6867 6868 1.744 0.8 13.952 37
I6868 0 6868 1.32342e-05
R8242 6868 6869 1.712 0.8 13.696 37
I6869 0 6869 1.34816e-05
R8243 6869 6870 1.712 0.8 13.696 37
I6870 0 6870 1.23684e-05
R8244 6870 0 0.1 49.28 49.28 37
*seg: 688
R8245 0 6871 0.1 49.28 49.28 37
R8246 6875 6885 6.16 0.8 49.28 37
I6871 0 6871 1.24921e-05
R8247 6871 6872 1.712 0.8 13.696 37
I6872 0 6872 1.32342e-05
R8248 6872 6873 1.68 0.8 13.44 37
I6873 0 6873 1.23684e-05
R8249 6873 6874 1.616 0.8 12.928 37
I6874 0 6874 1.27395e-05
R8250 6874 6875 1.68 0.8 13.44 37
I6875 0 6875 1.27395e-05
R8251 6875 6876 1.648 0.8 13.184 37
I6876 0 6876 1.33579e-05
R8252 6876 6877 1.632 0.8 13.056 37
I6877 0 6877 1.34816e-05
R8253 6877 6878 1.632 0.8 13.056 37
I6878 0 6878 1.28631e-05
R8254 6878 6879 1.712 0.8 13.696 37
I6879 0 6879 1.26158e-05
R8255 6879 6880 1.68 0.8 13.44 37
I6880 0 6880 1.23684e-05
R8256 6880 0 0.1 49.28 49.28 37
*seg: 689
R8257 0 6881 0.1 49.28 49.28 37
R8258 6885 6895 6.16 0.8 49.28 37
I6881 0 6881 1.28631e-05
R8259 6881 6882 1.696 0.8 13.568 37
I6882 0 6882 1.29868e-05
R8260 6882 6883 1.6 0.8 12.8 37
I6883 0 6883 1.32342e-05
R8261 6883 6884 1.68 0.8 13.44 37
I6884 0 6884 1.24921e-05
R8262 6884 6885 1.648 0.8 13.184 37
I6885 0 6885 1.23684e-05
R8263 6885 6886 1.6 0.8 12.8 37
I6886 0 6886 1.28631e-05
R8264 6886 6887 1.6 0.8 12.8 37
I6887 0 6887 1.34816e-05
R8265 6887 6888 1.744 0.8 13.952 37
I6888 0 6888 1.23684e-05
R8266 6888 6889 1.616 0.8 12.928 37
I6889 0 6889 1.27395e-05
R8267 6889 6890 1.712 0.8 13.696 37
I6890 0 6890 1.23684e-05
R8268 6890 0 0.1 49.28 49.28 37
*seg: 690
R8269 0 6891 0.1 49.28 49.28 37
R8270 6895 6905 6.16 0.8 49.28 37
I6891 0 6891 1.34816e-05
R8271 6891 6892 1.712 0.8 13.696 37
I6892 0 6892 1.32342e-05
R8272 6892 6893 1.632 0.8 13.056 37
I6893 0 6893 1.24921e-05
R8273 6893 6894 1.664 0.8 13.312 37
I6894 0 6894 1.31105e-05
R8274 6894 6895 1.648 0.8 13.184 37
I6895 0 6895 1.23684e-05
R8275 6895 6896 1.6 0.8 12.8 37
I6896 0 6896 1.33579e-05
R8276 6896 6897 1.632 0.8 13.056 37
I6897 0 6897 1.27395e-05
R8277 6897 6898 1.728 0.8 13.824 37
I6898 0 6898 1.31105e-05
R8278 6898 6899 1.696 0.8 13.568 37
I6899 0 6899 1.34816e-05
R8279 6899 6900 1.664 0.8 13.312 37
I6900 0 6900 1.23684e-05
R8280 6900 0 0.1 49.28 49.28 37
*seg: 691
R8281 0 6901 0.1 49.28 49.28 37
R8282 6905 6915 6.16 0.8 49.28 37
I6901 0 6901 1.23684e-05
R8283 6901 6902 1.648 0.8 13.184 37
I6902 0 6902 1.33579e-05
R8284 6902 6903 1.68 0.8 13.44 37
I6903 0 6903 1.28631e-05
R8285 6903 6904 1.68 0.8 13.44 37
I6904 0 6904 1.32342e-05
R8286 6904 6905 1.648 0.8 13.184 37
I6905 0 6905 1.28631e-05
R8287 6905 6906 1.712 0.8 13.696 37
I6906 0 6906 1.23684e-05
R8288 6906 6907 1.632 0.8 13.056 37
I6907 0 6907 1.33579e-05
R8289 6907 6908 1.744 0.8 13.952 37
I6908 0 6908 1.32342e-05
R8290 6908 6909 1.712 0.8 13.696 37
I6909 0 6909 1.27395e-05
R8291 6909 6910 1.68 0.8 13.44 37
I6910 0 6910 1.23684e-05
R8292 6910 0 0.1 49.28 49.28 37
*seg: 692
R8293 0 6911 0.1 49.28 49.28 37
R8294 6915 6925 6.16 0.8 49.28 37
I6911 0 6911 1.31105e-05
R8295 6911 6912 1.712 0.8 13.696 37
I6912 0 6912 1.34816e-05
R8296 6912 6913 1.728 0.8 13.824 37
I6913 0 6913 1.34816e-05
R8297 6913 6914 1.696 0.8 13.568 37
I6914 0 6914 1.31105e-05
R8298 6914 6915 1.616 0.8 12.928 37
I6915 0 6915 1.28631e-05
R8299 6915 6916 1.68 0.8 13.44 37
I6916 0 6916 1.34816e-05
R8300 6916 6917 1.712 0.8 13.696 37
I6917 0 6917 1.31105e-05
R8301 6917 6918 1.616 0.8 12.928 37
I6918 0 6918 1.24921e-05
R8302 6918 6919 1.744 0.8 13.952 37
I6919 0 6919 1.32342e-05
R8303 6919 6920 1.664 0.8 13.312 37
I6920 0 6920 1.23684e-05
R8304 6920 0 0.1 49.28 49.28 37
*seg: 693
R8305 0 6921 0.1 49.28 49.28 37
R8306 6925 6935 6.16 0.8 49.28 37
I6921 0 6921 1.31105e-05
R8307 6921 6922 1.712 0.8 13.696 37
I6922 0 6922 1.31105e-05
R8308 6922 6923 1.696 0.8 13.568 37
I6923 0 6923 1.33579e-05
R8309 6923 6924 1.616 0.8 12.928 37
I6924 0 6924 1.34816e-05
R8310 6924 6925 1.648 0.8 13.184 37
I6925 0 6925 1.23684e-05
R8311 6925 6926 1.6 0.8 12.8 37
I6926 0 6926 1.29868e-05
R8312 6926 6927 1.664 0.8 13.312 37
I6927 0 6927 1.27395e-05
R8313 6927 6928 1.632 0.8 13.056 37
I6928 0 6928 1.23684e-05
R8314 6928 6929 1.712 0.8 13.696 37
I6929 0 6929 1.27395e-05
R8315 6929 6930 1.632 0.8 13.056 37
I6930 0 6930 1.23684e-05
R8316 6930 0 0.1 49.28 49.28 37
*seg: 694
R8317 0 6931 0.1 49.28 49.28 37
R8318 6935 6945 6.16 0.8 49.28 37
I6931 0 6931 1.31105e-05
R8319 6931 6932 1.632 0.8 13.056 37
I6932 0 6932 1.33579e-05
R8320 6932 6933 1.6 0.8 12.8 37
I6933 0 6933 1.23684e-05
R8321 6933 6934 1.648 0.8 13.184 37
I6934 0 6934 1.28631e-05
R8322 6934 6935 1.6 0.8 12.8 37
I6935 0 6935 1.29868e-05
R8323 6935 6936 1.744 0.8 13.952 37
I6936 0 6936 1.31105e-05
R8324 6936 6937 1.6 0.8 12.8 37
I6937 0 6937 1.34816e-05
R8325 6937 6938 1.728 0.8 13.824 37
I6938 0 6938 1.34816e-05
R8326 6938 6939 1.648 0.8 13.184 37
I6939 0 6939 1.24921e-05
R8327 6939 6940 1.616 0.8 12.928 37
I6940 0 6940 1.23684e-05
R8328 6940 0 0.1 49.28 49.28 37
*seg: 695
R8329 0 6941 0.1 49.28 49.28 37
R8330 6945 6955 6.16 0.8 49.28 37
I6941 0 6941 1.33579e-05
R8331 6941 6942 1.68 0.8 13.44 37
I6942 0 6942 1.28631e-05
R8332 6942 6943 1.696 0.8 13.568 37
I6943 0 6943 1.23684e-05
R8333 6943 6944 1.664 0.8 13.312 37
I6944 0 6944 1.26158e-05
R8334 6944 6945 1.6 0.8 12.8 37
I6945 0 6945 1.23684e-05
R8335 6945 6946 1.632 0.8 13.056 37
I6946 0 6946 1.28631e-05
R8336 6946 6947 1.68 0.8 13.44 37
I6947 0 6947 1.23684e-05
R8337 6947 6948 1.632 0.8 13.056 37
I6948 0 6948 1.31105e-05
R8338 6948 6949 1.744 0.8 13.952 37
I6949 0 6949 1.32342e-05
R8339 6949 6950 1.616 0.8 12.928 37
I6950 0 6950 1.23684e-05
R8340 6950 0 0.1 49.28 49.28 37
*seg: 696
R8341 0 6951 0.1 49.28 49.28 37
R8342 6955 6965 6.16 0.8 49.28 37
I6951 0 6951 1.29868e-05
R8343 6951 6952 1.712 0.8 13.696 37
I6952 0 6952 1.24921e-05
R8344 6952 6953 1.728 0.8 13.824 37
I6953 0 6953 1.27395e-05
R8345 6953 6954 1.664 0.8 13.312 37
I6954 0 6954 1.23684e-05
R8346 6954 6955 1.712 0.8 13.696 37
I6955 0 6955 1.28631e-05
R8347 6955 6956 1.616 0.8 12.928 37
I6956 0 6956 1.34816e-05
R8348 6956 6957 1.616 0.8 12.928 37
I6957 0 6957 1.24921e-05
R8349 6957 6958 1.712 0.8 13.696 37
I6958 0 6958 1.31105e-05
R8350 6958 6959 1.696 0.8 13.568 37
I6959 0 6959 1.28631e-05
R8351 6959 6960 1.728 0.8 13.824 37
I6960 0 6960 1.23684e-05
R8352 6960 0 0.1 49.28 49.28 37
*seg: 697
R8353 0 6961 0.1 49.28 49.28 37
R8354 6965 6975 6.16 0.8 49.28 37
I6961 0 6961 1.23684e-05
R8355 6961 6962 1.632 0.8 13.056 37
I6962 0 6962 1.23684e-05
R8356 6962 6963 1.744 0.8 13.952 37
I6963 0 6963 1.27395e-05
R8357 6963 6964 1.616 0.8 12.928 37
I6964 0 6964 1.34816e-05
R8358 6964 6965 1.648 0.8 13.184 37
I6965 0 6965 1.33579e-05
R8359 6965 6966 1.712 0.8 13.696 37
I6966 0 6966 1.33579e-05
R8360 6966 6967 1.712 0.8 13.696 37
I6967 0 6967 1.33579e-05
R8361 6967 6968 1.648 0.8 13.184 37
I6968 0 6968 1.23684e-05
R8362 6968 6969 1.744 0.8 13.952 37
I6969 0 6969 1.28631e-05
R8363 6969 6970 1.744 0.8 13.952 37
I6970 0 6970 1.23684e-05
R8364 6970 0 0.1 49.28 49.28 37
*seg: 698
R8365 0 6971 0.1 49.28 49.28 37
R8366 6975 6985 6.16 0.8 49.28 37
I6971 0 6971 1.33579e-05
R8367 6971 6972 1.664 0.8 13.312 37
I6972 0 6972 1.33579e-05
R8368 6972 6973 1.648 0.8 13.184 37
I6973 0 6973 1.32342e-05
R8369 6973 6974 1.6 0.8 12.8 37
I6974 0 6974 1.33579e-05
R8370 6974 6975 1.6 0.8 12.8 37
I6975 0 6975 1.32342e-05
R8371 6975 6976 1.6 0.8 12.8 37
I6976 0 6976 1.33579e-05
R8372 6976 6977 1.616 0.8 12.928 37
I6977 0 6977 1.32342e-05
R8373 6977 6978 1.6 0.8 12.8 37
I6978 0 6978 1.23684e-05
R8374 6978 6979 1.664 0.8 13.312 37
I6979 0 6979 1.31105e-05
R8375 6979 6980 1.616 0.8 12.928 37
I6980 0 6980 1.23684e-05
R8376 6980 0 0.1 49.28 49.28 37
*seg: 699
R8377 0 6981 0.1 49.28 49.28 37
R8378 6985 6995 6.16 0.8 49.28 37
I6981 0 6981 1.29868e-05
R8379 6981 6982 1.696 0.8 13.568 37
I6982 0 6982 1.32342e-05
R8380 6982 6983 1.728 0.8 13.824 37
I6983 0 6983 1.24921e-05
R8381 6983 6984 1.632 0.8 13.056 37
I6984 0 6984 1.33579e-05
R8382 6984 6985 1.616 0.8 12.928 37
I6985 0 6985 1.32342e-05
R8383 6985 6986 1.664 0.8 13.312 37
I6986 0 6986 1.34816e-05
R8384 6986 6987 1.664 0.8 13.312 37
I6987 0 6987 1.34816e-05
R8385 6987 6988 1.68 0.8 13.44 37
I6988 0 6988 1.32342e-05
R8386 6988 6989 1.616 0.8 12.928 37
I6989 0 6989 1.23684e-05
R8387 6989 6990 1.632 0.8 13.056 37
I6990 0 6990 1.23684e-05
R8388 6990 0 0.1 49.28 49.28 37
*seg: 700
R8389 0 6991 0.1 49.28 49.28 37
R8390 6995 7005 6.16 0.8 49.28 37
I6991 0 6991 1.29868e-05
R8391 6991 6992 1.616 0.8 12.928 37
I6992 0 6992 1.29868e-05
R8392 6992 6993 1.728 0.8 13.824 37
I6993 0 6993 1.33579e-05
R8393 6993 6994 1.744 0.8 13.952 37
I6994 0 6994 1.24921e-05
R8394 6994 6995 1.6 0.8 12.8 37
I6995 0 6995 1.31105e-05
R8395 6995 6996 1.6 0.8 12.8 37
I6996 0 6996 1.26158e-05
R8396 6996 6997 1.68 0.8 13.44 37
I6997 0 6997 1.31105e-05
R8397 6997 6998 1.664 0.8 13.312 37
I6998 0 6998 1.23684e-05
R8398 6998 6999 1.728 0.8 13.824 37
I6999 0 6999 1.32342e-05
R8399 6999 7000 1.728 0.8 13.824 37
I7000 0 7000 1.23684e-05
R8400 7000 0 0.1 49.28 49.28 37
*seg: 701
R8401 0 7001 0.1 49.28 49.28 37
R8402 7005 7015 6.16 0.8 49.28 37
I7001 0 7001 1.32342e-05
R8403 7001 7002 1.632 0.8 13.056 37
I7002 0 7002 1.27395e-05
R8404 7002 7003 1.632 0.8 13.056 37
I7003 0 7003 1.31105e-05
R8405 7003 7004 1.648 0.8 13.184 37
I7004 0 7004 1.24921e-05
R8406 7004 7005 1.696 0.8 13.568 37
I7005 0 7005 1.31105e-05
R8407 7005 7006 1.68 0.8 13.44 37
I7006 0 7006 1.29868e-05
R8408 7006 7007 1.6 0.8 12.8 37
I7007 0 7007 1.33579e-05
R8409 7007 7008 1.616 0.8 12.928 37
I7008 0 7008 1.26158e-05
R8410 7008 7009 1.696 0.8 13.568 37
I7009 0 7009 1.29868e-05
R8411 7009 7010 1.648 0.8 13.184 37
I7010 0 7010 1.23684e-05
R8412 7010 0 0.1 49.28 49.28 37
*seg: 702
R8413 0 7011 0.1 49.28 49.28 37
R8414 7015 7025 6.16 0.8 49.28 37
I7011 0 7011 1.24921e-05
R8415 7011 7012 1.744 0.8 13.952 37
I7012 0 7012 1.33579e-05
R8416 7012 7013 1.712 0.8 13.696 37
I7013 0 7013 1.26158e-05
R8417 7013 7014 1.632 0.8 13.056 37
I7014 0 7014 1.24921e-05
R8418 7014 7015 1.6 0.8 12.8 37
I7015 0 7015 1.32342e-05
R8419 7015 7016 1.616 0.8 12.928 37
I7016 0 7016 1.33579e-05
R8420 7016 7017 1.632 0.8 13.056 37
I7017 0 7017 1.26158e-05
R8421 7017 7018 1.68 0.8 13.44 37
I7018 0 7018 1.31105e-05
R8422 7018 7019 1.728 0.8 13.824 37
I7019 0 7019 1.33579e-05
R8423 7019 7020 1.696 0.8 13.568 37
I7020 0 7020 1.23684e-05
R8424 7020 0 0.1 49.28 49.28 37
*seg: 703
R8425 0 7021 0.1 49.28 49.28 37
R8426 7025 7035 6.16 0.8 49.28 37
I7021 0 7021 1.31105e-05
R8427 7021 7022 1.68 0.8 13.44 37
I7022 0 7022 1.24921e-05
R8428 7022 7023 1.68 0.8 13.44 37
I7023 0 7023 1.26158e-05
R8429 7023 7024 1.648 0.8 13.184 37
I7024 0 7024 1.26158e-05
R8430 7024 7025 1.6 0.8 12.8 37
I7025 0 7025 1.27395e-05
R8431 7025 7026 1.728 0.8 13.824 37
I7026 0 7026 1.32342e-05
R8432 7026 7027 1.648 0.8 13.184 37
I7027 0 7027 1.28631e-05
R8433 7027 7028 1.728 0.8 13.824 37
I7028 0 7028 1.33579e-05
R8434 7028 7029 1.728 0.8 13.824 37
I7029 0 7029 1.34816e-05
R8435 7029 7030 1.744 0.8 13.952 37
I7030 0 7030 1.23684e-05
R8436 7030 0 0.1 49.28 49.28 37
*seg: 704
R8437 0 7031 0.1 49.28 49.28 37
R8438 7035 7045 6.16 0.8 49.28 37
I7031 0 7031 1.24921e-05
R8439 7031 7032 1.696 0.8 13.568 37
I7032 0 7032 1.32342e-05
R8440 7032 7033 1.68 0.8 13.44 37
I7033 0 7033 1.24921e-05
R8441 7033 7034 1.664 0.8 13.312 37
I7034 0 7034 1.31105e-05
R8442 7034 7035 1.712 0.8 13.696 37
I7035 0 7035 1.26158e-05
R8443 7035 7036 1.616 0.8 12.928 37
I7036 0 7036 1.28631e-05
R8444 7036 7037 1.664 0.8 13.312 37
I7037 0 7037 1.27395e-05
R8445 7037 7038 1.744 0.8 13.952 37
I7038 0 7038 1.32342e-05
R8446 7038 7039 1.68 0.8 13.44 37
I7039 0 7039 1.32342e-05
R8447 7039 7040 1.648 0.8 13.184 37
I7040 0 7040 1.23684e-05
R8448 7040 0 0.1 49.28 49.28 37
*seg: 705
R8449 0 7041 0.1 49.28 49.28 37
R8450 7045 7055 6.16 0.8 49.28 37
I7041 0 7041 1.26158e-05
R8451 7041 7042 1.664 0.8 13.312 37
I7042 0 7042 1.34816e-05
R8452 7042 7043 1.648 0.8 13.184 37
I7043 0 7043 1.24921e-05
R8453 7043 7044 1.648 0.8 13.184 37
I7044 0 7044 1.34816e-05
R8454 7044 7045 1.664 0.8 13.312 37
I7045 0 7045 1.23684e-05
R8455 7045 7046 1.696 0.8 13.568 37
I7046 0 7046 1.32342e-05
R8456 7046 7047 1.728 0.8 13.824 37
I7047 0 7047 1.26158e-05
R8457 7047 7048 1.696 0.8 13.568 37
I7048 0 7048 1.34816e-05
R8458 7048 7049 1.696 0.8 13.568 37
I7049 0 7049 1.28631e-05
R8459 7049 7050 1.744 0.8 13.952 37
I7050 0 7050 1.23684e-05
R8460 7050 0 0.1 49.28 49.28 37
*seg: 706
R8461 0 7051 0.1 49.28 49.28 37
R8462 7055 7065 6.16 0.8 49.28 37
I7051 0 7051 1.29868e-05
R8463 7051 7052 1.664 0.8 13.312 37
I7052 0 7052 1.32342e-05
R8464 7052 7053 1.648 0.8 13.184 37
I7053 0 7053 1.28631e-05
R8465 7053 7054 1.6 0.8 12.8 37
I7054 0 7054 1.34816e-05
R8466 7054 7055 1.712 0.8 13.696 37
I7055 0 7055 1.34816e-05
R8467 7055 7056 1.744 0.8 13.952 37
I7056 0 7056 1.34816e-05
R8468 7056 7057 1.664 0.8 13.312 37
I7057 0 7057 1.28631e-05
R8469 7057 7058 1.744 0.8 13.952 37
I7058 0 7058 1.23684e-05
R8470 7058 7059 1.744 0.8 13.952 37
I7059 0 7059 1.29868e-05
R8471 7059 7060 1.632 0.8 13.056 37
I7060 0 7060 1.23684e-05
R8472 7060 0 0.1 49.28 49.28 37
*seg: 707
R8473 0 7061 0.1 49.28 49.28 37
R8474 7065 7075 6.16 0.8 49.28 37
I7061 0 7061 1.26158e-05
R8475 7061 7062 1.712 0.8 13.696 37
I7062 0 7062 1.33579e-05
R8476 7062 7063 1.728 0.8 13.824 37
I7063 0 7063 1.26158e-05
R8477 7063 7064 1.712 0.8 13.696 37
I7064 0 7064 1.29868e-05
R8478 7064 7065 1.728 0.8 13.824 37
I7065 0 7065 1.24921e-05
R8479 7065 7066 1.648 0.8 13.184 37
I7066 0 7066 1.34816e-05
R8480 7066 7067 1.712 0.8 13.696 37
I7067 0 7067 1.24921e-05
R8481 7067 7068 1.632 0.8 13.056 37
I7068 0 7068 1.28631e-05
R8482 7068 7069 1.648 0.8 13.184 37
I7069 0 7069 1.26158e-05
R8483 7069 7070 1.712 0.8 13.696 37
I7070 0 7070 1.23684e-05
R8484 7070 0 0.1 49.28 49.28 37
*seg: 708
R8485 0 7071 0.1 49.28 49.28 37
R8486 7075 7085 6.16 0.8 49.28 37
I7071 0 7071 1.24921e-05
R8487 7071 7072 1.68 0.8 13.44 37
I7072 0 7072 1.32342e-05
R8488 7072 7073 1.6 0.8 12.8 37
I7073 0 7073 1.29868e-05
R8489 7073 7074 1.6 0.8 12.8 37
I7074 0 7074 1.23684e-05
R8490 7074 7075 1.616 0.8 12.928 37
I7075 0 7075 1.34816e-05
R8491 7075 7076 1.712 0.8 13.696 37
I7076 0 7076 1.26158e-05
R8492 7076 7077 1.616 0.8 12.928 37
I7077 0 7077 1.31105e-05
R8493 7077 7078 1.648 0.8 13.184 37
I7078 0 7078 1.28631e-05
R8494 7078 7079 1.648 0.8 13.184 37
I7079 0 7079 1.29868e-05
R8495 7079 7080 1.6 0.8 12.8 37
I7080 0 7080 1.23684e-05
R8496 7080 0 0.1 49.28 49.28 37
*seg: 709
R8497 0 7081 0.1 49.28 49.28 37
R8498 7085 7095 6.16 0.8 49.28 37
I7081 0 7081 1.26158e-05
R8499 7081 7082 1.712 0.8 13.696 37
I7082 0 7082 1.34816e-05
R8500 7082 7083 1.744 0.8 13.952 37
I7083 0 7083 1.33579e-05
R8501 7083 7084 1.744 0.8 13.952 37
I7084 0 7084 1.23684e-05
R8502 7084 7085 1.696 0.8 13.568 37
I7085 0 7085 1.29868e-05
R8503 7085 7086 1.712 0.8 13.696 37
I7086 0 7086 1.26158e-05
R8504 7086 7087 1.728 0.8 13.824 37
I7087 0 7087 1.27395e-05
R8505 7087 7088 1.696 0.8 13.568 37
I7088 0 7088 1.24921e-05
R8506 7088 7089 1.664 0.8 13.312 37
I7089 0 7089 1.24921e-05
R8507 7089 7090 1.664 0.8 13.312 37
I7090 0 7090 1.23684e-05
R8508 7090 0 0.1 49.28 49.28 37
*seg: 710
R8509 0 7091 0.1 49.28 49.28 37
R8510 7095 7105 6.16 0.8 49.28 37
I7091 0 7091 1.29868e-05
R8511 7091 7092 1.616 0.8 12.928 37
I7092 0 7092 1.34816e-05
R8512 7092 7093 1.744 0.8 13.952 37
I7093 0 7093 1.29868e-05
R8513 7093 7094 1.6 0.8 12.8 37
I7094 0 7094 1.34816e-05
R8514 7094 7095 1.648 0.8 13.184 37
I7095 0 7095 1.27395e-05
R8515 7095 7096 1.696 0.8 13.568 37
I7096 0 7096 1.26158e-05
R8516 7096 7097 1.712 0.8 13.696 37
I7097 0 7097 1.32342e-05
R8517 7097 7098 1.632 0.8 13.056 37
I7098 0 7098 1.33579e-05
R8518 7098 7099 1.712 0.8 13.696 37
I7099 0 7099 1.34816e-05
R8519 7099 7100 1.68 0.8 13.44 37
I7100 0 7100 1.23684e-05
R8520 7100 0 0.1 49.28 49.28 37
*seg: 711
R8521 0 7101 0.1 49.28 49.28 37
R8522 7105 7115 6.16 0.8 49.28 37
I7101 0 7101 1.27395e-05
R8523 7101 7102 1.616 0.8 12.928 37
I7102 0 7102 1.32342e-05
R8524 7102 7103 1.68 0.8 13.44 37
I7103 0 7103 1.28631e-05
R8525 7103 7104 1.696 0.8 13.568 37
I7104 0 7104 1.26158e-05
R8526 7104 7105 1.648 0.8 13.184 37
I7105 0 7105 1.28631e-05
R8527 7105 7106 1.616 0.8 12.928 37
I7106 0 7106 1.24921e-05
R8528 7106 7107 1.632 0.8 13.056 37
I7107 0 7107 1.31105e-05
R8529 7107 7108 1.728 0.8 13.824 37
I7108 0 7108 1.27395e-05
R8530 7108 7109 1.664 0.8 13.312 37
I7109 0 7109 1.34816e-05
R8531 7109 7110 1.664 0.8 13.312 37
I7110 0 7110 1.23684e-05
R8532 7110 0 0.1 49.28 49.28 37
*seg: 712
R8533 0 7111 0.1 49.28 49.28 37
R8534 7115 7125 6.16 0.8 49.28 37
I7111 0 7111 1.23684e-05
R8535 7111 7112 1.616 0.8 12.928 37
I7112 0 7112 1.24921e-05
R8536 7112 7113 1.712 0.8 13.696 37
I7113 0 7113 1.31105e-05
R8537 7113 7114 1.648 0.8 13.184 37
I7114 0 7114 1.32342e-05
R8538 7114 7115 1.712 0.8 13.696 37
I7115 0 7115 1.28631e-05
R8539 7115 7116 1.744 0.8 13.952 37
I7116 0 7116 1.26158e-05
R8540 7116 7117 1.744 0.8 13.952 37
I7117 0 7117 1.33579e-05
R8541 7117 7118 1.712 0.8 13.696 37
I7118 0 7118 1.23684e-05
R8542 7118 7119 1.728 0.8 13.824 37
I7119 0 7119 1.27395e-05
R8543 7119 7120 1.68 0.8 13.44 37
I7120 0 7120 1.23684e-05
R8544 7120 0 0.1 49.28 49.28 37
*seg: 713
R8545 0 7121 0.1 49.28 49.28 37
R8546 7125 7135 6.16 0.8 49.28 37
I7121 0 7121 1.33579e-05
R8547 7121 7122 1.696 0.8 13.568 37
I7122 0 7122 1.24921e-05
R8548 7122 7123 1.696 0.8 13.568 37
I7123 0 7123 1.27395e-05
R8549 7123 7124 1.632 0.8 13.056 37
I7124 0 7124 1.27395e-05
R8550 7124 7125 1.728 0.8 13.824 37
I7125 0 7125 1.26158e-05
R8551 7125 7126 1.68 0.8 13.44 37
I7126 0 7126 1.28631e-05
R8552 7126 7127 1.728 0.8 13.824 37
I7127 0 7127 1.28631e-05
R8553 7127 7128 1.648 0.8 13.184 37
I7128 0 7128 1.31105e-05
R8554 7128 7129 1.696 0.8 13.568 37
I7129 0 7129 1.26158e-05
R8555 7129 7130 1.696 0.8 13.568 37
I7130 0 7130 1.23684e-05
R8556 7130 0 0.1 49.28 49.28 37
*seg: 714
R8557 0 7131 0.1 49.28 49.28 37
R8558 7135 7145 6.16 0.8 49.28 37
I7131 0 7131 1.31105e-05
R8559 7131 7132 1.696 0.8 13.568 37
I7132 0 7132 1.29868e-05
R8560 7132 7133 1.6 0.8 12.8 37
I7133 0 7133 1.31105e-05
R8561 7133 7134 1.68 0.8 13.44 37
I7134 0 7134 1.32342e-05
R8562 7134 7135 1.664 0.8 13.312 37
I7135 0 7135 1.32342e-05
R8563 7135 7136 1.712 0.8 13.696 37
I7136 0 7136 1.28631e-05
R8564 7136 7137 1.68 0.8 13.44 37
I7137 0 7137 1.26158e-05
R8565 7137 7138 1.6 0.8 12.8 37
I7138 0 7138 1.33579e-05
R8566 7138 7139 1.664 0.8 13.312 37
I7139 0 7139 1.31105e-05
R8567 7139 7140 1.648 0.8 13.184 37
I7140 0 7140 1.23684e-05
R8568 7140 0 0.1 49.28 49.28 37
*seg: 715
R8569 0 7141 0.1 49.28 49.28 37
R8570 7145 7155 6.16 0.8 49.28 37
I7141 0 7141 1.23684e-05
R8571 7141 7142 1.616 0.8 12.928 37
I7142 0 7142 1.26158e-05
R8572 7142 7143 1.728 0.8 13.824 37
I7143 0 7143 1.24921e-05
R8573 7143 7144 1.696 0.8 13.568 37
I7144 0 7144 1.29868e-05
R8574 7144 7145 1.648 0.8 13.184 37
I7145 0 7145 1.26158e-05
R8575 7145 7146 1.712 0.8 13.696 37
I7146 0 7146 1.26158e-05
R8576 7146 7147 1.632 0.8 13.056 37
I7147 0 7147 1.32342e-05
R8577 7147 7148 1.728 0.8 13.824 37
I7148 0 7148 1.33579e-05
R8578 7148 7149 1.68 0.8 13.44 37
I7149 0 7149 1.33579e-05
R8579 7149 7150 1.696 0.8 13.568 37
I7150 0 7150 1.23684e-05
R8580 7150 0 0.1 49.28 49.28 37
*seg: 716
R8581 0 7151 0.1 49.28 49.28 37
R8582 7155 7165 6.16 0.8 49.28 37
I7151 0 7151 1.33579e-05
R8583 7151 7152 1.6 0.8 12.8 37
I7152 0 7152 1.27395e-05
R8584 7152 7153 1.616 0.8 12.928 37
I7153 0 7153 1.23684e-05
R8585 7153 7154 1.68 0.8 13.44 37
I7154 0 7154 1.26158e-05
R8586 7154 7155 1.68 0.8 13.44 37
I7155 0 7155 1.28631e-05
R8587 7155 7156 1.664 0.8 13.312 37
I7156 0 7156 1.23684e-05
R8588 7156 7157 1.744 0.8 13.952 37
I7157 0 7157 1.32342e-05
R8589 7157 7158 1.744 0.8 13.952 37
I7158 0 7158 1.27395e-05
R8590 7158 7159 1.664 0.8 13.312 37
I7159 0 7159 1.34816e-05
R8591 7159 7160 1.632 0.8 13.056 37
I7160 0 7160 1.23684e-05
R8592 7160 0 0.1 49.28 49.28 37
*seg: 717
R8593 0 7161 0.1 49.28 49.28 37
R8594 7165 7175 6.16 0.8 49.28 37
I7161 0 7161 1.28631e-05
R8595 7161 7162 1.744 0.8 13.952 37
I7162 0 7162 1.27395e-05
R8596 7162 7163 1.632 0.8 13.056 37
I7163 0 7163 1.24921e-05
R8597 7163 7164 1.68 0.8 13.44 37
I7164 0 7164 1.29868e-05
R8598 7164 7165 1.664 0.8 13.312 37
I7165 0 7165 1.26158e-05
R8599 7165 7166 1.632 0.8 13.056 37
I7166 0 7166 1.31105e-05
R8600 7166 7167 1.712 0.8 13.696 37
I7167 0 7167 1.28631e-05
R8601 7167 7168 1.728 0.8 13.824 37
I7168 0 7168 1.34816e-05
R8602 7168 7169 1.696 0.8 13.568 37
I7169 0 7169 1.26158e-05
R8603 7169 7170 1.712 0.8 13.696 37
I7170 0 7170 1.23684e-05
R8604 7170 0 0.1 49.28 49.28 37
*seg: 718
R8605 0 7171 0.1 49.28 49.28 37
R8606 7175 7185 6.16 0.8 49.28 37
I7171 0 7171 1.31105e-05
R8607 7171 7172 1.68 0.8 13.44 37
I7172 0 7172 1.34816e-05
R8608 7172 7173 1.6 0.8 12.8 37
I7173 0 7173 1.31105e-05
R8609 7173 7174 1.648 0.8 13.184 37
I7174 0 7174 1.33579e-05
R8610 7174 7175 1.632 0.8 13.056 37
I7175 0 7175 1.31105e-05
R8611 7175 7176 1.6 0.8 12.8 37
I7176 0 7176 1.26158e-05
R8612 7176 7177 1.712 0.8 13.696 37
I7177 0 7177 1.23684e-05
R8613 7177 7178 1.632 0.8 13.056 37
I7178 0 7178 1.32342e-05
R8614 7178 7179 1.744 0.8 13.952 37
I7179 0 7179 1.34816e-05
R8615 7179 7180 1.744 0.8 13.952 37
I7180 0 7180 1.23684e-05
R8616 7180 0 0.1 49.28 49.28 37
*seg: 719
R8617 0 7181 0.1 49.28 49.28 37
R8618 7185 7195 6.16 0.8 49.28 37
I7181 0 7181 1.28631e-05
R8619 7181 7182 1.664 0.8 13.312 37
I7182 0 7182 1.32342e-05
R8620 7182 7183 1.744 0.8 13.952 37
I7183 0 7183 1.24921e-05
R8621 7183 7184 1.6 0.8 12.8 37
I7184 0 7184 1.27395e-05
R8622 7184 7185 1.664 0.8 13.312 37
I7185 0 7185 1.23684e-05
R8623 7185 7186 1.632 0.8 13.056 37
I7186 0 7186 1.31105e-05
R8624 7186 7187 1.68 0.8 13.44 37
I7187 0 7187 1.26158e-05
R8625 7187 7188 1.712 0.8 13.696 37
I7188 0 7188 1.31105e-05
R8626 7188 7189 1.616 0.8 12.928 37
I7189 0 7189 1.24921e-05
R8627 7189 7190 1.616 0.8 12.928 37
I7190 0 7190 1.23684e-05
R8628 7190 0 0.1 49.28 49.28 37
*seg: 720
R8629 0 7191 0.1 49.28 49.28 37
R8630 7195 7205 6.16 0.8 49.28 37
I7191 0 7191 1.29868e-05
R8631 7191 7192 1.744 0.8 13.952 37
I7192 0 7192 1.29868e-05
R8632 7192 7193 1.712 0.8 13.696 37
I7193 0 7193 1.23684e-05
R8633 7193 7194 1.616 0.8 12.928 37
I7194 0 7194 1.28631e-05
R8634 7194 7195 1.744 0.8 13.952 37
I7195 0 7195 1.26158e-05
R8635 7195 7196 1.696 0.8 13.568 37
I7196 0 7196 1.33579e-05
R8636 7196 7197 1.6 0.8 12.8 37
I7197 0 7197 1.24921e-05
R8637 7197 7198 1.696 0.8 13.568 37
I7198 0 7198 1.24921e-05
R8638 7198 7199 1.712 0.8 13.696 37
I7199 0 7199 1.27395e-05
R8639 7199 7200 1.6 0.8 12.8 37
I7200 0 7200 1.23684e-05
R8640 7200 0 0.1 49.28 49.28 37
*seg: 721
R8641 0 7201 0.1 49.28 49.28 37
R8642 7205 7215 6.16 0.8 49.28 37
I7201 0 7201 1.27395e-05
R8643 7201 7202 1.744 0.8 13.952 37
I7202 0 7202 1.27395e-05
R8644 7202 7203 1.68 0.8 13.44 37
I7203 0 7203 1.32342e-05
R8645 7203 7204 1.632 0.8 13.056 37
I7204 0 7204 1.34816e-05
R8646 7204 7205 1.648 0.8 13.184 37
I7205 0 7205 1.34816e-05
R8647 7205 7206 1.696 0.8 13.568 37
I7206 0 7206 1.26158e-05
R8648 7206 7207 1.712 0.8 13.696 37
I7207 0 7207 1.34816e-05
R8649 7207 7208 1.6 0.8 12.8 37
I7208 0 7208 1.29868e-05
R8650 7208 7209 1.648 0.8 13.184 37
I7209 0 7209 1.29868e-05
R8651 7209 7210 1.68 0.8 13.44 37
I7210 0 7210 1.23684e-05
R8652 7210 0 0.1 49.28 49.28 37
*seg: 722
R8653 0 7211 0.1 49.28 49.28 37
R8654 7215 7225 6.16 0.8 49.28 37
I7211 0 7211 1.31105e-05
R8655 7211 7212 1.648 0.8 13.184 37
I7212 0 7212 1.31105e-05
R8656 7212 7213 1.6 0.8 12.8 37
I7213 0 7213 1.27395e-05
R8657 7213 7214 1.68 0.8 13.44 37
I7214 0 7214 1.27395e-05
R8658 7214 7215 1.712 0.8 13.696 37
I7215 0 7215 1.32342e-05
R8659 7215 7216 1.728 0.8 13.824 37
I7216 0 7216 1.26158e-05
R8660 7216 7217 1.744 0.8 13.952 37
I7217 0 7217 1.28631e-05
R8661 7217 7218 1.616 0.8 12.928 37
I7218 0 7218 1.29868e-05
R8662 7218 7219 1.632 0.8 13.056 37
I7219 0 7219 1.32342e-05
R8663 7219 7220 1.616 0.8 12.928 37
I7220 0 7220 1.23684e-05
R8664 7220 0 0.1 49.28 49.28 37
*seg: 723
R8665 0 7221 0.1 49.28 49.28 37
R8666 7225 7235 6.16 0.8 49.28 37
I7221 0 7221 1.27395e-05
R8667 7221 7222 1.664 0.8 13.312 37
I7222 0 7222 1.34816e-05
R8668 7222 7223 1.648 0.8 13.184 37
I7223 0 7223 1.28631e-05
R8669 7223 7224 1.68 0.8 13.44 37
I7224 0 7224 1.29868e-05
R8670 7224 7225 1.712 0.8 13.696 37
I7225 0 7225 1.27395e-05
R8671 7225 7226 1.744 0.8 13.952 37
I7226 0 7226 1.32342e-05
R8672 7226 7227 1.744 0.8 13.952 37
I7227 0 7227 1.31105e-05
R8673 7227 7228 1.696 0.8 13.568 37
I7228 0 7228 1.33579e-05
R8674 7228 7229 1.6 0.8 12.8 37
I7229 0 7229 1.28631e-05
R8675 7229 7230 1.744 0.8 13.952 37
I7230 0 7230 1.23684e-05
R8676 7230 0 0.1 49.28 49.28 37
*seg: 724
R8677 0 7231 0.1 49.28 49.28 37
R8678 7235 7245 6.16 0.8 49.28 37
I7231 0 7231 1.23684e-05
R8679 7231 7232 1.728 0.8 13.824 37
I7232 0 7232 1.27395e-05
R8680 7232 7233 1.664 0.8 13.312 37
I7233 0 7233 1.28631e-05
R8681 7233 7234 1.648 0.8 13.184 37
I7234 0 7234 1.28631e-05
R8682 7234 7235 1.6 0.8 12.8 37
I7235 0 7235 1.33579e-05
R8683 7235 7236 1.744 0.8 13.952 37
I7236 0 7236 1.24921e-05
R8684 7236 7237 1.632 0.8 13.056 37
I7237 0 7237 1.23684e-05
R8685 7237 7238 1.664 0.8 13.312 37
I7238 0 7238 1.23684e-05
R8686 7238 7239 1.6 0.8 12.8 37
I7239 0 7239 1.24921e-05
R8687 7239 7240 1.648 0.8 13.184 37
I7240 0 7240 1.23684e-05
R8688 7240 0 0.1 49.28 49.28 37
*seg: 725
R8689 0 7241 0.1 49.28 49.28 37
R8690 7245 7255 6.16 0.8 49.28 37
I7241 0 7241 1.33579e-05
R8691 7241 7242 1.696 0.8 13.568 37
I7242 0 7242 1.24921e-05
R8692 7242 7243 1.616 0.8 12.928 37
I7243 0 7243 1.34816e-05
R8693 7243 7244 1.744 0.8 13.952 37
I7244 0 7244 1.31105e-05
R8694 7244 7245 1.632 0.8 13.056 37
I7245 0 7245 1.24921e-05
R8695 7245 7246 1.728 0.8 13.824 37
I7246 0 7246 1.34816e-05
R8696 7246 7247 1.664 0.8 13.312 37
I7247 0 7247 1.23684e-05
R8697 7247 7248 1.664 0.8 13.312 37
I7248 0 7248 1.33579e-05
R8698 7248 7249 1.68 0.8 13.44 37
I7249 0 7249 1.27395e-05
R8699 7249 7250 1.696 0.8 13.568 37
I7250 0 7250 1.23684e-05
R8700 7250 0 0.1 49.28 49.28 37
*seg: 726
R8701 0 7251 0.1 49.28 49.28 37
R8702 7255 7265 6.16 0.8 49.28 37
I7251 0 7251 1.32342e-05
R8703 7251 7252 1.728 0.8 13.824 37
I7252 0 7252 1.29868e-05
R8704 7252 7253 1.648 0.8 13.184 37
I7253 0 7253 1.23684e-05
R8705 7253 7254 1.6 0.8 12.8 37
I7254 0 7254 1.24921e-05
R8706 7254 7255 1.664 0.8 13.312 37
I7255 0 7255 1.28631e-05
R8707 7255 7256 1.6 0.8 12.8 37
I7256 0 7256 1.33579e-05
R8708 7256 7257 1.616 0.8 12.928 37
I7257 0 7257 1.27395e-05
R8709 7257 7258 1.728 0.8 13.824 37
I7258 0 7258 1.28631e-05
R8710 7258 7259 1.6 0.8 12.8 37
I7259 0 7259 1.27395e-05
R8711 7259 7260 1.6 0.8 12.8 37
I7260 0 7260 1.23684e-05
R8712 7260 0 0.1 49.28 49.28 37
*seg: 727
R8713 0 7261 0.1 49.28 49.28 37
R8714 7265 7275 6.16 0.8 49.28 37
I7261 0 7261 1.26158e-05
R8715 7261 7262 1.616 0.8 12.928 37
I7262 0 7262 1.26158e-05
R8716 7262 7263 1.664 0.8 13.312 37
I7263 0 7263 1.23684e-05
R8717 7263 7264 1.728 0.8 13.824 37
I7264 0 7264 1.33579e-05
R8718 7264 7265 1.744 0.8 13.952 37
I7265 0 7265 1.34816e-05
R8719 7265 7266 1.712 0.8 13.696 37
I7266 0 7266 1.29868e-05
R8720 7266 7267 1.744 0.8 13.952 37
I7267 0 7267 1.24921e-05
R8721 7267 7268 1.6 0.8 12.8 37
I7268 0 7268 1.23684e-05
R8722 7268 7269 1.712 0.8 13.696 37
I7269 0 7269 1.33579e-05
R8723 7269 7270 1.664 0.8 13.312 37
I7270 0 7270 1.23684e-05
R8724 7270 0 0.1 49.28 49.28 37
*seg: 728
R8725 0 7271 0.1 49.28 49.28 37
R8726 7275 7285 6.16 0.8 49.28 37
I7271 0 7271 1.34816e-05
R8727 7271 7272 1.632 0.8 13.056 37
I7272 0 7272 1.29868e-05
R8728 7272 7273 1.6 0.8 12.8 37
I7273 0 7273 1.33579e-05
R8729 7273 7274 1.616 0.8 12.928 37
I7274 0 7274 1.26158e-05
R8730 7274 7275 1.728 0.8 13.824 37
I7275 0 7275 1.31105e-05
R8731 7275 7276 1.744 0.8 13.952 37
I7276 0 7276 1.26158e-05
R8732 7276 7277 1.616 0.8 12.928 37
I7277 0 7277 1.23684e-05
R8733 7277 7278 1.728 0.8 13.824 37
I7278 0 7278 1.33579e-05
R8734 7278 7279 1.616 0.8 12.928 37
I7279 0 7279 1.23684e-05
R8735 7279 7280 1.728 0.8 13.824 37
I7280 0 7280 1.23684e-05
R8736 7280 0 0.1 49.28 49.28 37
*seg: 729
R8737 0 7281 0.1 49.28 49.28 37
R8738 7285 7295 6.16 0.8 49.28 37
I7281 0 7281 1.23684e-05
R8739 7281 7282 1.744 0.8 13.952 37
I7282 0 7282 1.29868e-05
R8740 7282 7283 1.712 0.8 13.696 37
I7283 0 7283 1.34816e-05
R8741 7283 7284 1.68 0.8 13.44 37
I7284 0 7284 1.28631e-05
R8742 7284 7285 1.728 0.8 13.824 37
I7285 0 7285 1.34816e-05
R8743 7285 7286 1.6 0.8 12.8 37
I7286 0 7286 1.23684e-05
R8744 7286 7287 1.648 0.8 13.184 37
I7287 0 7287 1.33579e-05
R8745 7287 7288 1.616 0.8 12.928 37
I7288 0 7288 1.27395e-05
R8746 7288 7289 1.648 0.8 13.184 37
I7289 0 7289 1.32342e-05
R8747 7289 7290 1.68 0.8 13.44 37
I7290 0 7290 1.23684e-05
R8748 7290 0 0.1 49.28 49.28 37
*seg: 730
R8749 0 7291 0.1 49.28 49.28 37
R8750 7295 7305 6.16 0.8 49.28 37
I7291 0 7291 1.32342e-05
R8751 7291 7292 1.648 0.8 13.184 37
I7292 0 7292 1.33579e-05
R8752 7292 7293 1.696 0.8 13.568 37
I7293 0 7293 1.31105e-05
R8753 7293 7294 1.6 0.8 12.8 37
I7294 0 7294 1.33579e-05
R8754 7294 7295 1.712 0.8 13.696 37
I7295 0 7295 1.26158e-05
R8755 7295 7296 1.616 0.8 12.928 37
I7296 0 7296 1.27395e-05
R8756 7296 7297 1.744 0.8 13.952 37
I7297 0 7297 1.23684e-05
R8757 7297 7298 1.728 0.8 13.824 37
I7298 0 7298 1.27395e-05
R8758 7298 7299 1.664 0.8 13.312 37
I7299 0 7299 1.29868e-05
R8759 7299 7300 1.744 0.8 13.952 37
I7300 0 7300 1.23684e-05
R8760 7300 0 0.1 49.28 49.28 37
*seg: 731
R8761 0 7301 0.1 49.28 49.28 37
R8762 7305 7315 6.16 0.8 49.28 37
I7301 0 7301 1.31105e-05
R8763 7301 7302 1.712 0.8 13.696 37
I7302 0 7302 1.28631e-05
R8764 7302 7303 1.632 0.8 13.056 37
I7303 0 7303 1.32342e-05
R8765 7303 7304 1.648 0.8 13.184 37
I7304 0 7304 1.26158e-05
R8766 7304 7305 1.664 0.8 13.312 37
I7305 0 7305 1.23684e-05
R8767 7305 7306 1.744 0.8 13.952 37
I7306 0 7306 1.32342e-05
R8768 7306 7307 1.616 0.8 12.928 37
I7307 0 7307 1.26158e-05
R8769 7307 7308 1.696 0.8 13.568 37
I7308 0 7308 1.24921e-05
R8770 7308 7309 1.744 0.8 13.952 37
I7309 0 7309 1.28631e-05
R8771 7309 7310 1.648 0.8 13.184 37
I7310 0 7310 1.23684e-05
R8772 7310 0 0.1 49.28 49.28 37
*seg: 732
R8773 0 7311 0.1 49.28 49.28 37
R8774 7315 7325 6.16 0.8 49.28 37
I7311 0 7311 1.28631e-05
R8775 7311 7312 1.68 0.8 13.44 37
I7312 0 7312 1.29868e-05
R8776 7312 7313 1.68 0.8 13.44 37
I7313 0 7313 1.28631e-05
R8777 7313 7314 1.616 0.8 12.928 37
I7314 0 7314 1.27395e-05
R8778 7314 7315 1.664 0.8 13.312 37
I7315 0 7315 1.27395e-05
R8779 7315 7316 1.696 0.8 13.568 37
I7316 0 7316 1.27395e-05
R8780 7316 7317 1.728 0.8 13.824 37
I7317 0 7317 1.27395e-05
R8781 7317 7318 1.728 0.8 13.824 37
I7318 0 7318 1.29868e-05
R8782 7318 7319 1.744 0.8 13.952 37
I7319 0 7319 1.32342e-05
R8783 7319 7320 1.616 0.8 12.928 37
I7320 0 7320 1.23684e-05
R8784 7320 0 0.1 49.28 49.28 37
*seg: 733
R8785 0 7321 0.1 49.28 49.28 37
R8786 7325 7335 6.16 0.8 49.28 37
I7321 0 7321 1.26158e-05
R8787 7321 7322 1.648 0.8 13.184 37
I7322 0 7322 1.33579e-05
R8788 7322 7323 1.728 0.8 13.824 37
I7323 0 7323 1.28631e-05
R8789 7323 7324 1.648 0.8 13.184 37
I7324 0 7324 1.34816e-05
R8790 7324 7325 1.6 0.8 12.8 37
I7325 0 7325 1.24921e-05
R8791 7325 7326 1.664 0.8 13.312 37
I7326 0 7326 1.34816e-05
R8792 7326 7327 1.616 0.8 12.928 37
I7327 0 7327 1.34816e-05
R8793 7327 7328 1.664 0.8 13.312 37
I7328 0 7328 1.34816e-05
R8794 7328 7329 1.616 0.8 12.928 37
I7329 0 7329 1.28631e-05
R8795 7329 7330 1.632 0.8 13.056 37
I7330 0 7330 1.23684e-05
R8796 7330 0 0.1 49.28 49.28 37
*seg: 734
R8797 0 7331 0.1 49.28 49.28 37
R8798 7335 7345 6.16 0.8 49.28 37
I7331 0 7331 1.33579e-05
R8799 7331 7332 1.728 0.8 13.824 37
I7332 0 7332 1.24921e-05
R8800 7332 7333 1.696 0.8 13.568 37
I7333 0 7333 1.26158e-05
R8801 7333 7334 1.616 0.8 12.928 37
I7334 0 7334 1.32342e-05
R8802 7334 7335 1.744 0.8 13.952 37
I7335 0 7335 1.27395e-05
R8803 7335 7336 1.632 0.8 13.056 37
I7336 0 7336 1.33579e-05
R8804 7336 7337 1.68 0.8 13.44 37
I7337 0 7337 1.23684e-05
R8805 7337 7338 1.616 0.8 12.928 37
I7338 0 7338 1.32342e-05
R8806 7338 7339 1.712 0.8 13.696 37
I7339 0 7339 1.31105e-05
R8807 7339 7340 1.6 0.8 12.8 37
I7340 0 7340 1.23684e-05
R8808 7340 0 0.1 49.28 49.28 37
*seg: 735
R8809 0 7341 0.1 49.28 49.28 37
R8810 7345 7355 6.16 0.8 49.28 37
I7341 0 7341 1.26158e-05
R8811 7341 7342 1.68 0.8 13.44 37
I7342 0 7342 1.23684e-05
R8812 7342 7343 1.728 0.8 13.824 37
I7343 0 7343 1.31105e-05
R8813 7343 7344 1.632 0.8 13.056 37
I7344 0 7344 1.31105e-05
R8814 7344 7345 1.664 0.8 13.312 37
I7345 0 7345 1.34816e-05
R8815 7345 7346 1.632 0.8 13.056 37
I7346 0 7346 1.29868e-05
R8816 7346 7347 1.648 0.8 13.184 37
I7347 0 7347 1.23684e-05
R8817 7347 7348 1.728 0.8 13.824 37
I7348 0 7348 1.34816e-05
R8818 7348 7349 1.696 0.8 13.568 37
I7349 0 7349 1.31105e-05
R8819 7349 7350 1.6 0.8 12.8 37
I7350 0 7350 1.23684e-05
R8820 7350 0 0.1 49.28 49.28 37
*seg: 736
R8821 0 7351 0.1 49.28 49.28 37
R8822 7355 7365 6.16 0.8 49.28 37
I7351 0 7351 1.29868e-05
R8823 7351 7352 1.664 0.8 13.312 37
I7352 0 7352 1.27395e-05
R8824 7352 7353 1.712 0.8 13.696 37
I7353 0 7353 1.31105e-05
R8825 7353 7354 1.728 0.8 13.824 37
I7354 0 7354 1.34816e-05
R8826 7354 7355 1.664 0.8 13.312 37
I7355 0 7355 1.31105e-05
R8827 7355 7356 1.68 0.8 13.44 37
I7356 0 7356 1.28631e-05
R8828 7356 7357 1.712 0.8 13.696 37
I7357 0 7357 1.32342e-05
R8829 7357 7358 1.648 0.8 13.184 37
I7358 0 7358 1.31105e-05
R8830 7358 7359 1.744 0.8 13.952 37
I7359 0 7359 1.27395e-05
R8831 7359 7360 1.616 0.8 12.928 37
I7360 0 7360 1.23684e-05
R8832 7360 0 0.1 49.28 49.28 37
*seg: 737
R8833 0 7361 0.1 49.28 49.28 37
R8834 7365 7375 6.16 0.8 49.28 37
I7361 0 7361 1.32342e-05
R8835 7361 7362 1.616 0.8 12.928 37
I7362 0 7362 1.33579e-05
R8836 7362 7363 1.6 0.8 12.8 37
I7363 0 7363 1.34816e-05
R8837 7363 7364 1.6 0.8 12.8 37
I7364 0 7364 1.28631e-05
R8838 7364 7365 1.744 0.8 13.952 37
I7365 0 7365 1.27395e-05
R8839 7365 7366 1.68 0.8 13.44 37
I7366 0 7366 1.33579e-05
R8840 7366 7367 1.648 0.8 13.184 37
I7367 0 7367 1.28631e-05
R8841 7367 7368 1.616 0.8 12.928 37
I7368 0 7368 1.29868e-05
R8842 7368 7369 1.648 0.8 13.184 37
I7369 0 7369 1.24921e-05
R8843 7369 7370 1.68 0.8 13.44 37
I7370 0 7370 1.23684e-05
R8844 7370 0 0.1 49.28 49.28 37
*seg: 738
R8845 0 7371 0.1 49.28 49.28 37
R8846 7375 7385 6.16 0.8 49.28 37
I7371 0 7371 1.29868e-05
R8847 7371 7372 1.728 0.8 13.824 37
I7372 0 7372 1.32342e-05
R8848 7372 7373 1.632 0.8 13.056 37
I7373 0 7373 1.24921e-05
R8849 7373 7374 1.744 0.8 13.952 37
I7374 0 7374 1.24921e-05
R8850 7374 7375 1.696 0.8 13.568 37
I7375 0 7375 1.24921e-05
R8851 7375 7376 1.712 0.8 13.696 37
I7376 0 7376 1.26158e-05
R8852 7376 7377 1.696 0.8 13.568 37
I7377 0 7377 1.23684e-05
R8853 7377 7378 1.712 0.8 13.696 37
I7378 0 7378 1.24921e-05
R8854 7378 7379 1.728 0.8 13.824 37
I7379 0 7379 1.33579e-05
R8855 7379 7380 1.664 0.8 13.312 37
I7380 0 7380 1.23684e-05
R8856 7380 0 0.1 49.28 49.28 37
*seg: 739
R8857 0 7381 0.1 49.28 49.28 37
R8858 7385 7395 6.16 0.8 49.28 37
I7381 0 7381 1.28631e-05
R8859 7381 7382 1.712 0.8 13.696 37
I7382 0 7382 1.27395e-05
R8860 7382 7383 1.728 0.8 13.824 37
I7383 0 7383 1.24921e-05
R8861 7383 7384 1.696 0.8 13.568 37
I7384 0 7384 1.23684e-05
R8862 7384 7385 1.728 0.8 13.824 37
I7385 0 7385 1.34816e-05
R8863 7385 7386 1.632 0.8 13.056 37
I7386 0 7386 1.24921e-05
R8864 7386 7387 1.744 0.8 13.952 37
I7387 0 7387 1.26158e-05
R8865 7387 7388 1.68 0.8 13.44 37
I7388 0 7388 1.28631e-05
R8866 7388 7389 1.632 0.8 13.056 37
I7389 0 7389 1.27395e-05
R8867 7389 7390 1.696 0.8 13.568 37
I7390 0 7390 1.23684e-05
R8868 7390 0 0.1 49.28 49.28 37
*seg: 740
R8869 0 7391 0.1 49.28 49.28 37
R8870 7395 7405 6.16 0.8 49.28 37
I7391 0 7391 1.31105e-05
R8871 7391 7392 1.632 0.8 13.056 37
I7392 0 7392 1.28631e-05
R8872 7392 7393 1.648 0.8 13.184 37
I7393 0 7393 1.23684e-05
R8873 7393 7394 1.744 0.8 13.952 37
I7394 0 7394 1.31105e-05
R8874 7394 7395 1.664 0.8 13.312 37
I7395 0 7395 1.31105e-05
R8875 7395 7396 1.648 0.8 13.184 37
I7396 0 7396 1.23684e-05
R8876 7396 7397 1.632 0.8 13.056 37
I7397 0 7397 1.31105e-05
R8877 7397 7398 1.632 0.8 13.056 37
I7398 0 7398 1.27395e-05
R8878 7398 7399 1.616 0.8 12.928 37
I7399 0 7399 1.29868e-05
R8879 7399 7400 1.6 0.8 12.8 37
I7400 0 7400 1.23684e-05
R8880 7400 0 0.1 49.28 49.28 37
*seg: 741
R8881 0 7401 0.1 49.28 49.28 37
R8882 7405 7415 6.16 0.8 49.28 37
I7401 0 7401 1.28631e-05
R8883 7401 7402 1.712 0.8 13.696 37
I7402 0 7402 1.29868e-05
R8884 7402 7403 1.648 0.8 13.184 37
I7403 0 7403 1.27395e-05
R8885 7403 7404 1.728 0.8 13.824 37
I7404 0 7404 1.32342e-05
R8886 7404 7405 1.728 0.8 13.824 37
I7405 0 7405 1.29868e-05
R8887 7405 7406 1.696 0.8 13.568 37
I7406 0 7406 1.29868e-05
R8888 7406 7407 1.632 0.8 13.056 37
I7407 0 7407 1.32342e-05
R8889 7407 7408 1.648 0.8 13.184 37
I7408 0 7408 1.33579e-05
R8890 7408 7409 1.68 0.8 13.44 37
I7409 0 7409 1.32342e-05
R8891 7409 7410 1.68 0.8 13.44 37
I7410 0 7410 1.23684e-05
R8892 7410 0 0.1 49.28 49.28 37
*seg: 742
R8893 0 7411 0.1 49.28 49.28 37
R8894 7415 7425 6.16 0.8 49.28 37
I7411 0 7411 1.23684e-05
R8895 7411 7412 1.616 0.8 12.928 37
I7412 0 7412 1.33579e-05
R8896 7412 7413 1.6 0.8 12.8 37
I7413 0 7413 1.29868e-05
R8897 7413 7414 1.68 0.8 13.44 37
I7414 0 7414 1.33579e-05
R8898 7414 7415 1.728 0.8 13.824 37
I7415 0 7415 1.34816e-05
R8899 7415 7416 1.744 0.8 13.952 37
I7416 0 7416 1.33579e-05
R8900 7416 7417 1.616 0.8 12.928 37
I7417 0 7417 1.24921e-05
R8901 7417 7418 1.648 0.8 13.184 37
I7418 0 7418 1.23684e-05
R8902 7418 7419 1.648 0.8 13.184 37
I7419 0 7419 1.32342e-05
R8903 7419 7420 1.664 0.8 13.312 37
I7420 0 7420 1.23684e-05
R8904 7420 0 0.1 49.28 49.28 37
*seg: 743
R8905 0 7421 0.1 49.28 49.28 37
R8906 7425 7435 6.16 0.8 49.28 37
I7421 0 7421 1.29868e-05
R8907 7421 7422 1.696 0.8 13.568 37
I7422 0 7422 1.29868e-05
R8908 7422 7423 1.728 0.8 13.824 37
I7423 0 7423 1.27395e-05
R8909 7423 7424 1.616 0.8 12.928 37
I7424 0 7424 1.29868e-05
R8910 7424 7425 1.696 0.8 13.568 37
I7425 0 7425 1.27395e-05
R8911 7425 7426 1.6 0.8 12.8 37
I7426 0 7426 1.34816e-05
R8912 7426 7427 1.664 0.8 13.312 37
I7427 0 7427 1.34816e-05
R8913 7427 7428 1.648 0.8 13.184 37
I7428 0 7428 1.28631e-05
R8914 7428 7429 1.696 0.8 13.568 37
I7429 0 7429 1.27395e-05
R8915 7429 7430 1.696 0.8 13.568 37
I7430 0 7430 1.23684e-05
R8916 7430 0 0.1 49.28 49.28 37
*seg: 744
R8917 0 7431 0.1 49.28 49.28 37
R8918 7435 7445 6.16 0.8 49.28 37
I7431 0 7431 1.28631e-05
R8919 7431 7432 1.712 0.8 13.696 37
I7432 0 7432 1.23684e-05
R8920 7432 7433 1.6 0.8 12.8 37
I7433 0 7433 1.33579e-05
R8921 7433 7434 1.68 0.8 13.44 37
I7434 0 7434 1.29868e-05
R8922 7434 7435 1.744 0.8 13.952 37
I7435 0 7435 1.33579e-05
R8923 7435 7436 1.616 0.8 12.928 37
I7436 0 7436 1.24921e-05
R8924 7436 7437 1.696 0.8 13.568 37
I7437 0 7437 1.29868e-05
R8925 7437 7438 1.6 0.8 12.8 37
I7438 0 7438 1.32342e-05
R8926 7438 7439 1.712 0.8 13.696 37
I7439 0 7439 1.24921e-05
R8927 7439 7440 1.712 0.8 13.696 37
I7440 0 7440 1.23684e-05
R8928 7440 0 0.1 49.28 49.28 37
*seg: 745
R8929 0 7441 0.1 49.28 49.28 37
R8930 7445 7455 6.16 0.8 49.28 37
I7441 0 7441 1.34816e-05
R8931 7441 7442 1.648 0.8 13.184 37
I7442 0 7442 1.27395e-05
R8932 7442 7443 1.616 0.8 12.928 37
I7443 0 7443 1.34816e-05
R8933 7443 7444 1.664 0.8 13.312 37
I7444 0 7444 1.27395e-05
R8934 7444 7445 1.616 0.8 12.928 37
I7445 0 7445 1.34816e-05
R8935 7445 7446 1.744 0.8 13.952 37
I7446 0 7446 1.31105e-05
R8936 7446 7447 1.664 0.8 13.312 37
I7447 0 7447 1.26158e-05
R8937 7447 7448 1.6 0.8 12.8 37
I7448 0 7448 1.28631e-05
R8938 7448 7449 1.712 0.8 13.696 37
I7449 0 7449 1.28631e-05
R8939 7449 7450 1.616 0.8 12.928 37
I7450 0 7450 1.23684e-05
R8940 7450 0 0.1 49.28 49.28 37
*seg: 746
R8941 0 7451 0.1 49.28 49.28 37
R8942 7455 7465 6.16 0.8 49.28 37
I7451 0 7451 1.24921e-05
R8943 7451 7452 1.744 0.8 13.952 37
I7452 0 7452 1.31105e-05
R8944 7452 7453 1.664 0.8 13.312 37
I7453 0 7453 1.31105e-05
R8945 7453 7454 1.664 0.8 13.312 37
I7454 0 7454 1.34816e-05
R8946 7454 7455 1.632 0.8 13.056 37
I7455 0 7455 1.26158e-05
R8947 7455 7456 1.712 0.8 13.696 37
I7456 0 7456 1.29868e-05
R8948 7456 7457 1.712 0.8 13.696 37
I7457 0 7457 1.23684e-05
R8949 7457 7458 1.744 0.8 13.952 37
I7458 0 7458 1.23684e-05
R8950 7458 7459 1.744 0.8 13.952 37
I7459 0 7459 1.26158e-05
R8951 7459 7460 1.616 0.8 12.928 37
I7460 0 7460 1.23684e-05
R8952 7460 0 0.1 49.28 49.28 37
*seg: 747
R8953 0 7461 0.1 49.28 49.28 37
R8954 7465 7475 6.16 0.8 49.28 37
I7461 0 7461 1.27395e-05
R8955 7461 7462 1.664 0.8 13.312 37
I7462 0 7462 1.24921e-05
R8956 7462 7463 1.664 0.8 13.312 37
I7463 0 7463 1.34816e-05
R8957 7463 7464 1.6 0.8 12.8 37
I7464 0 7464 1.24921e-05
R8958 7464 7465 1.664 0.8 13.312 37
I7465 0 7465 1.24921e-05
R8959 7465 7466 1.712 0.8 13.696 37
I7466 0 7466 1.23684e-05
R8960 7466 7467 1.648 0.8 13.184 37
I7467 0 7467 1.34816e-05
R8961 7467 7468 1.6 0.8 12.8 37
I7468 0 7468 1.33579e-05
R8962 7468 7469 1.744 0.8 13.952 37
I7469 0 7469 1.26158e-05
R8963 7469 7470 1.664 0.8 13.312 37
I7470 0 7470 1.23684e-05
R8964 7470 0 0.1 49.28 49.28 37
*seg: 748
R8965 0 7471 0.1 49.28 49.28 37
R8966 7475 7485 6.16 0.8 49.28 37
I7471 0 7471 1.34816e-05
R8967 7471 7472 1.696 0.8 13.568 37
I7472 0 7472 1.24921e-05
R8968 7472 7473 1.712 0.8 13.696 37
I7473 0 7473 1.32342e-05
R8969 7473 7474 1.616 0.8 12.928 37
I7474 0 7474 1.33579e-05
R8970 7474 7475 1.648 0.8 13.184 37
I7475 0 7475 1.26158e-05
R8971 7475 7476 1.728 0.8 13.824 37
I7476 0 7476 1.27395e-05
R8972 7476 7477 1.712 0.8 13.696 37
I7477 0 7477 1.26158e-05
R8973 7477 7478 1.744 0.8 13.952 37
I7478 0 7478 1.31105e-05
R8974 7478 7479 1.68 0.8 13.44 37
I7479 0 7479 1.28631e-05
R8975 7479 7480 1.712 0.8 13.696 37
I7480 0 7480 1.23684e-05
R8976 7480 0 0.1 49.28 49.28 37
*seg: 749
R8977 0 7481 0.1 49.28 49.28 37
R8978 7485 7495 6.16 0.8 49.28 37
I7481 0 7481 1.24921e-05
R8979 7481 7482 1.648 0.8 13.184 37
I7482 0 7482 1.23684e-05
R8980 7482 7483 1.744 0.8 13.952 37
I7483 0 7483 1.23684e-05
R8981 7483 7484 1.632 0.8 13.056 37
I7484 0 7484 1.33579e-05
R8982 7484 7485 1.632 0.8 13.056 37
I7485 0 7485 1.34816e-05
R8983 7485 7486 1.632 0.8 13.056 37
I7486 0 7486 1.26158e-05
R8984 7486 7487 1.664 0.8 13.312 37
I7487 0 7487 1.28631e-05
R8985 7487 7488 1.6 0.8 12.8 37
I7488 0 7488 1.33579e-05
R8986 7488 7489 1.616 0.8 12.928 37
I7489 0 7489 1.28631e-05
R8987 7489 7490 1.68 0.8 13.44 37
I7490 0 7490 1.23684e-05
R8988 7490 0 0.1 49.28 49.28 37
*seg: 750
R8989 0 7491 0.1 49.28 49.28 37
R8990 7495 7505 6.16 0.8 49.28 37
I7491 0 7491 1.26158e-05
R8991 7491 7492 1.696 0.8 13.568 37
I7492 0 7492 1.29868e-05
R8992 7492 7493 1.744 0.8 13.952 37
I7493 0 7493 1.32342e-05
R8993 7493 7494 1.632 0.8 13.056 37
I7494 0 7494 1.27395e-05
R8994 7494 7495 1.696 0.8 13.568 37
I7495 0 7495 1.29868e-05
R8995 7495 7496 1.632 0.8 13.056 37
I7496 0 7496 1.29868e-05
R8996 7496 7497 1.648 0.8 13.184 37
I7497 0 7497 1.33579e-05
R8997 7497 7498 1.68 0.8 13.44 37
I7498 0 7498 1.28631e-05
R8998 7498 7499 1.68 0.8 13.44 37
I7499 0 7499 1.33579e-05
R8999 7499 7500 1.68 0.8 13.44 37
I7500 0 7500 1.23684e-05
R9000 7500 0 0.1 49.28 49.28 37
*seg: 751
R9001 0 7501 0.1 49.28 49.28 37
R9002 7505 7515 6.16 0.8 49.28 37
I7501 0 7501 1.23684e-05
R9003 7501 7502 1.616 0.8 12.928 37
I7502 0 7502 1.33579e-05
R9004 7502 7503 1.712 0.8 13.696 37
I7503 0 7503 1.33579e-05
R9005 7503 7504 1.728 0.8 13.824 37
I7504 0 7504 1.32342e-05
R9006 7504 7505 1.6 0.8 12.8 37
I7505 0 7505 1.24921e-05
R9007 7505 7506 1.648 0.8 13.184 37
I7506 0 7506 1.31105e-05
R9008 7506 7507 1.68 0.8 13.44 37
I7507 0 7507 1.33579e-05
R9009 7507 7508 1.744 0.8 13.952 37
I7508 0 7508 1.33579e-05
R9010 7508 7509 1.744 0.8 13.952 37
I7509 0 7509 1.31105e-05
R9011 7509 7510 1.68 0.8 13.44 37
I7510 0 7510 1.23684e-05
R9012 7510 0 0.1 49.28 49.28 37
*seg: 752
R9013 0 7511 0.1 49.28 49.28 37
R9014 7515 7525 6.16 0.8 49.28 37
I7511 0 7511 1.26158e-05
R9015 7511 7512 1.728 0.8 13.824 37
I7512 0 7512 1.32342e-05
R9016 7512 7513 1.728 0.8 13.824 37
I7513 0 7513 1.32342e-05
R9017 7513 7514 1.728 0.8 13.824 37
I7514 0 7514 1.31105e-05
R9018 7514 7515 1.616 0.8 12.928 37
I7515 0 7515 1.26158e-05
R9019 7515 7516 1.6 0.8 12.8 37
I7516 0 7516 1.28631e-05
R9020 7516 7517 1.616 0.8 12.928 37
I7517 0 7517 1.32342e-05
R9021 7517 7518 1.712 0.8 13.696 37
I7518 0 7518 1.24921e-05
R9022 7518 7519 1.664 0.8 13.312 37
I7519 0 7519 1.26158e-05
R9023 7519 7520 1.696 0.8 13.568 37
I7520 0 7520 1.23684e-05
R9024 7520 0 0.1 49.28 49.28 37
*seg: 753
R9025 0 7521 0.1 49.28 49.28 37
R9026 7525 7535 6.16 0.8 49.28 37
I7521 0 7521 1.27395e-05
R9027 7521 7522 1.712 0.8 13.696 37
I7522 0 7522 1.34816e-05
R9028 7522 7523 1.712 0.8 13.696 37
I7523 0 7523 1.24921e-05
R9029 7523 7524 1.616 0.8 12.928 37
I7524 0 7524 1.28631e-05
R9030 7524 7525 1.616 0.8 12.928 37
I7525 0 7525 1.29868e-05
R9031 7525 7526 1.728 0.8 13.824 37
I7526 0 7526 1.28631e-05
R9032 7526 7527 1.664 0.8 13.312 37
I7527 0 7527 1.29868e-05
R9033 7527 7528 1.696 0.8 13.568 37
I7528 0 7528 1.28631e-05
R9034 7528 7529 1.696 0.8 13.568 37
I7529 0 7529 1.29868e-05
R9035 7529 7530 1.68 0.8 13.44 37
I7530 0 7530 1.23684e-05
R9036 7530 0 0.1 49.28 49.28 37
*seg: 754
R9037 0 7531 0.1 49.28 49.28 37
R9038 7535 7545 6.16 0.8 49.28 37
I7531 0 7531 1.29868e-05
R9039 7531 7532 1.648 0.8 13.184 37
I7532 0 7532 1.27395e-05
R9040 7532 7533 1.632 0.8 13.056 37
I7533 0 7533 1.32342e-05
R9041 7533 7534 1.712 0.8 13.696 37
I7534 0 7534 1.32342e-05
R9042 7534 7535 1.632 0.8 13.056 37
I7535 0 7535 1.34816e-05
R9043 7535 7536 1.648 0.8 13.184 37
I7536 0 7536 1.24921e-05
R9044 7536 7537 1.6 0.8 12.8 37
I7537 0 7537 1.33579e-05
R9045 7537 7538 1.632 0.8 13.056 37
I7538 0 7538 1.33579e-05
R9046 7538 7539 1.664 0.8 13.312 37
I7539 0 7539 1.28631e-05
R9047 7539 7540 1.712 0.8 13.696 37
I7540 0 7540 1.23684e-05
R9048 7540 0 0.1 49.28 49.28 37
*seg: 755
R9049 0 7541 0.1 49.28 49.28 37
R9050 7545 7555 6.16 0.8 49.28 37
I7541 0 7541 1.34816e-05
R9051 7541 7542 1.744 0.8 13.952 37
I7542 0 7542 1.28631e-05
R9052 7542 7543 1.744 0.8 13.952 37
I7543 0 7543 1.23684e-05
R9053 7543 7544 1.664 0.8 13.312 37
I7544 0 7544 1.33579e-05
R9054 7544 7545 1.616 0.8 12.928 37
I7545 0 7545 1.24921e-05
R9055 7545 7546 1.744 0.8 13.952 37
I7546 0 7546 1.34816e-05
R9056 7546 7547 1.68 0.8 13.44 37
I7547 0 7547 1.24921e-05
R9057 7547 7548 1.632 0.8 13.056 37
I7548 0 7548 1.34816e-05
R9058 7548 7549 1.744 0.8 13.952 37
I7549 0 7549 1.32342e-05
R9059 7549 7550 1.712 0.8 13.696 37
I7550 0 7550 1.23684e-05
R9060 7550 0 0.1 49.28 49.28 37
*seg: 756
R9061 0 7551 0.1 49.28 49.28 37
R9062 7555 7565 6.16 0.8 49.28 37
I7551 0 7551 1.31105e-05
R9063 7551 7552 1.6 0.8 12.8 37
I7552 0 7552 1.23684e-05
R9064 7552 7553 1.616 0.8 12.928 37
I7553 0 7553 1.31105e-05
R9065 7553 7554 1.696 0.8 13.568 37
I7554 0 7554 1.32342e-05
R9066 7554 7555 1.744 0.8 13.952 37
I7555 0 7555 1.28631e-05
R9067 7555 7556 1.712 0.8 13.696 37
I7556 0 7556 1.24921e-05
R9068 7556 7557 1.648 0.8 13.184 37
I7557 0 7557 1.34816e-05
R9069 7557 7558 1.664 0.8 13.312 37
I7558 0 7558 1.27395e-05
R9070 7558 7559 1.648 0.8 13.184 37
I7559 0 7559 1.31105e-05
R9071 7559 7560 1.696 0.8 13.568 37
I7560 0 7560 1.23684e-05
R9072 7560 0 0.1 49.28 49.28 37
*seg: 757
R9073 0 7561 0.1 49.28 49.28 37
R9074 7565 7575 6.16 0.8 49.28 37
I7561 0 7561 1.32342e-05
R9075 7561 7562 1.632 0.8 13.056 37
I7562 0 7562 1.28631e-05
R9076 7562 7563 1.648 0.8 13.184 37
I7563 0 7563 1.23684e-05
R9077 7563 7564 1.632 0.8 13.056 37
I7564 0 7564 1.34816e-05
R9078 7564 7565 1.664 0.8 13.312 37
I7565 0 7565 1.34816e-05
R9079 7565 7566 1.696 0.8 13.568 37
I7566 0 7566 1.34816e-05
R9080 7566 7567 1.6 0.8 12.8 37
I7567 0 7567 1.28631e-05
R9081 7567 7568 1.648 0.8 13.184 37
I7568 0 7568 1.24921e-05
R9082 7568 7569 1.728 0.8 13.824 37
I7569 0 7569 1.24921e-05
R9083 7569 7570 1.68 0.8 13.44 37
I7570 0 7570 1.23684e-05
R9084 7570 0 0.1 49.28 49.28 37
*seg: 758
R9085 0 7571 0.1 49.28 49.28 37
R9086 7575 7585 6.16 0.8 49.28 37
I7571 0 7571 1.23684e-05
R9087 7571 7572 1.632 0.8 13.056 37
I7572 0 7572 1.32342e-05
R9088 7572 7573 1.728 0.8 13.824 37
I7573 0 7573 1.27395e-05
R9089 7573 7574 1.68 0.8 13.44 37
I7574 0 7574 1.24921e-05
R9090 7574 7575 1.68 0.8 13.44 37
I7575 0 7575 1.24921e-05
R9091 7575 7576 1.712 0.8 13.696 37
I7576 0 7576 1.32342e-05
R9092 7576 7577 1.664 0.8 13.312 37
I7577 0 7577 1.23684e-05
R9093 7577 7578 1.744 0.8 13.952 37
I7578 0 7578 1.33579e-05
R9094 7578 7579 1.632 0.8 13.056 37
I7579 0 7579 1.32342e-05
R9095 7579 7580 1.696 0.8 13.568 37
I7580 0 7580 1.23684e-05
R9096 7580 0 0.1 49.28 49.28 37
*seg: 759
R9097 0 7581 0.1 49.28 49.28 37
R9098 7585 7595 6.16 0.8 49.28 37
I7581 0 7581 1.26158e-05
R9099 7581 7582 1.616 0.8 12.928 37
I7582 0 7582 1.29868e-05
R9100 7582 7583 1.712 0.8 13.696 37
I7583 0 7583 1.31105e-05
R9101 7583 7584 1.68 0.8 13.44 37
I7584 0 7584 1.32342e-05
R9102 7584 7585 1.616 0.8 12.928 37
I7585 0 7585 1.23684e-05
R9103 7585 7586 1.712 0.8 13.696 37
I7586 0 7586 1.33579e-05
R9104 7586 7587 1.616 0.8 12.928 37
I7587 0 7587 1.29868e-05
R9105 7587 7588 1.648 0.8 13.184 37
I7588 0 7588 1.24921e-05
R9106 7588 7589 1.68 0.8 13.44 37
I7589 0 7589 1.27395e-05
R9107 7589 7590 1.632 0.8 13.056 37
I7590 0 7590 1.23684e-05
R9108 7590 0 0.1 49.28 49.28 37
*seg: 760
R9109 0 7591 0.1 49.28 49.28 37
R9110 7595 7605 6.16 0.8 49.28 37
I7591 0 7591 1.28631e-05
R9111 7591 7592 1.6 0.8 12.8 37
I7592 0 7592 1.28631e-05
R9112 7592 7593 1.6 0.8 12.8 37
I7593 0 7593 1.33579e-05
R9113 7593 7594 1.744 0.8 13.952 37
I7594 0 7594 1.28631e-05
R9114 7594 7595 1.632 0.8 13.056 37
I7595 0 7595 1.23684e-05
R9115 7595 7596 1.728 0.8 13.824 37
I7596 0 7596 1.28631e-05
R9116 7596 7597 1.664 0.8 13.312 37
I7597 0 7597 1.33579e-05
R9117 7597 7598 1.664 0.8 13.312 37
I7598 0 7598 1.24921e-05
R9118 7598 7599 1.648 0.8 13.184 37
I7599 0 7599 1.33579e-05
R9119 7599 7600 1.664 0.8 13.312 37
I7600 0 7600 1.23684e-05
R9120 7600 0 0.1 49.28 49.28 37
*seg: 761
R9121 0 7601 0.1 49.28 49.28 37
R9122 7605 7615 6.16 0.8 49.28 37
I7601 0 7601 1.34816e-05
R9123 7601 7602 1.744 0.8 13.952 37
I7602 0 7602 1.28631e-05
R9124 7602 7603 1.68 0.8 13.44 37
I7603 0 7603 1.33579e-05
R9125 7603 7604 1.696 0.8 13.568 37
I7604 0 7604 1.23684e-05
R9126 7604 7605 1.648 0.8 13.184 37
I7605 0 7605 1.31105e-05
R9127 7605 7606 1.616 0.8 12.928 37
I7606 0 7606 1.24921e-05
R9128 7606 7607 1.744 0.8 13.952 37
I7607 0 7607 1.23684e-05
R9129 7607 7608 1.696 0.8 13.568 37
I7608 0 7608 1.28631e-05
R9130 7608 7609 1.728 0.8 13.824 37
I7609 0 7609 1.31105e-05
R9131 7609 7610 1.712 0.8 13.696 37
I7610 0 7610 1.23684e-05
R9132 7610 0 0.1 49.28 49.28 37
*seg: 762
R9133 0 7611 0.1 49.28 49.28 37
R9134 7615 7625 6.16 0.8 49.28 37
I7611 0 7611 1.28631e-05
R9135 7611 7612 1.728 0.8 13.824 37
I7612 0 7612 1.31105e-05
R9136 7612 7613 1.632 0.8 13.056 37
I7613 0 7613 1.23684e-05
R9137 7613 7614 1.712 0.8 13.696 37
I7614 0 7614 1.29868e-05
R9138 7614 7615 1.664 0.8 13.312 37
I7615 0 7615 1.26158e-05
R9139 7615 7616 1.68 0.8 13.44 37
I7616 0 7616 1.26158e-05
R9140 7616 7617 1.728 0.8 13.824 37
I7617 0 7617 1.24921e-05
R9141 7617 7618 1.632 0.8 13.056 37
I7618 0 7618 1.23684e-05
R9142 7618 7619 1.744 0.8 13.952 37
I7619 0 7619 1.28631e-05
R9143 7619 7620 1.6 0.8 12.8 37
I7620 0 7620 1.23684e-05
R9144 7620 0 0.1 49.28 49.28 37
*seg: 763
R9145 0 7621 0.1 49.28 49.28 37
R9146 7625 7635 6.16 0.8 49.28 37
I7621 0 7621 1.28631e-05
R9147 7621 7622 1.648 0.8 13.184 37
I7622 0 7622 1.31105e-05
R9148 7622 7623 1.712 0.8 13.696 37
I7623 0 7623 1.23684e-05
R9149 7623 7624 1.664 0.8 13.312 37
I7624 0 7624 1.28631e-05
R9150 7624 7625 1.632 0.8 13.056 37
I7625 0 7625 1.26158e-05
R9151 7625 7626 1.648 0.8 13.184 37
I7626 0 7626 1.34816e-05
R9152 7626 7627 1.648 0.8 13.184 37
I7627 0 7627 1.26158e-05
R9153 7627 7628 1.6 0.8 12.8 37
I7628 0 7628 1.27395e-05
R9154 7628 7629 1.616 0.8 12.928 37
I7629 0 7629 1.29868e-05
R9155 7629 7630 1.712 0.8 13.696 37
I7630 0 7630 1.23684e-05
R9156 7630 0 0.1 49.28 49.28 37
*seg: 764
R9157 0 7631 0.1 49.28 49.28 37
R9158 7635 7645 6.16 0.8 49.28 37
I7631 0 7631 1.29868e-05
R9159 7631 7632 1.648 0.8 13.184 37
I7632 0 7632 1.32342e-05
R9160 7632 7633 1.664 0.8 13.312 37
I7633 0 7633 1.24921e-05
R9161 7633 7634 1.648 0.8 13.184 37
I7634 0 7634 1.26158e-05
R9162 7634 7635 1.616 0.8 12.928 37
I7635 0 7635 1.27395e-05
R9163 7635 7636 1.632 0.8 13.056 37
I7636 0 7636 1.27395e-05
R9164 7636 7637 1.632 0.8 13.056 37
I7637 0 7637 1.27395e-05
R9165 7637 7638 1.616 0.8 12.928 37
I7638 0 7638 1.33579e-05
R9166 7638 7639 1.616 0.8 12.928 37
I7639 0 7639 1.32342e-05
R9167 7639 7640 1.744 0.8 13.952 37
I7640 0 7640 1.23684e-05
R9168 7640 0 0.1 49.28 49.28 37
*seg: 765
R9169 0 7641 0.1 49.28 49.28 37
R9170 7645 7655 6.16 0.8 49.28 37
I7641 0 7641 1.28631e-05
R9171 7641 7642 1.696 0.8 13.568 37
I7642 0 7642 1.31105e-05
R9172 7642 7643 1.632 0.8 13.056 37
I7643 0 7643 1.23684e-05
R9173 7643 7644 1.632 0.8 13.056 37
I7644 0 7644 1.26158e-05
R9174 7644 7645 1.712 0.8 13.696 37
I7645 0 7645 1.31105e-05
R9175 7645 7646 1.712 0.8 13.696 37
I7646 0 7646 1.28631e-05
R9176 7646 7647 1.728 0.8 13.824 37
I7647 0 7647 1.34816e-05
R9177 7647 7648 1.728 0.8 13.824 37
I7648 0 7648 1.26158e-05
R9178 7648 7649 1.632 0.8 13.056 37
I7649 0 7649 1.34816e-05
R9179 7649 7650 1.616 0.8 12.928 37
I7650 0 7650 1.23684e-05
R9180 7650 0 0.1 49.28 49.28 37
*seg: 766
R9181 0 7651 0.1 49.28 49.28 37
R9182 7655 7665 6.16 0.8 49.28 37
I7651 0 7651 1.24921e-05
R9183 7651 7652 1.712 0.8 13.696 37
I7652 0 7652 1.34816e-05
R9184 7652 7653 1.744 0.8 13.952 37
I7653 0 7653 1.31105e-05
R9185 7653 7654 1.6 0.8 12.8 37
I7654 0 7654 1.28631e-05
R9186 7654 7655 1.696 0.8 13.568 37
I7655 0 7655 1.24921e-05
R9187 7655 7656 1.664 0.8 13.312 37
I7656 0 7656 1.24921e-05
R9188 7656 7657 1.6 0.8 12.8 37
I7657 0 7657 1.24921e-05
R9189 7657 7658 1.664 0.8 13.312 37
I7658 0 7658 1.28631e-05
R9190 7658 7659 1.744 0.8 13.952 37
I7659 0 7659 1.33579e-05
R9191 7659 7660 1.68 0.8 13.44 37
I7660 0 7660 1.23684e-05
R9192 7660 0 0.1 49.28 49.28 37
*seg: 767
R9193 0 7661 0.1 49.28 49.28 37
R9194 7665 7675 6.16 0.8 49.28 37
I7661 0 7661 1.23684e-05
R9195 7661 7662 1.664 0.8 13.312 37
I7662 0 7662 1.29868e-05
R9196 7662 7663 1.616 0.8 12.928 37
I7663 0 7663 1.24921e-05
R9197 7663 7664 1.664 0.8 13.312 37
I7664 0 7664 1.34816e-05
R9198 7664 7665 1.712 0.8 13.696 37
I7665 0 7665 1.24921e-05
R9199 7665 7666 1.728 0.8 13.824 37
I7666 0 7666 1.26158e-05
R9200 7666 7667 1.68 0.8 13.44 37
I7667 0 7667 1.34816e-05
R9201 7667 7668 1.68 0.8 13.44 37
I7668 0 7668 1.23684e-05
R9202 7668 7669 1.728 0.8 13.824 37
I7669 0 7669 1.32342e-05
R9203 7669 7670 1.648 0.8 13.184 37
I7670 0 7670 1.23684e-05
R9204 7670 0 0.1 49.28 49.28 37
*seg: 768
R9205 0 7671 0.1 49.28 49.28 37
R9206 7675 7685 6.16 0.8 49.28 37
I7671 0 7671 1.23684e-05
R9207 7671 7672 1.616 0.8 12.928 37
I7672 0 7672 1.32342e-05
R9208 7672 7673 1.728 0.8 13.824 37
I7673 0 7673 1.24921e-05
R9209 7673 7674 1.648 0.8 13.184 37
I7674 0 7674 1.31105e-05
R9210 7674 7675 1.616 0.8 12.928 37
I7675 0 7675 1.32342e-05
R9211 7675 7676 1.728 0.8 13.824 37
I7676 0 7676 1.33579e-05
R9212 7676 7677 1.616 0.8 12.928 37
I7677 0 7677 1.24921e-05
R9213 7677 7678 1.632 0.8 13.056 37
I7678 0 7678 1.23684e-05
R9214 7678 7679 1.68 0.8 13.44 37
I7679 0 7679 1.28631e-05
R9215 7679 7680 1.616 0.8 12.928 37
I7680 0 7680 1.23684e-05
R9216 7680 0 0.1 49.28 49.28 37
*seg: 769
R9217 0 7681 0.1 49.28 49.28 37
R9218 7685 7695 6.16 0.8 49.28 37
I7681 0 7681 1.29868e-05
R9219 7681 7682 1.696 0.8 13.568 37
I7682 0 7682 1.31105e-05
R9220 7682 7683 1.632 0.8 13.056 37
I7683 0 7683 1.28631e-05
R9221 7683 7684 1.744 0.8 13.952 37
I7684 0 7684 1.24921e-05
R9222 7684 7685 1.728 0.8 13.824 37
I7685 0 7685 1.23684e-05
R9223 7685 7686 1.68 0.8 13.44 37
I7686 0 7686 1.28631e-05
R9224 7686 7687 1.664 0.8 13.312 37
I7687 0 7687 1.31105e-05
R9225 7687 7688 1.6 0.8 12.8 37
I7688 0 7688 1.28631e-05
R9226 7688 7689 1.68 0.8 13.44 37
I7689 0 7689 1.32342e-05
R9227 7689 7690 1.632 0.8 13.056 37
I7690 0 7690 1.23684e-05
R9228 7690 0 0.1 49.28 49.28 37
*seg: 770
R9229 0 7691 0.1 49.28 49.28 37
R9230 7695 7705 6.16 0.8 49.28 37
I7691 0 7691 1.28631e-05
R9231 7691 7692 1.664 0.8 13.312 37
I7692 0 7692 1.34816e-05
R9232 7692 7693 1.616 0.8 12.928 37
I7693 0 7693 1.28631e-05
R9233 7693 7694 1.728 0.8 13.824 37
I7694 0 7694 1.32342e-05
R9234 7694 7695 1.632 0.8 13.056 37
I7695 0 7695 1.28631e-05
R9235 7695 7696 1.648 0.8 13.184 37
I7696 0 7696 1.34816e-05
R9236 7696 7697 1.632 0.8 13.056 37
I7697 0 7697 1.27395e-05
R9237 7697 7698 1.648 0.8 13.184 37
I7698 0 7698 1.26158e-05
R9238 7698 7699 1.648 0.8 13.184 37
I7699 0 7699 1.31105e-05
R9239 7699 7700 1.648 0.8 13.184 37
I7700 0 7700 1.23684e-05
R9240 7700 0 0.1 49.28 49.28 37
*seg: 771
R9241 0 7701 0.1 49.28 49.28 37
R9242 7705 7715 6.16 0.8 49.28 37
I7701 0 7701 1.31105e-05
R9243 7701 7702 1.696 0.8 13.568 37
I7702 0 7702 1.33579e-05
R9244 7702 7703 1.696 0.8 13.568 37
I7703 0 7703 1.28631e-05
R9245 7703 7704 1.664 0.8 13.312 37
I7704 0 7704 1.27395e-05
R9246 7704 7705 1.664 0.8 13.312 37
I7705 0 7705 1.29868e-05
R9247 7705 7706 1.648 0.8 13.184 37
I7706 0 7706 1.32342e-05
R9248 7706 7707 1.728 0.8 13.824 37
I7707 0 7707 1.27395e-05
R9249 7707 7708 1.696 0.8 13.568 37
I7708 0 7708 1.32342e-05
R9250 7708 7709 1.68 0.8 13.44 37
I7709 0 7709 1.28631e-05
R9251 7709 7710 1.712 0.8 13.696 37
I7710 0 7710 1.23684e-05
R9252 7710 0 0.1 49.28 49.28 37
*seg: 772
R9253 0 7711 0.1 49.28 49.28 37
R9254 7715 7725 6.16 0.8 49.28 37
I7711 0 7711 1.26158e-05
R9255 7711 7712 1.632 0.8 13.056 37
I7712 0 7712 1.26158e-05
R9256 7712 7713 1.744 0.8 13.952 37
I7713 0 7713 1.29868e-05
R9257 7713 7714 1.6 0.8 12.8 37
I7714 0 7714 1.34816e-05
R9258 7714 7715 1.728 0.8 13.824 37
I7715 0 7715 1.32342e-05
R9259 7715 7716 1.648 0.8 13.184 37
I7716 0 7716 1.34816e-05
R9260 7716 7717 1.712 0.8 13.696 37
I7717 0 7717 1.33579e-05
R9261 7717 7718 1.632 0.8 13.056 37
I7718 0 7718 1.29868e-05
R9262 7718 7719 1.744 0.8 13.952 37
I7719 0 7719 1.29868e-05
R9263 7719 7720 1.68 0.8 13.44 37
I7720 0 7720 1.23684e-05
R9264 7720 0 0.1 49.28 49.28 37
*seg: 773
R9265 0 7721 0.1 49.28 49.28 37
R9266 7725 7735 6.16 0.8 49.28 37
I7721 0 7721 1.24921e-05
R9267 7721 7722 1.728 0.8 13.824 37
I7722 0 7722 1.34816e-05
R9268 7722 7723 1.632 0.8 13.056 37
I7723 0 7723 1.34816e-05
R9269 7723 7724 1.712 0.8 13.696 37
I7724 0 7724 1.26158e-05
R9270 7724 7725 1.6 0.8 12.8 37
I7725 0 7725 1.24921e-05
R9271 7725 7726 1.696 0.8 13.568 37
I7726 0 7726 1.28631e-05
R9272 7726 7727 1.648 0.8 13.184 37
I7727 0 7727 1.32342e-05
R9273 7727 7728 1.632 0.8 13.056 37
I7728 0 7728 1.29868e-05
R9274 7728 7729 1.6 0.8 12.8 37
I7729 0 7729 1.31105e-05
R9275 7729 7730 1.744 0.8 13.952 37
I7730 0 7730 1.23684e-05
R9276 7730 0 0.1 49.28 49.28 37
*seg: 774
R9277 0 7731 0.1 49.28 49.28 37
R9278 7735 7745 6.16 0.8 49.28 37
I7731 0 7731 1.33579e-05
R9279 7731 7732 1.648 0.8 13.184 37
I7732 0 7732 1.31105e-05
R9280 7732 7733 1.6 0.8 12.8 37
I7733 0 7733 1.33579e-05
R9281 7733 7734 1.68 0.8 13.44 37
I7734 0 7734 1.23684e-05
R9282 7734 7735 1.728 0.8 13.824 37
I7735 0 7735 1.23684e-05
R9283 7735 7736 1.68 0.8 13.44 37
I7736 0 7736 1.24921e-05
R9284 7736 7737 1.712 0.8 13.696 37
I7737 0 7737 1.28631e-05
R9285 7737 7738 1.616 0.8 12.928 37
I7738 0 7738 1.31105e-05
R9286 7738 7739 1.648 0.8 13.184 37
I7739 0 7739 1.26158e-05
R9287 7739 7740 1.6 0.8 12.8 37
I7740 0 7740 1.23684e-05
R9288 7740 0 0.1 49.28 49.28 37
*seg: 775
R9289 0 7741 0.1 49.28 49.28 37
R9290 7745 7755 6.16 0.8 49.28 37
I7741 0 7741 1.26158e-05
R9291 7741 7742 1.664 0.8 13.312 37
I7742 0 7742 1.29868e-05
R9292 7742 7743 1.744 0.8 13.952 37
I7743 0 7743 1.29868e-05
R9293 7743 7744 1.744 0.8 13.952 37
I7744 0 7744 1.27395e-05
R9294 7744 7745 1.6 0.8 12.8 37
I7745 0 7745 1.28631e-05
R9295 7745 7746 1.6 0.8 12.8 37
I7746 0 7746 1.28631e-05
R9296 7746 7747 1.632 0.8 13.056 37
I7747 0 7747 1.24921e-05
R9297 7747 7748 1.616 0.8 12.928 37
I7748 0 7748 1.28631e-05
R9298 7748 7749 1.728 0.8 13.824 37
I7749 0 7749 1.24921e-05
R9299 7749 7750 1.712 0.8 13.696 37
I7750 0 7750 1.23684e-05
R9300 7750 0 0.1 49.28 49.28 37
*seg: 776
R9301 0 7751 0.1 49.28 49.28 37
R9302 7755 7765 6.16 0.8 49.28 37
I7751 0 7751 1.31105e-05
R9303 7751 7752 1.744 0.8 13.952 37
I7752 0 7752 1.26158e-05
R9304 7752 7753 1.616 0.8 12.928 37
I7753 0 7753 1.33579e-05
R9305 7753 7754 1.648 0.8 13.184 37
I7754 0 7754 1.34816e-05
R9306 7754 7755 1.664 0.8 13.312 37
I7755 0 7755 1.29868e-05
R9307 7755 7756 1.664 0.8 13.312 37
I7756 0 7756 1.24921e-05
R9308 7756 7757 1.728 0.8 13.824 37
I7757 0 7757 1.28631e-05
R9309 7757 7758 1.632 0.8 13.056 37
I7758 0 7758 1.28631e-05
R9310 7758 7759 1.68 0.8 13.44 37
I7759 0 7759 1.31105e-05
R9311 7759 7760 1.712 0.8 13.696 37
I7760 0 7760 1.23684e-05
R9312 7760 0 0.1 49.28 49.28 37
*seg: 777
R9313 0 7761 0.1 49.28 49.28 37
R9314 7765 7775 6.16 0.8 49.28 37
I7761 0 7761 1.31105e-05
R9315 7761 7762 1.648 0.8 13.184 37
I7762 0 7762 1.34816e-05
R9316 7762 7763 1.648 0.8 13.184 37
I7763 0 7763 1.28631e-05
R9317 7763 7764 1.632 0.8 13.056 37
I7764 0 7764 1.28631e-05
R9318 7764 7765 1.6 0.8 12.8 37
I7765 0 7765 1.27395e-05
R9319 7765 7766 1.648 0.8 13.184 37
I7766 0 7766 1.31105e-05
R9320 7766 7767 1.68 0.8 13.44 37
I7767 0 7767 1.24921e-05
R9321 7767 7768 1.6 0.8 12.8 37
I7768 0 7768 1.31105e-05
R9322 7768 7769 1.68 0.8 13.44 37
I7769 0 7769 1.34816e-05
R9323 7769 7770 1.648 0.8 13.184 37
I7770 0 7770 1.23684e-05
R9324 7770 0 0.1 49.28 49.28 37
*seg: 778
R9325 0 7771 0.1 49.28 49.28 37
R9326 7775 7785 6.16 0.8 49.28 37
I7771 0 7771 1.29868e-05
R9327 7771 7772 1.664 0.8 13.312 37
I7772 0 7772 1.28631e-05
R9328 7772 7773 1.616 0.8 12.928 37
I7773 0 7773 1.32342e-05
R9329 7773 7774 1.616 0.8 12.928 37
I7774 0 7774 1.34816e-05
R9330 7774 7775 1.664 0.8 13.312 37
I7775 0 7775 1.31105e-05
R9331 7775 7776 1.632 0.8 13.056 37
I7776 0 7776 1.34816e-05
R9332 7776 7777 1.6 0.8 12.8 37
I7777 0 7777 1.34816e-05
R9333 7777 7778 1.728 0.8 13.824 37
I7778 0 7778 1.26158e-05
R9334 7778 7779 1.648 0.8 13.184 37
I7779 0 7779 1.29868e-05
R9335 7779 7780 1.68 0.8 13.44 37
I7780 0 7780 1.23684e-05
R9336 7780 0 0.1 49.28 49.28 37
*seg: 779
R9337 0 7781 0.1 49.28 49.28 37
R9338 7785 7795 6.16 0.8 49.28 37
I7781 0 7781 1.23684e-05
R9339 7781 7782 1.6 0.8 12.8 37
I7782 0 7782 1.28631e-05
R9340 7782 7783 1.648 0.8 13.184 37
I7783 0 7783 1.28631e-05
R9341 7783 7784 1.632 0.8 13.056 37
I7784 0 7784 1.23684e-05
R9342 7784 7785 1.664 0.8 13.312 37
I7785 0 7785 1.33579e-05
R9343 7785 7786 1.664 0.8 13.312 37
I7786 0 7786 1.34816e-05
R9344 7786 7787 1.6 0.8 12.8 37
I7787 0 7787 1.27395e-05
R9345 7787 7788 1.68 0.8 13.44 37
I7788 0 7788 1.29868e-05
R9346 7788 7789 1.664 0.8 13.312 37
I7789 0 7789 1.26158e-05
R9347 7789 7790 1.744 0.8 13.952 37
I7790 0 7790 1.23684e-05
R9348 7790 0 0.1 49.28 49.28 37
*seg: 780
R9349 0 7791 0.1 49.28 49.28 37
R9350 7795 7805 6.16 0.8 49.28 37
I7791 0 7791 1.28631e-05
R9351 7791 7792 1.664 0.8 13.312 37
I7792 0 7792 1.26158e-05
R9352 7792 7793 1.68 0.8 13.44 37
I7793 0 7793 1.34816e-05
R9353 7793 7794 1.68 0.8 13.44 37
I7794 0 7794 1.27395e-05
R9354 7794 7795 1.68 0.8 13.44 37
I7795 0 7795 1.23684e-05
R9355 7795 7796 1.632 0.8 13.056 37
I7796 0 7796 1.34816e-05
R9356 7796 7797 1.712 0.8 13.696 37
I7797 0 7797 1.27395e-05
R9357 7797 7798 1.696 0.8 13.568 37
I7798 0 7798 1.26158e-05
R9358 7798 7799 1.616 0.8 12.928 37
I7799 0 7799 1.23684e-05
R9359 7799 7800 1.712 0.8 13.696 37
I7800 0 7800 1.23684e-05
R9360 7800 0 0.1 49.28 49.28 37
*seg: 781
R9361 0 7801 0.1 49.28 49.28 37
R9362 7805 7815 6.16 0.8 49.28 37
I7801 0 7801 1.33579e-05
R9363 7801 7802 1.744 0.8 13.952 37
I7802 0 7802 1.29868e-05
R9364 7802 7803 1.712 0.8 13.696 37
I7803 0 7803 1.23684e-05
R9365 7803 7804 1.616 0.8 12.928 37
I7804 0 7804 1.27395e-05
R9366 7804 7805 1.712 0.8 13.696 37
I7805 0 7805 1.29868e-05
R9367 7805 7806 1.728 0.8 13.824 37
I7806 0 7806 1.23684e-05
R9368 7806 7807 1.616 0.8 12.928 37
I7807 0 7807 1.27395e-05
R9369 7807 7808 1.616 0.8 12.928 37
I7808 0 7808 1.31105e-05
R9370 7808 7809 1.664 0.8 13.312 37
I7809 0 7809 1.23684e-05
R9371 7809 7810 1.648 0.8 13.184 37
I7810 0 7810 1.23684e-05
R9372 7810 0 0.1 49.28 49.28 37
*seg: 782
R9373 0 7811 0.1 49.28 49.28 37
R9374 7815 7825 6.16 0.8 49.28 37
I7811 0 7811 1.33579e-05
R9375 7811 7812 1.712 0.8 13.696 37
I7812 0 7812 1.34816e-05
R9376 7812 7813 1.744 0.8 13.952 37
I7813 0 7813 1.34816e-05
R9377 7813 7814 1.6 0.8 12.8 37
I7814 0 7814 1.23684e-05
R9378 7814 7815 1.632 0.8 13.056 37
I7815 0 7815 1.23684e-05
R9379 7815 7816 1.6 0.8 12.8 37
I7816 0 7816 1.23684e-05
R9380 7816 7817 1.616 0.8 12.928 37
I7817 0 7817 1.33579e-05
R9381 7817 7818 1.68 0.8 13.44 37
I7818 0 7818 1.23684e-05
R9382 7818 7819 1.616 0.8 12.928 37
I7819 0 7819 1.33579e-05
R9383 7819 7820 1.632 0.8 13.056 37
I7820 0 7820 1.23684e-05
R9384 7820 0 0.1 49.28 49.28 37
*seg: 783
R9385 0 7821 0.1 49.28 49.28 37
R9386 7825 7835 6.16 0.8 49.28 37
I7821 0 7821 1.34816e-05
R9387 7821 7822 1.632 0.8 13.056 37
I7822 0 7822 1.29868e-05
R9388 7822 7823 1.664 0.8 13.312 37
I7823 0 7823 1.32342e-05
R9389 7823 7824 1.632 0.8 13.056 37
I7824 0 7824 1.26158e-05
R9390 7824 7825 1.616 0.8 12.928 37
I7825 0 7825 1.34816e-05
R9391 7825 7826 1.696 0.8 13.568 37
I7826 0 7826 1.28631e-05
R9392 7826 7827 1.632 0.8 13.056 37
I7827 0 7827 1.28631e-05
R9393 7827 7828 1.68 0.8 13.44 37
I7828 0 7828 1.24921e-05
R9394 7828 7829 1.712 0.8 13.696 37
I7829 0 7829 1.31105e-05
R9395 7829 7830 1.648 0.8 13.184 37
I7830 0 7830 1.23684e-05
R9396 7830 0 0.1 49.28 49.28 37
*seg: 784
R9397 0 7831 0.1 49.28 49.28 37
R9398 7835 7845 6.16 0.8 49.28 37
I7831 0 7831 1.33579e-05
R9399 7831 7832 1.664 0.8 13.312 37
I7832 0 7832 1.27395e-05
R9400 7832 7833 1.712 0.8 13.696 37
I7833 0 7833 1.32342e-05
R9401 7833 7834 1.616 0.8 12.928 37
I7834 0 7834 1.24921e-05
R9402 7834 7835 1.744 0.8 13.952 37
I7835 0 7835 1.28631e-05
R9403 7835 7836 1.648 0.8 13.184 37
I7836 0 7836 1.29868e-05
R9404 7836 7837 1.648 0.8 13.184 37
I7837 0 7837 1.32342e-05
R9405 7837 7838 1.728 0.8 13.824 37
I7838 0 7838 1.29868e-05
R9406 7838 7839 1.648 0.8 13.184 37
I7839 0 7839 1.23684e-05
R9407 7839 7840 1.6 0.8 12.8 37
I7840 0 7840 1.23684e-05
R9408 7840 0 0.1 49.28 49.28 37
*seg: 785
R9409 0 7841 0.1 49.28 49.28 37
R9410 7845 7855 6.16 0.8 49.28 37
I7841 0 7841 1.32342e-05
R9411 7841 7842 1.68 0.8 13.44 37
I7842 0 7842 1.26158e-05
R9412 7842 7843 1.696 0.8 13.568 37
I7843 0 7843 1.29868e-05
R9413 7843 7844 1.728 0.8 13.824 37
I7844 0 7844 1.24921e-05
R9414 7844 7845 1.6 0.8 12.8 37
I7845 0 7845 1.23684e-05
R9415 7845 7846 1.616 0.8 12.928 37
I7846 0 7846 1.34816e-05
R9416 7846 7847 1.632 0.8 13.056 37
I7847 0 7847 1.31105e-05
R9417 7847 7848 1.616 0.8 12.928 37
I7848 0 7848 1.27395e-05
R9418 7848 7849 1.664 0.8 13.312 37
I7849 0 7849 1.32342e-05
R9419 7849 7850 1.68 0.8 13.44 37
I7850 0 7850 1.23684e-05
R9420 7850 0 0.1 49.28 49.28 37
*seg: 786
R9421 0 7851 0.1 49.28 49.28 37
R9422 7855 7865 6.16 0.8 49.28 37
I7851 0 7851 1.28631e-05
R9423 7851 7852 1.648 0.8 13.184 37
I7852 0 7852 1.24921e-05
R9424 7852 7853 1.664 0.8 13.312 37
I7853 0 7853 1.28631e-05
R9425 7853 7854 1.632 0.8 13.056 37
I7854 0 7854 1.23684e-05
R9426 7854 7855 1.616 0.8 12.928 37
I7855 0 7855 1.29868e-05
R9427 7855 7856 1.616 0.8 12.928 37
I7856 0 7856 1.32342e-05
R9428 7856 7857 1.664 0.8 13.312 37
I7857 0 7857 1.33579e-05
R9429 7857 7858 1.616 0.8 12.928 37
I7858 0 7858 1.26158e-05
R9430 7858 7859 1.664 0.8 13.312 37
I7859 0 7859 1.27395e-05
R9431 7859 7860 1.664 0.8 13.312 37
I7860 0 7860 1.23684e-05
R9432 7860 0 0.1 49.28 49.28 37
*seg: 787
R9433 0 7861 0.1 49.28 49.28 37
R9434 7865 7875 6.16 0.8 49.28 37
I7861 0 7861 1.29868e-05
R9435 7861 7862 1.664 0.8 13.312 37
I7862 0 7862 1.32342e-05
R9436 7862 7863 1.648 0.8 13.184 37
I7863 0 7863 1.33579e-05
R9437 7863 7864 1.696 0.8 13.568 37
I7864 0 7864 1.33579e-05
R9438 7864 7865 1.632 0.8 13.056 37
I7865 0 7865 1.29868e-05
R9439 7865 7866 1.68 0.8 13.44 37
I7866 0 7866 1.26158e-05
R9440 7866 7867 1.728 0.8 13.824 37
I7867 0 7867 1.31105e-05
R9441 7867 7868 1.744 0.8 13.952 37
I7868 0 7868 1.33579e-05
R9442 7868 7869 1.616 0.8 12.928 37
I7869 0 7869 1.33579e-05
R9443 7869 7870 1.616 0.8 12.928 37
I7870 0 7870 1.23684e-05
R9444 7870 0 0.1 49.28 49.28 37
*seg: 788
R9445 0 7871 0.1 49.28 49.28 37
R9446 7875 7885 6.16 0.8 49.28 37
I7871 0 7871 1.31105e-05
R9447 7871 7872 1.696 0.8 13.568 37
I7872 0 7872 1.23684e-05
R9448 7872 7873 1.744 0.8 13.952 37
I7873 0 7873 1.27395e-05
R9449 7873 7874 1.648 0.8 13.184 37
I7874 0 7874 1.31105e-05
R9450 7874 7875 1.728 0.8 13.824 37
I7875 0 7875 1.29868e-05
R9451 7875 7876 1.744 0.8 13.952 37
I7876 0 7876 1.28631e-05
R9452 7876 7877 1.712 0.8 13.696 37
I7877 0 7877 1.29868e-05
R9453 7877 7878 1.728 0.8 13.824 37
I7878 0 7878 1.24921e-05
R9454 7878 7879 1.712 0.8 13.696 37
I7879 0 7879 1.32342e-05
R9455 7879 7880 1.664 0.8 13.312 37
I7880 0 7880 1.23684e-05
R9456 7880 0 0.1 49.28 49.28 37
*seg: 789
R9457 0 7881 0.1 49.28 49.28 37
R9458 7885 7895 6.16 0.8 49.28 37
I7881 0 7881 1.32342e-05
R9459 7881 7882 1.68 0.8 13.44 37
I7882 0 7882 1.26158e-05
R9460 7882 7883 1.712 0.8 13.696 37
I7883 0 7883 1.28631e-05
R9461 7883 7884 1.664 0.8 13.312 37
I7884 0 7884 1.33579e-05
R9462 7884 7885 1.632 0.8 13.056 37
I7885 0 7885 1.23684e-05
R9463 7885 7886 1.664 0.8 13.312 37
I7886 0 7886 1.33579e-05
R9464 7886 7887 1.664 0.8 13.312 37
I7887 0 7887 1.27395e-05
R9465 7887 7888 1.744 0.8 13.952 37
I7888 0 7888 1.23684e-05
R9466 7888 7889 1.68 0.8 13.44 37
I7889 0 7889 1.29868e-05
R9467 7889 7890 1.696 0.8 13.568 37
I7890 0 7890 1.23684e-05
R9468 7890 0 0.1 49.28 49.28 37
*seg: 790
R9469 0 7891 0.1 49.28 49.28 37
R9470 7895 7905 6.16 0.8 49.28 37
I7891 0 7891 1.27395e-05
R9471 7891 7892 1.632 0.8 13.056 37
I7892 0 7892 1.28631e-05
R9472 7892 7893 1.632 0.8 13.056 37
I7893 0 7893 1.31105e-05
R9473 7893 7894 1.632 0.8 13.056 37
I7894 0 7894 1.24921e-05
R9474 7894 7895 1.616 0.8 12.928 37
I7895 0 7895 1.23684e-05
R9475 7895 7896 1.728 0.8 13.824 37
I7896 0 7896 1.23684e-05
R9476 7896 7897 1.696 0.8 13.568 37
I7897 0 7897 1.23684e-05
R9477 7897 7898 1.632 0.8 13.056 37
I7898 0 7898 1.24921e-05
R9478 7898 7899 1.744 0.8 13.952 37
I7899 0 7899 1.24921e-05
R9479 7899 7900 1.712 0.8 13.696 37
I7900 0 7900 1.23684e-05
R9480 7900 0 0.1 49.28 49.28 37
*seg: 791
R9481 0 7901 0.1 49.28 49.28 37
R9482 7905 7915 6.16 0.8 49.28 37
I7901 0 7901 1.32342e-05
R9483 7901 7902 1.696 0.8 13.568 37
I7902 0 7902 1.23684e-05
R9484 7902 7903 1.6 0.8 12.8 37
I7903 0 7903 1.23684e-05
R9485 7903 7904 1.712 0.8 13.696 37
I7904 0 7904 1.28631e-05
R9486 7904 7905 1.728 0.8 13.824 37
I7905 0 7905 1.26158e-05
R9487 7905 7906 1.728 0.8 13.824 37
I7906 0 7906 1.31105e-05
R9488 7906 7907 1.664 0.8 13.312 37
I7907 0 7907 1.34816e-05
R9489 7907 7908 1.632 0.8 13.056 37
I7908 0 7908 1.28631e-05
R9490 7908 7909 1.664 0.8 13.312 37
I7909 0 7909 1.24921e-05
R9491 7909 7910 1.696 0.8 13.568 37
I7910 0 7910 1.23684e-05
R9492 7910 0 0.1 49.28 49.28 37
*seg: 792
R9493 0 7911 0.1 49.28 49.28 37
R9494 7915 7925 6.16 0.8 49.28 37
I7911 0 7911 1.33579e-05
R9495 7911 7912 1.616 0.8 12.928 37
I7912 0 7912 1.28631e-05
R9496 7912 7913 1.648 0.8 13.184 37
I7913 0 7913 1.33579e-05
R9497 7913 7914 1.616 0.8 12.928 37
I7914 0 7914 1.31105e-05
R9498 7914 7915 1.632 0.8 13.056 37
I7915 0 7915 1.23684e-05
R9499 7915 7916 1.6 0.8 12.8 37
I7916 0 7916 1.33579e-05
R9500 7916 7917 1.648 0.8 13.184 37
I7917 0 7917 1.28631e-05
R9501 7917 7918 1.664 0.8 13.312 37
I7918 0 7918 1.23684e-05
R9502 7918 7919 1.6 0.8 12.8 37
I7919 0 7919 1.27395e-05
R9503 7919 7920 1.632 0.8 13.056 37
I7920 0 7920 1.23684e-05
R9504 7920 0 0.1 49.28 49.28 37
*seg: 793
R9505 0 7921 0.1 49.28 49.28 37
R9506 7925 7935 6.16 0.8 49.28 37
I7921 0 7921 1.23684e-05
R9507 7921 7922 1.696 0.8 13.568 37
I7922 0 7922 1.27395e-05
R9508 7922 7923 1.6 0.8 12.8 37
I7923 0 7923 1.32342e-05
R9509 7923 7924 1.68 0.8 13.44 37
I7924 0 7924 1.31105e-05
R9510 7924 7925 1.744 0.8 13.952 37
I7925 0 7925 1.23684e-05
R9511 7925 7926 1.696 0.8 13.568 37
I7926 0 7926 1.34816e-05
R9512 7926 7927 1.696 0.8 13.568 37
I7927 0 7927 1.34816e-05
R9513 7927 7928 1.632 0.8 13.056 37
I7928 0 7928 1.33579e-05
R9514 7928 7929 1.632 0.8 13.056 37
I7929 0 7929 1.29868e-05
R9515 7929 7930 1.632 0.8 13.056 37
I7930 0 7930 1.23684e-05
R9516 7930 0 0.1 49.28 49.28 37
*seg: 794
R9517 0 7931 0.1 49.28 49.28 37
R9518 7935 7945 6.16 0.8 49.28 37
I7931 0 7931 1.26158e-05
R9519 7931 7932 1.68 0.8 13.44 37
I7932 0 7932 1.31105e-05
R9520 7932 7933 1.696 0.8 13.568 37
I7933 0 7933 1.23684e-05
R9521 7933 7934 1.728 0.8 13.824 37
I7934 0 7934 1.34816e-05
R9522 7934 7935 1.68 0.8 13.44 37
I7935 0 7935 1.32342e-05
R9523 7935 7936 1.664 0.8 13.312 37
I7936 0 7936 1.33579e-05
R9524 7936 7937 1.712 0.8 13.696 37
I7937 0 7937 1.29868e-05
R9525 7937 7938 1.68 0.8 13.44 37
I7938 0 7938 1.27395e-05
R9526 7938 7939 1.6 0.8 12.8 37
I7939 0 7939 1.26158e-05
R9527 7939 7940 1.632 0.8 13.056 37
I7940 0 7940 1.23684e-05
R9528 7940 0 0.1 49.28 49.28 37
*seg: 795
R9529 0 7941 0.1 49.28 49.28 37
R9530 7945 7955 6.16 0.8 49.28 37
I7941 0 7941 1.34816e-05
R9531 7941 7942 1.728 0.8 13.824 37
I7942 0 7942 1.27395e-05
R9532 7942 7943 1.648 0.8 13.184 37
I7943 0 7943 1.24921e-05
R9533 7943 7944 1.712 0.8 13.696 37
I7944 0 7944 1.31105e-05
R9534 7944 7945 1.712 0.8 13.696 37
I7945 0 7945 1.32342e-05
R9535 7945 7946 1.744 0.8 13.952 37
I7946 0 7946 1.34816e-05
R9536 7946 7947 1.664 0.8 13.312 37
I7947 0 7947 1.32342e-05
R9537 7947 7948 1.68 0.8 13.44 37
I7948 0 7948 1.33579e-05
R9538 7948 7949 1.744 0.8 13.952 37
I7949 0 7949 1.28631e-05
R9539 7949 7950 1.616 0.8 12.928 37
I7950 0 7950 1.23684e-05
R9540 7950 0 0.1 49.28 49.28 37
*seg: 796
R9541 0 7951 0.1 49.28 49.28 37
R9542 7955 7965 6.16 0.8 49.28 37
I7951 0 7951 1.28631e-05
R9543 7951 7952 1.616 0.8 12.928 37
I7952 0 7952 1.23684e-05
R9544 7952 7953 1.664 0.8 13.312 37
I7953 0 7953 1.33579e-05
R9545 7953 7954 1.68 0.8 13.44 37
I7954 0 7954 1.27395e-05
R9546 7954 7955 1.664 0.8 13.312 37
I7955 0 7955 1.33579e-05
R9547 7955 7956 1.744 0.8 13.952 37
I7956 0 7956 1.34816e-05
R9548 7956 7957 1.712 0.8 13.696 37
I7957 0 7957 1.24921e-05
R9549 7957 7958 1.632 0.8 13.056 37
I7958 0 7958 1.31105e-05
R9550 7958 7959 1.6 0.8 12.8 37
I7959 0 7959 1.28631e-05
R9551 7959 7960 1.664 0.8 13.312 37
I7960 0 7960 1.23684e-05
R9552 7960 0 0.1 49.28 49.28 37
*seg: 797
R9553 0 7961 0.1 49.28 49.28 37
R9554 7965 7975 6.16 0.8 49.28 37
I7961 0 7961 1.32342e-05
R9555 7961 7962 1.664 0.8 13.312 37
I7962 0 7962 1.31105e-05
R9556 7962 7963 1.68 0.8 13.44 37
I7963 0 7963 1.33579e-05
R9557 7963 7964 1.68 0.8 13.44 37
I7964 0 7964 1.32342e-05
R9558 7964 7965 1.68 0.8 13.44 37
I7965 0 7965 1.31105e-05
R9559 7965 7966 1.632 0.8 13.056 37
I7966 0 7966 1.33579e-05
R9560 7966 7967 1.744 0.8 13.952 37
I7967 0 7967 1.26158e-05
R9561 7967 7968 1.664 0.8 13.312 37
I7968 0 7968 1.29868e-05
R9562 7968 7969 1.648 0.8 13.184 37
I7969 0 7969 1.23684e-05
R9563 7969 7970 1.696 0.8 13.568 37
I7970 0 7970 1.23684e-05
R9564 7970 0 0.1 49.28 49.28 37
*seg: 798
R9565 0 7971 0.1 49.28 49.28 37
R9566 7975 7985 6.16 0.8 49.28 37
I7971 0 7971 1.31105e-05
R9567 7971 7972 1.696 0.8 13.568 37
I7972 0 7972 1.23684e-05
R9568 7972 7973 1.632 0.8 13.056 37
I7973 0 7973 1.34816e-05
R9569 7973 7974 1.696 0.8 13.568 37
I7974 0 7974 1.31105e-05
R9570 7974 7975 1.648 0.8 13.184 37
I7975 0 7975 1.28631e-05
R9571 7975 7976 1.664 0.8 13.312 37
I7976 0 7976 1.24921e-05
R9572 7976 7977 1.648 0.8 13.184 37
I7977 0 7977 1.23684e-05
R9573 7977 7978 1.68 0.8 13.44 37
I7978 0 7978 1.31105e-05
R9574 7978 7979 1.728 0.8 13.824 37
I7979 0 7979 1.34816e-05
R9575 7979 7980 1.616 0.8 12.928 37
I7980 0 7980 1.23684e-05
R9576 7980 0 0.1 49.28 49.28 37
*seg: 799
R9577 0 7981 0.1 49.28 49.28 37
R9578 7985 7995 6.16 0.8 49.28 37
I7981 0 7981 1.31105e-05
R9579 7981 7982 1.68 0.8 13.44 37
I7982 0 7982 1.33579e-05
R9580 7982 7983 1.696 0.8 13.568 37
I7983 0 7983 1.23684e-05
R9581 7983 7984 1.728 0.8 13.824 37
I7984 0 7984 1.24921e-05
R9582 7984 7985 1.744 0.8 13.952 37
I7985 0 7985 1.34816e-05
R9583 7985 7986 1.6 0.8 12.8 37
I7986 0 7986 1.33579e-05
R9584 7986 7987 1.6 0.8 12.8 37
I7987 0 7987 1.27395e-05
R9585 7987 7988 1.712 0.8 13.696 37
I7988 0 7988 1.28631e-05
R9586 7988 7989 1.648 0.8 13.184 37
I7989 0 7989 1.27395e-05
R9587 7989 7990 1.632 0.8 13.056 37
I7990 0 7990 1.23684e-05
R9588 7990 0 0.1 49.28 49.28 37
*seg: 800
R9589 0 7991 0.1 49.28 49.28 37
R9590 7995 8005 6.16 0.8 49.28 37
I7991 0 7991 1.34816e-05
R9591 7991 7992 1.696 0.8 13.568 37
I7992 0 7992 1.34816e-05
R9592 7992 7993 1.744 0.8 13.952 37
I7993 0 7993 1.23684e-05
R9593 7993 7994 1.728 0.8 13.824 37
I7994 0 7994 1.31105e-05
R9594 7994 7995 1.728 0.8 13.824 37
I7995 0 7995 1.32342e-05
R9595 7995 7996 1.632 0.8 13.056 37
I7996 0 7996 1.28631e-05
R9596 7996 7997 1.664 0.8 13.312 37
I7997 0 7997 1.27395e-05
R9597 7997 7998 1.744 0.8 13.952 37
I7998 0 7998 1.34816e-05
R9598 7998 7999 1.712 0.8 13.696 37
I7999 0 7999 1.27395e-05
R9599 7999 8000 1.712 0.8 13.696 37
I8000 0 8000 1.23684e-05
R9600 8000 0 0.1 49.28 49.28 37
*seg: 801
R9601 0 8001 0.1 49.28 49.28 37
R9602 8005 8015 6.16 0.8 49.28 37
I8001 0 8001 1.26158e-05
R9603 8001 8002 1.712 0.8 13.696 37
I8002 0 8002 1.31105e-05
R9604 8002 8003 1.728 0.8 13.824 37
I8003 0 8003 1.34816e-05
R9605 8003 8004 1.712 0.8 13.696 37
I8004 0 8004 1.32342e-05
R9606 8004 8005 1.728 0.8 13.824 37
I8005 0 8005 1.29868e-05
R9607 8005 8006 1.632 0.8 13.056 37
I8006 0 8006 1.28631e-05
R9608 8006 8007 1.632 0.8 13.056 37
I8007 0 8007 1.23684e-05
R9609 8007 8008 1.616 0.8 12.928 37
I8008 0 8008 1.34816e-05
R9610 8008 8009 1.712 0.8 13.696 37
I8009 0 8009 1.33579e-05
R9611 8009 8010 1.6 0.8 12.8 37
I8010 0 8010 1.23684e-05
R9612 8010 0 0.1 49.28 49.28 37
*seg: 802
R9613 0 8011 0.1 49.28 49.28 37
R9614 8015 8025 6.16 0.8 49.28 37
I8011 0 8011 1.28631e-05
R9615 8011 8012 1.712 0.8 13.696 37
I8012 0 8012 1.24921e-05
R9616 8012 8013 1.728 0.8 13.824 37
I8013 0 8013 1.29868e-05
R9617 8013 8014 1.712 0.8 13.696 37
I8014 0 8014 1.31105e-05
R9618 8014 8015 1.728 0.8 13.824 37
I8015 0 8015 1.31105e-05
R9619 8015 8016 1.68 0.8 13.44 37
I8016 0 8016 1.27395e-05
R9620 8016 8017 1.712 0.8 13.696 37
I8017 0 8017 1.24921e-05
R9621 8017 8018 1.6 0.8 12.8 37
I8018 0 8018 1.26158e-05
R9622 8018 8019 1.6 0.8 12.8 37
I8019 0 8019 1.24921e-05
R9623 8019 8020 1.696 0.8 13.568 37
I8020 0 8020 1.23684e-05
R9624 8020 0 0.1 49.28 49.28 37
*seg: 803
R9625 0 8021 0.1 49.28 49.28 37
R9626 8025 8035 6.16 0.8 49.28 37
I8021 0 8021 1.24921e-05
R9627 8021 8022 1.6 0.8 12.8 37
I8022 0 8022 1.24921e-05
R9628 8022 8023 1.68 0.8 13.44 37
I8023 0 8023 1.29868e-05
R9629 8023 8024 1.6 0.8 12.8 37
I8024 0 8024 1.32342e-05
R9630 8024 8025 1.744 0.8 13.952 37
I8025 0 8025 1.31105e-05
R9631 8025 8026 1.712 0.8 13.696 37
I8026 0 8026 1.32342e-05
R9632 8026 8027 1.648 0.8 13.184 37
I8027 0 8027 1.29868e-05
R9633 8027 8028 1.6 0.8 12.8 37
I8028 0 8028 1.24921e-05
R9634 8028 8029 1.712 0.8 13.696 37
I8029 0 8029 1.27395e-05
R9635 8029 8030 1.68 0.8 13.44 37
I8030 0 8030 1.23684e-05
R9636 8030 0 0.1 49.28 49.28 37
*seg: 804
R9637 0 8031 0.1 49.28 49.28 37
R9638 8035 8045 6.16 0.8 49.28 37
I8031 0 8031 1.34816e-05
R9639 8031 8032 1.696 0.8 13.568 37
I8032 0 8032 1.31105e-05
R9640 8032 8033 1.68 0.8 13.44 37
I8033 0 8033 1.34816e-05
R9641 8033 8034 1.744 0.8 13.952 37
I8034 0 8034 1.29868e-05
R9642 8034 8035 1.696 0.8 13.568 37
I8035 0 8035 1.26158e-05
R9643 8035 8036 1.728 0.8 13.824 37
I8036 0 8036 1.32342e-05
R9644 8036 8037 1.744 0.8 13.952 37
I8037 0 8037 1.33579e-05
R9645 8037 8038 1.6 0.8 12.8 37
I8038 0 8038 1.34816e-05
R9646 8038 8039 1.728 0.8 13.824 37
I8039 0 8039 1.32342e-05
R9647 8039 8040 1.68 0.8 13.44 37
I8040 0 8040 1.23684e-05
R9648 8040 0 0.1 49.28 49.28 37
*seg: 805
R9649 0 8041 0.1 49.28 49.28 37
R9650 8045 8055 6.16 0.8 49.28 37
I8041 0 8041 1.27395e-05
R9651 8041 8042 1.696 0.8 13.568 37
I8042 0 8042 1.27395e-05
R9652 8042 8043 1.664 0.8 13.312 37
I8043 0 8043 1.29868e-05
R9653 8043 8044 1.712 0.8 13.696 37
I8044 0 8044 1.34816e-05
R9654 8044 8045 1.728 0.8 13.824 37
I8045 0 8045 1.26158e-05
R9655 8045 8046 1.616 0.8 12.928 37
I8046 0 8046 1.24921e-05
R9656 8046 8047 1.648 0.8 13.184 37
I8047 0 8047 1.23684e-05
R9657 8047 8048 1.632 0.8 13.056 37
I8048 0 8048 1.23684e-05
R9658 8048 8049 1.712 0.8 13.696 37
I8049 0 8049 1.31105e-05
R9659 8049 8050 1.712 0.8 13.696 37
I8050 0 8050 1.23684e-05
R9660 8050 0 0.1 49.28 49.28 37
*seg: 806
R9661 0 8051 0.1 49.28 49.28 37
R9662 8055 8065 6.16 0.8 49.28 37
I8051 0 8051 1.33579e-05
R9663 8051 8052 1.712 0.8 13.696 37
I8052 0 8052 1.27395e-05
R9664 8052 8053 1.68 0.8 13.44 37
I8053 0 8053 1.27395e-05
R9665 8053 8054 1.728 0.8 13.824 37
I8054 0 8054 1.27395e-05
R9666 8054 8055 1.68 0.8 13.44 37
I8055 0 8055 1.26158e-05
R9667 8055 8056 1.616 0.8 12.928 37
I8056 0 8056 1.29868e-05
R9668 8056 8057 1.664 0.8 13.312 37
I8057 0 8057 1.29868e-05
R9669 8057 8058 1.632 0.8 13.056 37
I8058 0 8058 1.27395e-05
R9670 8058 8059 1.648 0.8 13.184 37
I8059 0 8059 1.27395e-05
R9671 8059 8060 1.68 0.8 13.44 37
I8060 0 8060 1.23684e-05
R9672 8060 0 0.1 49.28 49.28 37
*seg: 807
R9673 0 8061 0.1 49.28 49.28 37
R9674 8065 8075 6.16 0.8 49.28 37
I8061 0 8061 1.34816e-05
R9675 8061 8062 1.648 0.8 13.184 37
I8062 0 8062 1.32342e-05
R9676 8062 8063 1.6 0.8 12.8 37
I8063 0 8063 1.28631e-05
R9677 8063 8064 1.696 0.8 13.568 37
I8064 0 8064 1.31105e-05
R9678 8064 8065 1.728 0.8 13.824 37
I8065 0 8065 1.27395e-05
R9679 8065 8066 1.616 0.8 12.928 37
I8066 0 8066 1.24921e-05
R9680 8066 8067 1.616 0.8 12.928 37
I8067 0 8067 1.28631e-05
R9681 8067 8068 1.664 0.8 13.312 37
I8068 0 8068 1.27395e-05
R9682 8068 8069 1.648 0.8 13.184 37
I8069 0 8069 1.32342e-05
R9683 8069 8070 1.6 0.8 12.8 37
I8070 0 8070 1.23684e-05
R9684 8070 0 0.1 49.28 49.28 37
*seg: 808
R9685 0 8071 0.1 49.28 49.28 37
R9686 8075 8085 6.16 0.8 49.28 37
I8071 0 8071 1.27395e-05
R9687 8071 8072 1.728 0.8 13.824 37
I8072 0 8072 1.26158e-05
R9688 8072 8073 1.648 0.8 13.184 37
I8073 0 8073 1.24921e-05
R9689 8073 8074 1.68 0.8 13.44 37
I8074 0 8074 1.26158e-05
R9690 8074 8075 1.712 0.8 13.696 37
I8075 0 8075 1.32342e-05
R9691 8075 8076 1.664 0.8 13.312 37
I8076 0 8076 1.33579e-05
R9692 8076 8077 1.648 0.8 13.184 37
I8077 0 8077 1.33579e-05
R9693 8077 8078 1.696 0.8 13.568 37
I8078 0 8078 1.34816e-05
R9694 8078 8079 1.744 0.8 13.952 37
I8079 0 8079 1.32342e-05
R9695 8079 8080 1.744 0.8 13.952 37
I8080 0 8080 1.23684e-05
R9696 8080 0 0.1 49.28 49.28 37
*seg: 809
R9697 0 8081 0.1 49.28 49.28 37
R9698 8085 8095 6.16 0.8 49.28 37
I8081 0 8081 1.28631e-05
R9699 8081 8082 1.648 0.8 13.184 37
I8082 0 8082 1.23684e-05
R9700 8082 8083 1.632 0.8 13.056 37
I8083 0 8083 1.31105e-05
R9701 8083 8084 1.712 0.8 13.696 37
I8084 0 8084 1.26158e-05
R9702 8084 8085 1.632 0.8 13.056 37
I8085 0 8085 1.32342e-05
R9703 8085 8086 1.68 0.8 13.44 37
I8086 0 8086 1.34816e-05
R9704 8086 8087 1.712 0.8 13.696 37
I8087 0 8087 1.23684e-05
R9705 8087 8088 1.616 0.8 12.928 37
I8088 0 8088 1.33579e-05
R9706 8088 8089 1.744 0.8 13.952 37
I8089 0 8089 1.24921e-05
R9707 8089 8090 1.632 0.8 13.056 37
I8090 0 8090 1.23684e-05
R9708 8090 0 0.1 49.28 49.28 37
*seg: 810
R9709 0 8091 0.1 49.28 49.28 37
R9710 8095 8105 6.16 0.8 49.28 37
I8091 0 8091 1.24921e-05
R9711 8091 8092 1.696 0.8 13.568 37
I8092 0 8092 1.31105e-05
R9712 8092 8093 1.664 0.8 13.312 37
I8093 0 8093 1.29868e-05
R9713 8093 8094 1.632 0.8 13.056 37
I8094 0 8094 1.32342e-05
R9714 8094 8095 1.632 0.8 13.056 37
I8095 0 8095 1.33579e-05
R9715 8095 8096 1.664 0.8 13.312 37
I8096 0 8096 1.34816e-05
R9716 8096 8097 1.696 0.8 13.568 37
I8097 0 8097 1.34816e-05
R9717 8097 8098 1.728 0.8 13.824 37
I8098 0 8098 1.31105e-05
R9718 8098 8099 1.744 0.8 13.952 37
I8099 0 8099 1.29868e-05
R9719 8099 8100 1.616 0.8 12.928 37
I8100 0 8100 1.23684e-05
R9720 8100 0 0.1 49.28 49.28 37
*seg: 811
R9721 0 8101 0.1 49.28 49.28 37
R9722 8105 8115 6.16 0.8 49.28 37
I8101 0 8101 1.29868e-05
R9723 8101 8102 1.728 0.8 13.824 37
I8102 0 8102 1.32342e-05
R9724 8102 8103 1.696 0.8 13.568 37
I8103 0 8103 1.23684e-05
R9725 8103 8104 1.712 0.8 13.696 37
I8104 0 8104 1.32342e-05
R9726 8104 8105 1.696 0.8 13.568 37
I8105 0 8105 1.32342e-05
R9727 8105 8106 1.744 0.8 13.952 37
I8106 0 8106 1.34816e-05
R9728 8106 8107 1.712 0.8 13.696 37
I8107 0 8107 1.33579e-05
R9729 8107 8108 1.648 0.8 13.184 37
I8108 0 8108 1.28631e-05
R9730 8108 8109 1.696 0.8 13.568 37
I8109 0 8109 1.23684e-05
R9731 8109 8110 1.632 0.8 13.056 37
I8110 0 8110 1.23684e-05
R9732 8110 0 0.1 49.28 49.28 37
*seg: 812
R9733 0 8111 0.1 49.28 49.28 37
R9734 8115 8125 6.16 0.8 49.28 37
I8111 0 8111 1.34816e-05
R9735 8111 8112 1.696 0.8 13.568 37
I8112 0 8112 1.31105e-05
R9736 8112 8113 1.648 0.8 13.184 37
I8113 0 8113 1.23684e-05
R9737 8113 8114 1.648 0.8 13.184 37
I8114 0 8114 1.29868e-05
R9738 8114 8115 1.648 0.8 13.184 37
I8115 0 8115 1.33579e-05
R9739 8115 8116 1.648 0.8 13.184 37
I8116 0 8116 1.31105e-05
R9740 8116 8117 1.648 0.8 13.184 37
I8117 0 8117 1.32342e-05
R9741 8117 8118 1.712 0.8 13.696 37
I8118 0 8118 1.34816e-05
R9742 8118 8119 1.744 0.8 13.952 37
I8119 0 8119 1.28631e-05
R9743 8119 8120 1.664 0.8 13.312 37
I8120 0 8120 1.23684e-05
R9744 8120 0 0.1 49.28 49.28 37
*seg: 813
R9745 0 8121 0.1 49.28 49.28 37
R9746 8125 8135 6.16 0.8 49.28 37
I8121 0 8121 1.34816e-05
R9747 8121 8122 1.744 0.8 13.952 37
I8122 0 8122 1.24921e-05
R9748 8122 8123 1.6 0.8 12.8 37
I8123 0 8123 1.31105e-05
R9749 8123 8124 1.664 0.8 13.312 37
I8124 0 8124 1.24921e-05
R9750 8124 8125 1.728 0.8 13.824 37
I8125 0 8125 1.29868e-05
R9751 8125 8126 1.664 0.8 13.312 37
I8126 0 8126 1.27395e-05
R9752 8126 8127 1.648 0.8 13.184 37
I8127 0 8127 1.31105e-05
R9753 8127 8128 1.68 0.8 13.44 37
I8128 0 8128 1.24921e-05
R9754 8128 8129 1.632 0.8 13.056 37
I8129 0 8129 1.24921e-05
R9755 8129 8130 1.728 0.8 13.824 37
I8130 0 8130 1.23684e-05
R9756 8130 0 0.1 49.28 49.28 37
*seg: 814
R9757 0 8131 0.1 49.28 49.28 37
R9758 8135 8145 6.16 0.8 49.28 37
I8131 0 8131 1.32342e-05
R9759 8131 8132 1.728 0.8 13.824 37
I8132 0 8132 1.31105e-05
R9760 8132 8133 1.728 0.8 13.824 37
I8133 0 8133 1.24921e-05
R9761 8133 8134 1.744 0.8 13.952 37
I8134 0 8134 1.31105e-05
R9762 8134 8135 1.6 0.8 12.8 37
I8135 0 8135 1.28631e-05
R9763 8135 8136 1.664 0.8 13.312 37
I8136 0 8136 1.28631e-05
R9764 8136 8137 1.68 0.8 13.44 37
I8137 0 8137 1.32342e-05
R9765 8137 8138 1.696 0.8 13.568 37
I8138 0 8138 1.31105e-05
R9766 8138 8139 1.632 0.8 13.056 37
I8139 0 8139 1.23684e-05
R9767 8139 8140 1.728 0.8 13.824 37
I8140 0 8140 1.23684e-05
R9768 8140 0 0.1 49.28 49.28 37
*seg: 815
R9769 0 8141 0.1 49.28 49.28 37
R9770 8145 8155 6.16 0.8 49.28 37
I8141 0 8141 1.29868e-05
R9771 8141 8142 1.616 0.8 12.928 37
I8142 0 8142 1.26158e-05
R9772 8142 8143 1.6 0.8 12.8 37
I8143 0 8143 1.29868e-05
R9773 8143 8144 1.664 0.8 13.312 37
I8144 0 8144 1.32342e-05
R9774 8144 8145 1.68 0.8 13.44 37
I8145 0 8145 1.28631e-05
R9775 8145 8146 1.696 0.8 13.568 37
I8146 0 8146 1.27395e-05
R9776 8146 8147 1.664 0.8 13.312 37
I8147 0 8147 1.26158e-05
R9777 8147 8148 1.6 0.8 12.8 37
I8148 0 8148 1.28631e-05
R9778 8148 8149 1.632 0.8 13.056 37
I8149 0 8149 1.26158e-05
R9779 8149 8150 1.744 0.8 13.952 37
I8150 0 8150 1.23684e-05
R9780 8150 0 0.1 49.28 49.28 37
*seg: 816
R9781 0 8151 0.1 49.28 49.28 37
R9782 8155 8165 6.16 0.8 49.28 37
I8151 0 8151 1.29868e-05
R9783 8151 8152 1.648 0.8 13.184 37
I8152 0 8152 1.32342e-05
R9784 8152 8153 1.616 0.8 12.928 37
I8153 0 8153 1.26158e-05
R9785 8153 8154 1.712 0.8 13.696 37
I8154 0 8154 1.33579e-05
R9786 8154 8155 1.712 0.8 13.696 37
I8155 0 8155 1.31105e-05
R9787 8155 8156 1.648 0.8 13.184 37
I8156 0 8156 1.24921e-05
R9788 8156 8157 1.6 0.8 12.8 37
I8157 0 8157 1.32342e-05
R9789 8157 8158 1.68 0.8 13.44 37
I8158 0 8158 1.31105e-05
R9790 8158 8159 1.68 0.8 13.44 37
I8159 0 8159 1.29868e-05
R9791 8159 8160 1.712 0.8 13.696 37
I8160 0 8160 1.23684e-05
R9792 8160 0 0.1 49.28 49.28 37
*seg: 817
R9793 0 8161 0.1 49.28 49.28 37
R9794 8165 8175 6.16 0.8 49.28 37
I8161 0 8161 1.26158e-05
R9795 8161 8162 1.632 0.8 13.056 37
I8162 0 8162 1.23684e-05
R9796 8162 8163 1.728 0.8 13.824 37
I8163 0 8163 1.34816e-05
R9797 8163 8164 1.712 0.8 13.696 37
I8164 0 8164 1.27395e-05
R9798 8164 8165 1.664 0.8 13.312 37
I8165 0 8165 1.32342e-05
R9799 8165 8166 1.696 0.8 13.568 37
I8166 0 8166 1.29868e-05
R9800 8166 8167 1.744 0.8 13.952 37
I8167 0 8167 1.33579e-05
R9801 8167 8168 1.712 0.8 13.696 37
I8168 0 8168 1.23684e-05
R9802 8168 8169 1.6 0.8 12.8 37
I8169 0 8169 1.28631e-05
R9803 8169 8170 1.744 0.8 13.952 37
I8170 0 8170 1.23684e-05
R9804 8170 0 0.1 49.28 49.28 37
*seg: 818
R9805 0 8171 0.1 49.28 49.28 37
R9806 8175 8185 6.16 0.8 49.28 37
I8171 0 8171 1.24921e-05
R9807 8171 8172 1.712 0.8 13.696 37
I8172 0 8172 1.26158e-05
R9808 8172 8173 1.696 0.8 13.568 37
I8173 0 8173 1.32342e-05
R9809 8173 8174 1.728 0.8 13.824 37
I8174 0 8174 1.24921e-05
R9810 8174 8175 1.712 0.8 13.696 37
I8175 0 8175 1.23684e-05
R9811 8175 8176 1.744 0.8 13.952 37
I8176 0 8176 1.29868e-05
R9812 8176 8177 1.616 0.8 12.928 37
I8177 0 8177 1.27395e-05
R9813 8177 8178 1.648 0.8 13.184 37
I8178 0 8178 1.31105e-05
R9814 8178 8179 1.744 0.8 13.952 37
I8179 0 8179 1.26158e-05
R9815 8179 8180 1.712 0.8 13.696 37
I8180 0 8180 1.23684e-05
R9816 8180 0 0.1 49.28 49.28 37
*seg: 819
R9817 0 8181 0.1 49.28 49.28 37
R9818 8185 8195 6.16 0.8 49.28 37
I8181 0 8181 1.27395e-05
R9819 8181 8182 1.696 0.8 13.568 37
I8182 0 8182 1.24921e-05
R9820 8182 8183 1.728 0.8 13.824 37
I8183 0 8183 1.29868e-05
R9821 8183 8184 1.712 0.8 13.696 37
I8184 0 8184 1.31105e-05
R9822 8184 8185 1.68 0.8 13.44 37
I8185 0 8185 1.28631e-05
R9823 8185 8186 1.728 0.8 13.824 37
I8186 0 8186 1.32342e-05
R9824 8186 8187 1.648 0.8 13.184 37
I8187 0 8187 1.34816e-05
R9825 8187 8188 1.648 0.8 13.184 37
I8188 0 8188 1.29868e-05
R9826 8188 8189 1.696 0.8 13.568 37
I8189 0 8189 1.28631e-05
R9827 8189 8190 1.6 0.8 12.8 37
I8190 0 8190 1.23684e-05
R9828 8190 0 0.1 49.28 49.28 37
*seg: 820
R9829 0 8191 0.1 49.28 49.28 37
R9830 8195 8205 6.16 0.8 49.28 37
I8191 0 8191 1.31105e-05
R9831 8191 8192 1.744 0.8 13.952 37
I8192 0 8192 1.27395e-05
R9832 8192 8193 1.744 0.8 13.952 37
I8193 0 8193 1.31105e-05
R9833 8193 8194 1.664 0.8 13.312 37
I8194 0 8194 1.31105e-05
R9834 8194 8195 1.664 0.8 13.312 37
I8195 0 8195 1.33579e-05
R9835 8195 8196 1.664 0.8 13.312 37
I8196 0 8196 1.31105e-05
R9836 8196 8197 1.6 0.8 12.8 37
I8197 0 8197 1.24921e-05
R9837 8197 8198 1.664 0.8 13.312 37
I8198 0 8198 1.31105e-05
R9838 8198 8199 1.664 0.8 13.312 37
I8199 0 8199 1.34816e-05
R9839 8199 8200 1.632 0.8 13.056 37
I8200 0 8200 1.23684e-05
R9840 8200 0 0.1 49.28 49.28 37
*seg: 821
R9841 0 8201 0.1 49.28 49.28 37
R9842 8205 8215 6.16 0.8 49.28 37
I8201 0 8201 1.27395e-05
R9843 8201 8202 1.6 0.8 12.8 37
I8202 0 8202 1.28631e-05
R9844 8202 8203 1.728 0.8 13.824 37
I8203 0 8203 1.23684e-05
R9845 8203 8204 1.648 0.8 13.184 37
I8204 0 8204 1.32342e-05
R9846 8204 8205 1.696 0.8 13.568 37
I8205 0 8205 1.31105e-05
R9847 8205 8206 1.648 0.8 13.184 37
I8206 0 8206 1.23684e-05
R9848 8206 8207 1.68 0.8 13.44 37
I8207 0 8207 1.23684e-05
R9849 8207 8208 1.6 0.8 12.8 37
I8208 0 8208 1.34816e-05
R9850 8208 8209 1.648 0.8 13.184 37
I8209 0 8209 1.27395e-05
R9851 8209 8210 1.744 0.8 13.952 37
I8210 0 8210 1.23684e-05
R9852 8210 0 0.1 49.28 49.28 37
*seg: 822
R9853 0 8211 0.1 49.28 49.28 37
R9854 8215 8225 6.16 0.8 49.28 37
I8211 0 8211 1.23684e-05
R9855 8211 8212 1.712 0.8 13.696 37
I8212 0 8212 1.32342e-05
R9856 8212 8213 1.616 0.8 12.928 37
I8213 0 8213 1.31105e-05
R9857 8213 8214 1.6 0.8 12.8 37
I8214 0 8214 1.23684e-05
R9858 8214 8215 1.632 0.8 13.056 37
I8215 0 8215 1.23684e-05
R9859 8215 8216 1.648 0.8 13.184 37
I8216 0 8216 1.23684e-05
R9860 8216 8217 1.664 0.8 13.312 37
I8217 0 8217 1.29868e-05
R9861 8217 8218 1.712 0.8 13.696 37
I8218 0 8218 1.29868e-05
R9862 8218 8219 1.68 0.8 13.44 37
I8219 0 8219 1.31105e-05
R9863 8219 8220 1.696 0.8 13.568 37
I8220 0 8220 1.23684e-05
R9864 8220 0 0.1 49.28 49.28 37
*seg: 823
R9865 0 8221 0.1 49.28 49.28 37
R9866 8225 8235 6.16 0.8 49.28 37
I8221 0 8221 1.32342e-05
R9867 8221 8222 1.648 0.8 13.184 37
I8222 0 8222 1.26158e-05
R9868 8222 8223 1.632 0.8 13.056 37
I8223 0 8223 1.34816e-05
R9869 8223 8224 1.728 0.8 13.824 37
I8224 0 8224 1.31105e-05
R9870 8224 8225 1.664 0.8 13.312 37
I8225 0 8225 1.32342e-05
R9871 8225 8226 1.712 0.8 13.696 37
I8226 0 8226 1.29868e-05
R9872 8226 8227 1.632 0.8 13.056 37
I8227 0 8227 1.29868e-05
R9873 8227 8228 1.712 0.8 13.696 37
I8228 0 8228 1.28631e-05
R9874 8228 8229 1.616 0.8 12.928 37
I8229 0 8229 1.33579e-05
R9875 8229 8230 1.648 0.8 13.184 37
I8230 0 8230 1.23684e-05
R9876 8230 0 0.1 49.28 49.28 37
*seg: 824
R9877 0 8231 0.1 49.28 49.28 37
R9878 8235 8245 6.16 0.8 49.28 37
I8231 0 8231 1.26158e-05
R9879 8231 8232 1.712 0.8 13.696 37
I8232 0 8232 1.34816e-05
R9880 8232 8233 1.728 0.8 13.824 37
I8233 0 8233 1.24921e-05
R9881 8233 8234 1.728 0.8 13.824 37
I8234 0 8234 1.28631e-05
R9882 8234 8235 1.664 0.8 13.312 37
I8235 0 8235 1.32342e-05
R9883 8235 8236 1.728 0.8 13.824 37
I8236 0 8236 1.32342e-05
R9884 8236 8237 1.616 0.8 12.928 37
I8237 0 8237 1.28631e-05
R9885 8237 8238 1.728 0.8 13.824 37
I8238 0 8238 1.27395e-05
R9886 8238 8239 1.68 0.8 13.44 37
I8239 0 8239 1.33579e-05
R9887 8239 8240 1.664 0.8 13.312 37
I8240 0 8240 1.23684e-05
R9888 8240 0 0.1 49.28 49.28 37
*seg: 825
R9889 0 8241 0.1 49.28 49.28 37
R9890 8245 8255 6.16 0.8 49.28 37
I8241 0 8241 1.32342e-05
R9891 8241 8242 1.728 0.8 13.824 37
I8242 0 8242 1.31105e-05
R9892 8242 8243 1.648 0.8 13.184 37
I8243 0 8243 1.24921e-05
R9893 8243 8244 1.6 0.8 12.8 37
I8244 0 8244 1.29868e-05
R9894 8244 8245 1.712 0.8 13.696 37
I8245 0 8245 1.32342e-05
R9895 8245 8246 1.648 0.8 13.184 37
I8246 0 8246 1.33579e-05
R9896 8246 8247 1.6 0.8 12.8 37
I8247 0 8247 1.27395e-05
R9897 8247 8248 1.728 0.8 13.824 37
I8248 0 8248 1.27395e-05
R9898 8248 8249 1.664 0.8 13.312 37
I8249 0 8249 1.24921e-05
R9899 8249 8250 1.744 0.8 13.952 37
I8250 0 8250 1.23684e-05
R9900 8250 0 0.1 49.28 49.28 37
*seg: 826
R9901 0 8251 0.1 49.28 49.28 37
R9902 8255 8265 6.16 0.8 49.28 37
I8251 0 8251 1.23684e-05
R9903 8251 8252 1.744 0.8 13.952 37
I8252 0 8252 1.29868e-05
R9904 8252 8253 1.6 0.8 12.8 37
I8253 0 8253 1.31105e-05
R9905 8253 8254 1.68 0.8 13.44 37
I8254 0 8254 1.24921e-05
R9906 8254 8255 1.728 0.8 13.824 37
I8255 0 8255 1.34816e-05
R9907 8255 8256 1.664 0.8 13.312 37
I8256 0 8256 1.27395e-05
R9908 8256 8257 1.728 0.8 13.824 37
I8257 0 8257 1.23684e-05
R9909 8257 8258 1.6 0.8 12.8 37
I8258 0 8258 1.23684e-05
R9910 8258 8259 1.648 0.8 13.184 37
I8259 0 8259 1.24921e-05
R9911 8259 8260 1.632 0.8 13.056 37
I8260 0 8260 1.23684e-05
R9912 8260 0 0.1 49.28 49.28 37
*seg: 827
R9913 0 8261 0.1 49.28 49.28 37
R9914 8265 8275 6.16 0.8 49.28 37
I8261 0 8261 1.27395e-05
R9915 8261 8262 1.744 0.8 13.952 37
I8262 0 8262 1.28631e-05
R9916 8262 8263 1.6 0.8 12.8 37
I8263 0 8263 1.24921e-05
R9917 8263 8264 1.744 0.8 13.952 37
I8264 0 8264 1.24921e-05
R9918 8264 8265 1.712 0.8 13.696 37
I8265 0 8265 1.31105e-05
R9919 8265 8266 1.616 0.8 12.928 37
I8266 0 8266 1.23684e-05
R9920 8266 8267 1.616 0.8 12.928 37
I8267 0 8267 1.28631e-05
R9921 8267 8268 1.728 0.8 13.824 37
I8268 0 8268 1.33579e-05
R9922 8268 8269 1.664 0.8 13.312 37
I8269 0 8269 1.29868e-05
R9923 8269 8270 1.744 0.8 13.952 37
I8270 0 8270 1.23684e-05
R9924 8270 0 0.1 49.28 49.28 37
*seg: 828
R9925 0 8271 0.1 49.28 49.28 37
R9926 8275 8285 6.16 0.8 49.28 37
I8271 0 8271 1.34816e-05
R9927 8271 8272 1.616 0.8 12.928 37
I8272 0 8272 1.28631e-05
R9928 8272 8273 1.68 0.8 13.44 37
I8273 0 8273 1.28631e-05
R9929 8273 8274 1.632 0.8 13.056 37
I8274 0 8274 1.27395e-05
R9930 8274 8275 1.68 0.8 13.44 37
I8275 0 8275 1.27395e-05
R9931 8275 8276 1.712 0.8 13.696 37
I8276 0 8276 1.23684e-05
R9932 8276 8277 1.744 0.8 13.952 37
I8277 0 8277 1.31105e-05
R9933 8277 8278 1.68 0.8 13.44 37
I8278 0 8278 1.32342e-05
R9934 8278 8279 1.728 0.8 13.824 37
I8279 0 8279 1.31105e-05
R9935 8279 8280 1.664 0.8 13.312 37
I8280 0 8280 1.23684e-05
R9936 8280 0 0.1 49.28 49.28 37
*seg: 829
R9937 0 8281 0.1 49.28 49.28 37
R9938 8285 8295 6.16 0.8 49.28 37
I8281 0 8281 1.23684e-05
R9939 8281 8282 1.728 0.8 13.824 37
I8282 0 8282 1.28631e-05
R9940 8282 8283 1.632 0.8 13.056 37
I8283 0 8283 1.29868e-05
R9941 8283 8284 1.744 0.8 13.952 37
I8284 0 8284 1.27395e-05
R9942 8284 8285 1.6 0.8 12.8 37
I8285 0 8285 1.34816e-05
R9943 8285 8286 1.744 0.8 13.952 37
I8286 0 8286 1.28631e-05
R9944 8286 8287 1.616 0.8 12.928 37
I8287 0 8287 1.33579e-05
R9945 8287 8288 1.648 0.8 13.184 37
I8288 0 8288 1.27395e-05
R9946 8288 8289 1.632 0.8 13.056 37
I8289 0 8289 1.34816e-05
R9947 8289 8290 1.632 0.8 13.056 37
I8290 0 8290 1.23684e-05
R9948 8290 0 0.1 49.28 49.28 37
*seg: 830
R9949 0 8291 0.1 49.28 49.28 37
R9950 8295 8305 6.16 0.8 49.28 37
I8291 0 8291 1.24921e-05
R9951 8291 8292 1.696 0.8 13.568 37
I8292 0 8292 1.24921e-05
R9952 8292 8293 1.616 0.8 12.928 37
I8293 0 8293 1.24921e-05
R9953 8293 8294 1.68 0.8 13.44 37
I8294 0 8294 1.23684e-05
R9954 8294 8295 1.664 0.8 13.312 37
I8295 0 8295 1.34816e-05
R9955 8295 8296 1.664 0.8 13.312 37
I8296 0 8296 1.32342e-05
R9956 8296 8297 1.616 0.8 12.928 37
I8297 0 8297 1.27395e-05
R9957 8297 8298 1.664 0.8 13.312 37
I8298 0 8298 1.32342e-05
R9958 8298 8299 1.6 0.8 12.8 37
I8299 0 8299 1.26158e-05
R9959 8299 8300 1.712 0.8 13.696 37
I8300 0 8300 1.23684e-05
R9960 8300 0 0.1 49.28 49.28 37
*seg: 831
R9961 0 8301 0.1 49.28 49.28 37
R9962 8305 8315 6.16 0.8 49.28 37
I8301 0 8301 1.31105e-05
R9963 8301 8302 1.616 0.8 12.928 37
I8302 0 8302 1.23684e-05
R9964 8302 8303 1.616 0.8 12.928 37
I8303 0 8303 1.31105e-05
R9965 8303 8304 1.744 0.8 13.952 37
I8304 0 8304 1.33579e-05
R9966 8304 8305 1.632 0.8 13.056 37
I8305 0 8305 1.26158e-05
R9967 8305 8306 1.616 0.8 12.928 37
I8306 0 8306 1.23684e-05
R9968 8306 8307 1.696 0.8 13.568 37
I8307 0 8307 1.31105e-05
R9969 8307 8308 1.696 0.8 13.568 37
I8308 0 8308 1.32342e-05
R9970 8308 8309 1.6 0.8 12.8 37
I8309 0 8309 1.33579e-05
R9971 8309 8310 1.728 0.8 13.824 37
I8310 0 8310 1.23684e-05
R9972 8310 0 0.1 49.28 49.28 37
*seg: 832
R9973 0 8311 0.1 49.28 49.28 37
R9974 8315 8325 6.16 0.8 49.28 37
I8311 0 8311 1.32342e-05
R9975 8311 8312 1.632 0.8 13.056 37
I8312 0 8312 1.32342e-05
R9976 8312 8313 1.648 0.8 13.184 37
I8313 0 8313 1.28631e-05
R9977 8313 8314 1.664 0.8 13.312 37
I8314 0 8314 1.33579e-05
R9978 8314 8315 1.632 0.8 13.056 37
I8315 0 8315 1.31105e-05
R9979 8315 8316 1.712 0.8 13.696 37
I8316 0 8316 1.26158e-05
R9980 8316 8317 1.664 0.8 13.312 37
I8317 0 8317 1.32342e-05
R9981 8317 8318 1.696 0.8 13.568 37
I8318 0 8318 1.26158e-05
R9982 8318 8319 1.664 0.8 13.312 37
I8319 0 8319 1.34816e-05
R9983 8319 8320 1.6 0.8 12.8 37
I8320 0 8320 1.23684e-05
R9984 8320 0 0.1 49.28 49.28 37
*seg: 833
R9985 0 8321 0.1 49.28 49.28 37
R9986 8325 8335 6.16 0.8 49.28 37
I8321 0 8321 1.33579e-05
R9987 8321 8322 1.648 0.8 13.184 37
I8322 0 8322 1.33579e-05
R9988 8322 8323 1.728 0.8 13.824 37
I8323 0 8323 1.26158e-05
R9989 8323 8324 1.648 0.8 13.184 37
I8324 0 8324 1.28631e-05
R9990 8324 8325 1.6 0.8 12.8 37
I8325 0 8325 1.29868e-05
R9991 8325 8326 1.6 0.8 12.8 37
I8326 0 8326 1.34816e-05
R9992 8326 8327 1.696 0.8 13.568 37
I8327 0 8327 1.28631e-05
R9993 8327 8328 1.712 0.8 13.696 37
I8328 0 8328 1.31105e-05
R9994 8328 8329 1.616 0.8 12.928 37
I8329 0 8329 1.24921e-05
R9995 8329 8330 1.68 0.8 13.44 37
I8330 0 8330 1.23684e-05
R9996 8330 0 0.1 49.28 49.28 37
*seg: 834
R9997 0 8331 0.1 49.28 49.28 37
R9998 8335 8345 6.16 0.8 49.28 37
I8331 0 8331 1.33579e-05
R9999 8331 8332 1.712 0.8 13.696 37
I8332 0 8332 1.28631e-05
R10000 8332 8333 1.664 0.8 13.312 37
I8333 0 8333 1.28631e-05
R10001 8333 8334 1.696 0.8 13.568 37
I8334 0 8334 1.34816e-05
R10002 8334 8335 1.664 0.8 13.312 37
I8335 0 8335 1.31105e-05
R10003 8335 8336 1.68 0.8 13.44 37
I8336 0 8336 1.33579e-05
R10004 8336 8337 1.648 0.8 13.184 37
I8337 0 8337 1.28631e-05
R10005 8337 8338 1.728 0.8 13.824 37
I8338 0 8338 1.34816e-05
R10006 8338 8339 1.696 0.8 13.568 37
I8339 0 8339 1.34816e-05
R10007 8339 8340 1.744 0.8 13.952 37
I8340 0 8340 1.23684e-05
R10008 8340 0 0.1 49.28 49.28 37
*seg: 835
R10009 0 8341 0.1 49.28 49.28 37
R10010 8345 8355 6.16 0.8 49.28 37
I8341 0 8341 1.24921e-05
R10011 8341 8342 1.616 0.8 12.928 37
I8342 0 8342 1.26158e-05
R10012 8342 8343 1.664 0.8 13.312 37
I8343 0 8343 1.33579e-05
R10013 8343 8344 1.664 0.8 13.312 37
I8344 0 8344 1.29868e-05
R10014 8344 8345 1.696 0.8 13.568 37
I8345 0 8345 1.29868e-05
R10015 8345 8346 1.696 0.8 13.568 37
I8346 0 8346 1.26158e-05
R10016 8346 8347 1.632 0.8 13.056 37
I8347 0 8347 1.23684e-05
R10017 8347 8348 1.648 0.8 13.184 37
I8348 0 8348 1.31105e-05
R10018 8348 8349 1.696 0.8 13.568 37
I8349 0 8349 1.26158e-05
R10019 8349 8350 1.712 0.8 13.696 37
I8350 0 8350 1.23684e-05
R10020 8350 0 0.1 49.28 49.28 37
*seg: 836
R10021 0 8351 0.1 49.28 49.28 37
R10022 8355 8365 6.16 0.8 49.28 37
I8351 0 8351 1.33579e-05
R10023 8351 8352 1.744 0.8 13.952 37
I8352 0 8352 1.29868e-05
R10024 8352 8353 1.648 0.8 13.184 37
I8353 0 8353 1.33579e-05
R10025 8353 8354 1.664 0.8 13.312 37
I8354 0 8354 1.34816e-05
R10026 8354 8355 1.744 0.8 13.952 37
I8355 0 8355 1.32342e-05
R10027 8355 8356 1.664 0.8 13.312 37
I8356 0 8356 1.24921e-05
R10028 8356 8357 1.616 0.8 12.928 37
I8357 0 8357 1.24921e-05
R10029 8357 8358 1.6 0.8 12.8 37
I8358 0 8358 1.32342e-05
R10030 8358 8359 1.616 0.8 12.928 37
I8359 0 8359 1.27395e-05
R10031 8359 8360 1.616 0.8 12.928 37
I8360 0 8360 1.23684e-05
R10032 8360 0 0.1 49.28 49.28 37
*seg: 837
R10033 0 8361 0.1 49.28 49.28 37
R10034 8365 8375 6.16 0.8 49.28 37
I8361 0 8361 1.26158e-05
R10035 8361 8362 1.648 0.8 13.184 37
I8362 0 8362 1.29868e-05
R10036 8362 8363 1.6 0.8 12.8 37
I8363 0 8363 1.23684e-05
R10037 8363 8364 1.68 0.8 13.44 37
I8364 0 8364 1.33579e-05
R10038 8364 8365 1.632 0.8 13.056 37
I8365 0 8365 1.23684e-05
R10039 8365 8366 1.712 0.8 13.696 37
I8366 0 8366 1.28631e-05
R10040 8366 8367 1.728 0.8 13.824 37
I8367 0 8367 1.31105e-05
R10041 8367 8368 1.696 0.8 13.568 37
I8368 0 8368 1.26158e-05
R10042 8368 8369 1.648 0.8 13.184 37
I8369 0 8369 1.33579e-05
R10043 8369 8370 1.696 0.8 13.568 37
I8370 0 8370 1.23684e-05
R10044 8370 0 0.1 49.28 49.28 37
*seg: 838
R10045 0 8371 0.1 49.28 49.28 37
R10046 8375 8385 6.16 0.8 49.28 37
I8371 0 8371 1.34816e-05
R10047 8371 8372 1.632 0.8 13.056 37
I8372 0 8372 1.24921e-05
R10048 8372 8373 1.696 0.8 13.568 37
I8373 0 8373 1.31105e-05
R10049 8373 8374 1.696 0.8 13.568 37
I8374 0 8374 1.32342e-05
R10050 8374 8375 1.744 0.8 13.952 37
I8375 0 8375 1.31105e-05
R10051 8375 8376 1.696 0.8 13.568 37
I8376 0 8376 1.23684e-05
R10052 8376 8377 1.712 0.8 13.696 37
I8377 0 8377 1.24921e-05
R10053 8377 8378 1.68 0.8 13.44 37
I8378 0 8378 1.23684e-05
R10054 8378 8379 1.68 0.8 13.44 37
I8379 0 8379 1.33579e-05
R10055 8379 8380 1.632 0.8 13.056 37
I8380 0 8380 1.23684e-05
R10056 8380 0 0.1 49.28 49.28 37
*seg: 839
R10057 0 8381 0.1 49.28 49.28 37
R10058 8385 8395 6.16 0.8 49.28 37
I8381 0 8381 1.28631e-05
R10059 8381 8382 1.744 0.8 13.952 37
I8382 0 8382 1.29868e-05
R10060 8382 8383 1.744 0.8 13.952 37
I8383 0 8383 1.27395e-05
R10061 8383 8384 1.696 0.8 13.568 37
I8384 0 8384 1.32342e-05
R10062 8384 8385 1.616 0.8 12.928 37
I8385 0 8385 1.28631e-05
R10063 8385 8386 1.648 0.8 13.184 37
I8386 0 8386 1.29868e-05
R10064 8386 8387 1.6 0.8 12.8 37
I8387 0 8387 1.33579e-05
R10065 8387 8388 1.696 0.8 13.568 37
I8388 0 8388 1.31105e-05
R10066 8388 8389 1.712 0.8 13.696 37
I8389 0 8389 1.31105e-05
R10067 8389 8390 1.648 0.8 13.184 37
I8390 0 8390 1.23684e-05
R10068 8390 0 0.1 49.28 49.28 37
*seg: 840
R10069 0 8391 0.1 49.28 49.28 37
R10070 8395 8405 6.16 0.8 49.28 37
I8391 0 8391 1.27395e-05
R10071 8391 8392 1.744 0.8 13.952 37
I8392 0 8392 1.34816e-05
R10072 8392 8393 1.616 0.8 12.928 37
I8393 0 8393 1.28631e-05
R10073 8393 8394 1.728 0.8 13.824 37
I8394 0 8394 1.26158e-05
R10074 8394 8395 1.696 0.8 13.568 37
I8395 0 8395 1.29868e-05
R10075 8395 8396 1.648 0.8 13.184 37
I8396 0 8396 1.32342e-05
R10076 8396 8397 1.68 0.8 13.44 37
I8397 0 8397 1.29868e-05
R10077 8397 8398 1.744 0.8 13.952 37
I8398 0 8398 1.23684e-05
R10078 8398 8399 1.616 0.8 12.928 37
I8399 0 8399 1.32342e-05
R10079 8399 8400 1.6 0.8 12.8 37
I8400 0 8400 1.23684e-05
R10080 8400 0 0.1 49.28 49.28 37
*seg: 841
R10081 0 8401 0.1 49.28 49.28 37
R10082 8405 8415 6.16 0.8 49.28 37
I8401 0 8401 1.34816e-05
R10083 8401 8402 1.648 0.8 13.184 37
I8402 0 8402 1.33579e-05
R10084 8402 8403 1.68 0.8 13.44 37
I8403 0 8403 1.27395e-05
R10085 8403 8404 1.728 0.8 13.824 37
I8404 0 8404 1.23684e-05
R10086 8404 8405 1.712 0.8 13.696 37
I8405 0 8405 1.26158e-05
R10087 8405 8406 1.664 0.8 13.312 37
I8406 0 8406 1.34816e-05
R10088 8406 8407 1.664 0.8 13.312 37
I8407 0 8407 1.29868e-05
R10089 8407 8408 1.632 0.8 13.056 37
I8408 0 8408 1.28631e-05
R10090 8408 8409 1.68 0.8 13.44 37
I8409 0 8409 1.27395e-05
R10091 8409 8410 1.6 0.8 12.8 37
I8410 0 8410 1.23684e-05
R10092 8410 0 0.1 49.28 49.28 37
*seg: 842
R10093 0 8411 0.1 49.28 49.28 37
R10094 8415 8425 6.16 0.8 49.28 37
I8411 0 8411 1.31105e-05
R10095 8411 8412 1.712 0.8 13.696 37
I8412 0 8412 1.32342e-05
R10096 8412 8413 1.648 0.8 13.184 37
I8413 0 8413 1.23684e-05
R10097 8413 8414 1.712 0.8 13.696 37
I8414 0 8414 1.34816e-05
R10098 8414 8415 1.648 0.8 13.184 37
I8415 0 8415 1.29868e-05
R10099 8415 8416 1.744 0.8 13.952 37
I8416 0 8416 1.26158e-05
R10100 8416 8417 1.68 0.8 13.44 37
I8417 0 8417 1.27395e-05
R10101 8417 8418 1.616 0.8 12.928 37
I8418 0 8418 1.31105e-05
R10102 8418 8419 1.712 0.8 13.696 37
I8419 0 8419 1.27395e-05
R10103 8419 8420 1.68 0.8 13.44 37
I8420 0 8420 1.23684e-05
R10104 8420 0 0.1 49.28 49.28 37
*seg: 843
R10105 0 8421 0.1 49.28 49.28 37
R10106 8425 8435 6.16 0.8 49.28 37
I8421 0 8421 1.24921e-05
R10107 8421 8422 1.6 0.8 12.8 37
I8422 0 8422 1.34816e-05
R10108 8422 8423 1.696 0.8 13.568 37
I8423 0 8423 1.33579e-05
R10109 8423 8424 1.712 0.8 13.696 37
I8424 0 8424 1.24921e-05
R10110 8424 8425 1.632 0.8 13.056 37
I8425 0 8425 1.26158e-05
R10111 8425 8426 1.68 0.8 13.44 37
I8426 0 8426 1.28631e-05
R10112 8426 8427 1.664 0.8 13.312 37
I8427 0 8427 1.31105e-05
R10113 8427 8428 1.6 0.8 12.8 37
I8428 0 8428 1.32342e-05
R10114 8428 8429 1.744 0.8 13.952 37
I8429 0 8429 1.23684e-05
R10115 8429 8430 1.616 0.8 12.928 37
I8430 0 8430 1.23684e-05
R10116 8430 0 0.1 49.28 49.28 37
*seg: 844
R10117 0 8431 0.1 49.28 49.28 37
R10118 8435 8445 6.16 0.8 49.28 37
I8431 0 8431 1.23684e-05
R10119 8431 8432 1.744 0.8 13.952 37
I8432 0 8432 1.28631e-05
R10120 8432 8433 1.632 0.8 13.056 37
I8433 0 8433 1.34816e-05
R10121 8433 8434 1.648 0.8 13.184 37
I8434 0 8434 1.28631e-05
R10122 8434 8435 1.648 0.8 13.184 37
I8435 0 8435 1.23684e-05
R10123 8435 8436 1.728 0.8 13.824 37
I8436 0 8436 1.33579e-05
R10124 8436 8437 1.712 0.8 13.696 37
I8437 0 8437 1.29868e-05
R10125 8437 8438 1.6 0.8 12.8 37
I8438 0 8438 1.28631e-05
R10126 8438 8439 1.696 0.8 13.568 37
I8439 0 8439 1.34816e-05
R10127 8439 8440 1.696 0.8 13.568 37
I8440 0 8440 1.23684e-05
R10128 8440 0 0.1 49.28 49.28 37
*seg: 845
R10129 0 8441 0.1 49.28 49.28 37
R10130 8445 8455 6.16 0.8 49.28 37
I8441 0 8441 1.24921e-05
R10131 8441 8442 1.728 0.8 13.824 37
I8442 0 8442 1.27395e-05
R10132 8442 8443 1.68 0.8 13.44 37
I8443 0 8443 1.32342e-05
R10133 8443 8444 1.648 0.8 13.184 37
I8444 0 8444 1.23684e-05
R10134 8444 8445 1.696 0.8 13.568 37
I8445 0 8445 1.26158e-05
R10135 8445 8446 1.6 0.8 12.8 37
I8446 0 8446 1.29868e-05
R10136 8446 8447 1.712 0.8 13.696 37
I8447 0 8447 1.26158e-05
R10137 8447 8448 1.6 0.8 12.8 37
I8448 0 8448 1.26158e-05
R10138 8448 8449 1.68 0.8 13.44 37
I8449 0 8449 1.31105e-05
R10139 8449 8450 1.616 0.8 12.928 37
I8450 0 8450 1.23684e-05
R10140 8450 0 0.1 49.28 49.28 37
*seg: 846
R10141 0 8451 0.1 49.28 49.28 37
R10142 8455 8465 6.16 0.8 49.28 37
I8451 0 8451 1.24921e-05
R10143 8451 8452 1.728 0.8 13.824 37
I8452 0 8452 1.31105e-05
R10144 8452 8453 1.632 0.8 13.056 37
I8453 0 8453 1.31105e-05
R10145 8453 8454 1.744 0.8 13.952 37
I8454 0 8454 1.27395e-05
R10146 8454 8455 1.728 0.8 13.824 37
I8455 0 8455 1.34816e-05
R10147 8455 8456 1.664 0.8 13.312 37
I8456 0 8456 1.27395e-05
R10148 8456 8457 1.6 0.8 12.8 37
I8457 0 8457 1.28631e-05
R10149 8457 8458 1.664 0.8 13.312 37
I8458 0 8458 1.29868e-05
R10150 8458 8459 1.712 0.8 13.696 37
I8459 0 8459 1.32342e-05
R10151 8459 8460 1.712 0.8 13.696 37
I8460 0 8460 1.23684e-05
R10152 8460 0 0.1 49.28 49.28 37
*seg: 847
R10153 0 8461 0.1 49.28 49.28 37
R10154 8465 8475 6.16 0.8 49.28 37
I8461 0 8461 1.29868e-05
R10155 8461 8462 1.648 0.8 13.184 37
I8462 0 8462 1.34816e-05
R10156 8462 8463 1.648 0.8 13.184 37
I8463 0 8463 1.34816e-05
R10157 8463 8464 1.6 0.8 12.8 37
I8464 0 8464 1.31105e-05
R10158 8464 8465 1.664 0.8 13.312 37
I8465 0 8465 1.27395e-05
R10159 8465 8466 1.648 0.8 13.184 37
I8466 0 8466 1.24921e-05
R10160 8466 8467 1.616 0.8 12.928 37
I8467 0 8467 1.27395e-05
R10161 8467 8468 1.744 0.8 13.952 37
I8468 0 8468 1.29868e-05
R10162 8468 8469 1.6 0.8 12.8 37
I8469 0 8469 1.28631e-05
R10163 8469 8470 1.664 0.8 13.312 37
I8470 0 8470 1.23684e-05
R10164 8470 0 0.1 49.28 49.28 37
*seg: 848
R10165 0 8471 0.1 49.28 49.28 37
R10166 8475 8485 6.16 0.8 49.28 37
I8471 0 8471 1.28631e-05
R10167 8471 8472 1.6 0.8 12.8 37
I8472 0 8472 1.29868e-05
R10168 8472 8473 1.744 0.8 13.952 37
I8473 0 8473 1.32342e-05
R10169 8473 8474 1.664 0.8 13.312 37
I8474 0 8474 1.33579e-05
R10170 8474 8475 1.6 0.8 12.8 37
I8475 0 8475 1.23684e-05
R10171 8475 8476 1.6 0.8 12.8 37
I8476 0 8476 1.28631e-05
R10172 8476 8477 1.68 0.8 13.44 37
I8477 0 8477 1.34816e-05
R10173 8477 8478 1.664 0.8 13.312 37
I8478 0 8478 1.33579e-05
R10174 8478 8479 1.712 0.8 13.696 37
I8479 0 8479 1.32342e-05
R10175 8479 8480 1.648 0.8 13.184 37
I8480 0 8480 1.23684e-05
R10176 8480 0 0.1 49.28 49.28 37
*seg: 849
R10177 0 8481 0.1 49.28 49.28 37
R10178 8485 8495 6.16 0.8 49.28 37
I8481 0 8481 1.28631e-05
R10179 8481 8482 1.664 0.8 13.312 37
I8482 0 8482 1.26158e-05
R10180 8482 8483 1.6 0.8 12.8 37
I8483 0 8483 1.27395e-05
R10181 8483 8484 1.648 0.8 13.184 37
I8484 0 8484 1.24921e-05
R10182 8484 8485 1.648 0.8 13.184 37
I8485 0 8485 1.28631e-05
R10183 8485 8486 1.616 0.8 12.928 37
I8486 0 8486 1.28631e-05
R10184 8486 8487 1.68 0.8 13.44 37
I8487 0 8487 1.26158e-05
R10185 8487 8488 1.664 0.8 13.312 37
I8488 0 8488 1.26158e-05
R10186 8488 8489 1.664 0.8 13.312 37
I8489 0 8489 1.32342e-05
R10187 8489 8490 1.6 0.8 12.8 37
I8490 0 8490 1.23684e-05
R10188 8490 0 0.1 49.28 49.28 37
*seg: 850
R10189 0 8491 0.1 49.28 49.28 37
R10190 8495 8505 6.16 0.8 49.28 37
I8491 0 8491 1.26158e-05
R10191 8491 8492 1.6 0.8 12.8 37
I8492 0 8492 1.29868e-05
R10192 8492 8493 1.68 0.8 13.44 37
I8493 0 8493 1.33579e-05
R10193 8493 8494 1.616 0.8 12.928 37
I8494 0 8494 1.34816e-05
R10194 8494 8495 1.616 0.8 12.928 37
I8495 0 8495 1.31105e-05
R10195 8495 8496 1.696 0.8 13.568 37
I8496 0 8496 1.24921e-05
R10196 8496 8497 1.68 0.8 13.44 37
I8497 0 8497 1.34816e-05
R10197 8497 8498 1.6 0.8 12.8 37
I8498 0 8498 1.28631e-05
R10198 8498 8499 1.744 0.8 13.952 37
I8499 0 8499 1.26158e-05
R10199 8499 8500 1.632 0.8 13.056 37
I8500 0 8500 1.23684e-05
R10200 8500 0 0.1 49.28 49.28 37
*seg: 851
R10201 0 8501 0.1 49.28 49.28 37
R10202 8505 8515 6.16 0.8 49.28 37
I8501 0 8501 1.24921e-05
R10203 8501 8502 1.648 0.8 13.184 37
I8502 0 8502 1.32342e-05
R10204 8502 8503 1.744 0.8 13.952 37
I8503 0 8503 1.29868e-05
R10205 8503 8504 1.648 0.8 13.184 37
I8504 0 8504 1.34816e-05
R10206 8504 8505 1.6 0.8 12.8 37
I8505 0 8505 1.31105e-05
R10207 8505 8506 1.712 0.8 13.696 37
I8506 0 8506 1.27395e-05
R10208 8506 8507 1.6 0.8 12.8 37
I8507 0 8507 1.28631e-05
R10209 8507 8508 1.696 0.8 13.568 37
I8508 0 8508 1.32342e-05
R10210 8508 8509 1.6 0.8 12.8 37
I8509 0 8509 1.29868e-05
R10211 8509 8510 1.712 0.8 13.696 37
I8510 0 8510 1.23684e-05
R10212 8510 0 0.1 49.28 49.28 37
*seg: 852
R10213 0 8511 0.1 49.28 49.28 37
R10214 8515 8525 6.16 0.8 49.28 37
I8511 0 8511 1.33579e-05
R10215 8511 8512 1.616 0.8 12.928 37
I8512 0 8512 1.23684e-05
R10216 8512 8513 1.6 0.8 12.8 37
I8513 0 8513 1.27395e-05
R10217 8513 8514 1.728 0.8 13.824 37
I8514 0 8514 1.31105e-05
R10218 8514 8515 1.696 0.8 13.568 37
I8515 0 8515 1.27395e-05
R10219 8515 8516 1.68 0.8 13.44 37
I8516 0 8516 1.32342e-05
R10220 8516 8517 1.728 0.8 13.824 37
I8517 0 8517 1.26158e-05
R10221 8517 8518 1.664 0.8 13.312 37
I8518 0 8518 1.34816e-05
R10222 8518 8519 1.632 0.8 13.056 37
I8519 0 8519 1.28631e-05
R10223 8519 8520 1.696 0.8 13.568 37
I8520 0 8520 1.23684e-05
R10224 8520 0 0.1 49.28 49.28 37
*seg: 853
R10225 0 8521 0.1 49.28 49.28 37
R10226 8525 8535 6.16 0.8 49.28 37
I8521 0 8521 1.31105e-05
R10227 8521 8522 1.728 0.8 13.824 37
I8522 0 8522 1.33579e-05
R10228 8522 8523 1.712 0.8 13.696 37
I8523 0 8523 1.26158e-05
R10229 8523 8524 1.696 0.8 13.568 37
I8524 0 8524 1.33579e-05
R10230 8524 8525 1.696 0.8 13.568 37
I8525 0 8525 1.26158e-05
R10231 8525 8526 1.664 0.8 13.312 37
I8526 0 8526 1.28631e-05
R10232 8526 8527 1.696 0.8 13.568 37
I8527 0 8527 1.28631e-05
R10233 8527 8528 1.68 0.8 13.44 37
I8528 0 8528 1.23684e-05
R10234 8528 8529 1.744 0.8 13.952 37
I8529 0 8529 1.27395e-05
R10235 8529 8530 1.712 0.8 13.696 37
I8530 0 8530 1.23684e-05
R10236 8530 0 0.1 49.28 49.28 37
*seg: 854
R10237 0 8531 0.1 49.28 49.28 37
R10238 8535 8545 6.16 0.8 49.28 37
I8531 0 8531 1.27395e-05
R10239 8531 8532 1.648 0.8 13.184 37
I8532 0 8532 1.27395e-05
R10240 8532 8533 1.6 0.8 12.8 37
I8533 0 8533 1.27395e-05
R10241 8533 8534 1.728 0.8 13.824 37
I8534 0 8534 1.29868e-05
R10242 8534 8535 1.68 0.8 13.44 37
I8535 0 8535 1.28631e-05
R10243 8535 8536 1.632 0.8 13.056 37
I8536 0 8536 1.24921e-05
R10244 8536 8537 1.6 0.8 12.8 37
I8537 0 8537 1.28631e-05
R10245 8537 8538 1.664 0.8 13.312 37
I8538 0 8538 1.32342e-05
R10246 8538 8539 1.6 0.8 12.8 37
I8539 0 8539 1.31105e-05
R10247 8539 8540 1.648 0.8 13.184 37
I8540 0 8540 1.23684e-05
R10248 8540 0 0.1 49.28 49.28 37
*seg: 855
R10249 0 8541 0.1 49.28 49.28 37
R10250 8545 8555 6.16 0.8 49.28 37
I8541 0 8541 1.33579e-05
R10251 8541 8542 1.664 0.8 13.312 37
I8542 0 8542 1.29868e-05
R10252 8542 8543 1.712 0.8 13.696 37
I8543 0 8543 1.24921e-05
R10253 8543 8544 1.712 0.8 13.696 37
I8544 0 8544 1.32342e-05
R10254 8544 8545 1.728 0.8 13.824 37
I8545 0 8545 1.29868e-05
R10255 8545 8546 1.6 0.8 12.8 37
I8546 0 8546 1.33579e-05
R10256 8546 8547 1.712 0.8 13.696 37
I8547 0 8547 1.34816e-05
R10257 8547 8548 1.712 0.8 13.696 37
I8548 0 8548 1.27395e-05
R10258 8548 8549 1.712 0.8 13.696 37
I8549 0 8549 1.24921e-05
R10259 8549 8550 1.6 0.8 12.8 37
I8550 0 8550 1.23684e-05
R10260 8550 0 0.1 49.28 49.28 37
*seg: 856
R10261 0 8551 0.1 49.28 49.28 37
R10262 8555 8565 6.16 0.8 49.28 37
I8551 0 8551 1.24921e-05
R10263 8551 8552 1.68 0.8 13.44 37
I8552 0 8552 1.26158e-05
R10264 8552 8553 1.712 0.8 13.696 37
I8553 0 8553 1.27395e-05
R10265 8553 8554 1.632 0.8 13.056 37
I8554 0 8554 1.33579e-05
R10266 8554 8555 1.632 0.8 13.056 37
I8555 0 8555 1.24921e-05
R10267 8555 8556 1.648 0.8 13.184 37
I8556 0 8556 1.32342e-05
R10268 8556 8557 1.696 0.8 13.568 37
I8557 0 8557 1.23684e-05
R10269 8557 8558 1.632 0.8 13.056 37
I8558 0 8558 1.26158e-05
R10270 8558 8559 1.632 0.8 13.056 37
I8559 0 8559 1.29868e-05
R10271 8559 8560 1.712 0.8 13.696 37
I8560 0 8560 1.23684e-05
R10272 8560 0 0.1 49.28 49.28 37
*seg: 857
R10273 0 8561 0.1 49.28 49.28 37
R10274 8565 8575 6.16 0.8 49.28 37
I8561 0 8561 1.31105e-05
R10275 8561 8562 1.6 0.8 12.8 37
I8562 0 8562 1.29868e-05
R10276 8562 8563 1.728 0.8 13.824 37
I8563 0 8563 1.33579e-05
R10277 8563 8564 1.648 0.8 13.184 37
I8564 0 8564 1.32342e-05
R10278 8564 8565 1.6 0.8 12.8 37
I8565 0 8565 1.34816e-05
R10279 8565 8566 1.616 0.8 12.928 37
I8566 0 8566 1.32342e-05
R10280 8566 8567 1.712 0.8 13.696 37
I8567 0 8567 1.26158e-05
R10281 8567 8568 1.696 0.8 13.568 37
I8568 0 8568 1.26158e-05
R10282 8568 8569 1.632 0.8 13.056 37
I8569 0 8569 1.26158e-05
R10283 8569 8570 1.6 0.8 12.8 37
I8570 0 8570 1.23684e-05
R10284 8570 0 0.1 49.28 49.28 37
*seg: 858
R10285 0 8571 0.1 49.28 49.28 37
R10286 8575 8585 6.16 0.8 49.28 37
I8571 0 8571 1.26158e-05
R10287 8571 8572 1.616 0.8 12.928 37
I8572 0 8572 1.23684e-05
R10288 8572 8573 1.696 0.8 13.568 37
I8573 0 8573 1.33579e-05
R10289 8573 8574 1.712 0.8 13.696 37
I8574 0 8574 1.32342e-05
R10290 8574 8575 1.696 0.8 13.568 37
I8575 0 8575 1.33579e-05
R10291 8575 8576 1.616 0.8 12.928 37
I8576 0 8576 1.23684e-05
R10292 8576 8577 1.712 0.8 13.696 37
I8577 0 8577 1.31105e-05
R10293 8577 8578 1.728 0.8 13.824 37
I8578 0 8578 1.32342e-05
R10294 8578 8579 1.6 0.8 12.8 37
I8579 0 8579 1.24921e-05
R10295 8579 8580 1.6 0.8 12.8 37
I8580 0 8580 1.23684e-05
R10296 8580 0 0.1 49.28 49.28 37
*seg: 859
R10297 0 8581 0.1 49.28 49.28 37
R10298 8585 8595 6.16 0.8 49.28 37
I8581 0 8581 1.34816e-05
R10299 8581 8582 1.648 0.8 13.184 37
I8582 0 8582 1.23684e-05
R10300 8582 8583 1.616 0.8 12.928 37
I8583 0 8583 1.23684e-05
R10301 8583 8584 1.632 0.8 13.056 37
I8584 0 8584 1.32342e-05
R10302 8584 8585 1.744 0.8 13.952 37
I8585 0 8585 1.24921e-05
R10303 8585 8586 1.632 0.8 13.056 37
I8586 0 8586 1.28631e-05
R10304 8586 8587 1.712 0.8 13.696 37
I8587 0 8587 1.31105e-05
R10305 8587 8588 1.632 0.8 13.056 37
I8588 0 8588 1.34816e-05
R10306 8588 8589 1.616 0.8 12.928 37
I8589 0 8589 1.33579e-05
R10307 8589 8590 1.664 0.8 13.312 37
I8590 0 8590 1.23684e-05
R10308 8590 0 0.1 49.28 49.28 37
*seg: 860
R10309 0 8591 0.1 49.28 49.28 37
R10310 8595 8605 6.16 0.8 49.28 37
I8591 0 8591 1.33579e-05
R10311 8591 8592 1.664 0.8 13.312 37
I8592 0 8592 1.32342e-05
R10312 8592 8593 1.712 0.8 13.696 37
I8593 0 8593 1.29868e-05
R10313 8593 8594 1.728 0.8 13.824 37
I8594 0 8594 1.33579e-05
R10314 8594 8595 1.68 0.8 13.44 37
I8595 0 8595 1.32342e-05
R10315 8595 8596 1.664 0.8 13.312 37
I8596 0 8596 1.28631e-05
R10316 8596 8597 1.728 0.8 13.824 37
I8597 0 8597 1.31105e-05
R10317 8597 8598 1.712 0.8 13.696 37
I8598 0 8598 1.27395e-05
R10318 8598 8599 1.616 0.8 12.928 37
I8599 0 8599 1.32342e-05
R10319 8599 8600 1.648 0.8 13.184 37
I8600 0 8600 1.23684e-05
R10320 8600 0 0.1 49.28 49.28 37
*seg: 861
R10321 0 8601 0.1 49.28 49.28 37
R10322 8605 8615 6.16 0.8 49.28 37
I8601 0 8601 1.33579e-05
R10323 8601 8602 1.632 0.8 13.056 37
I8602 0 8602 1.33579e-05
R10324 8602 8603 1.648 0.8 13.184 37
I8603 0 8603 1.26158e-05
R10325 8603 8604 1.744 0.8 13.952 37
I8604 0 8604 1.34816e-05
R10326 8604 8605 1.696 0.8 13.568 37
I8605 0 8605 1.24921e-05
R10327 8605 8606 1.728 0.8 13.824 37
I8606 0 8606 1.28631e-05
R10328 8606 8607 1.712 0.8 13.696 37
I8607 0 8607 1.31105e-05
R10329 8607 8608 1.744 0.8 13.952 37
I8608 0 8608 1.28631e-05
R10330 8608 8609 1.632 0.8 13.056 37
I8609 0 8609 1.32342e-05
R10331 8609 8610 1.696 0.8 13.568 37
I8610 0 8610 1.23684e-05
R10332 8610 0 0.1 49.28 49.28 37
*seg: 862
R10333 0 8611 0.1 49.28 49.28 37
R10334 8615 8625 6.16 0.8 49.28 37
I8611 0 8611 1.33579e-05
R10335 8611 8612 1.744 0.8 13.952 37
I8612 0 8612 1.24921e-05
R10336 8612 8613 1.68 0.8 13.44 37
I8613 0 8613 1.32342e-05
R10337 8613 8614 1.68 0.8 13.44 37
I8614 0 8614 1.28631e-05
R10338 8614 8615 1.616 0.8 12.928 37
I8615 0 8615 1.26158e-05
R10339 8615 8616 1.712 0.8 13.696 37
I8616 0 8616 1.28631e-05
R10340 8616 8617 1.6 0.8 12.8 37
I8617 0 8617 1.26158e-05
R10341 8617 8618 1.712 0.8 13.696 37
I8618 0 8618 1.29868e-05
R10342 8618 8619 1.728 0.8 13.824 37
I8619 0 8619 1.27395e-05
R10343 8619 8620 1.68 0.8 13.44 37
I8620 0 8620 1.23684e-05
R10344 8620 0 0.1 49.28 49.28 37
*seg: 863
R10345 0 8621 0.1 49.28 49.28 37
R10346 8625 8635 6.16 0.8 49.28 37
I8621 0 8621 1.32342e-05
R10347 8621 8622 1.6 0.8 12.8 37
I8622 0 8622 1.33579e-05
R10348 8622 8623 1.744 0.8 13.952 37
I8623 0 8623 1.34816e-05
R10349 8623 8624 1.728 0.8 13.824 37
I8624 0 8624 1.26158e-05
R10350 8624 8625 1.648 0.8 13.184 37
I8625 0 8625 1.31105e-05
R10351 8625 8626 1.616 0.8 12.928 37
I8626 0 8626 1.33579e-05
R10352 8626 8627 1.744 0.8 13.952 37
I8627 0 8627 1.27395e-05
R10353 8627 8628 1.648 0.8 13.184 37
I8628 0 8628 1.24921e-05
R10354 8628 8629 1.728 0.8 13.824 37
I8629 0 8629 1.26158e-05
R10355 8629 8630 1.616 0.8 12.928 37
I8630 0 8630 1.23684e-05
R10356 8630 0 0.1 49.28 49.28 37
*seg: 864
R10357 0 8631 0.1 49.28 49.28 37
R10358 8635 8645 6.16 0.8 49.28 37
I8631 0 8631 1.31105e-05
R10359 8631 8632 1.632 0.8 13.056 37
I8632 0 8632 1.32342e-05
R10360 8632 8633 1.728 0.8 13.824 37
I8633 0 8633 1.32342e-05
R10361 8633 8634 1.648 0.8 13.184 37
I8634 0 8634 1.34816e-05
R10362 8634 8635 1.696 0.8 13.568 37
I8635 0 8635 1.32342e-05
R10363 8635 8636 1.712 0.8 13.696 37
I8636 0 8636 1.29868e-05
R10364 8636 8637 1.696 0.8 13.568 37
I8637 0 8637 1.27395e-05
R10365 8637 8638 1.696 0.8 13.568 37
I8638 0 8638 1.27395e-05
R10366 8638 8639 1.712 0.8 13.696 37
I8639 0 8639 1.33579e-05
R10367 8639 8640 1.68 0.8 13.44 37
I8640 0 8640 1.23684e-05
R10368 8640 0 0.1 49.28 49.28 37
*seg: 865
R10369 0 8641 0.1 49.28 49.28 37
R10370 8645 8655 6.16 0.8 49.28 37
I8641 0 8641 1.28631e-05
R10371 8641 8642 1.664 0.8 13.312 37
I8642 0 8642 1.24921e-05
R10372 8642 8643 1.6 0.8 12.8 37
I8643 0 8643 1.24921e-05
R10373 8643 8644 1.632 0.8 13.056 37
I8644 0 8644 1.24921e-05
R10374 8644 8645 1.664 0.8 13.312 37
I8645 0 8645 1.31105e-05
R10375 8645 8646 1.728 0.8 13.824 37
I8646 0 8646 1.24921e-05
R10376 8646 8647 1.6 0.8 12.8 37
I8647 0 8647 1.32342e-05
R10377 8647 8648 1.648 0.8 13.184 37
I8648 0 8648 1.34816e-05
R10378 8648 8649 1.744 0.8 13.952 37
I8649 0 8649 1.32342e-05
R10379 8649 8650 1.744 0.8 13.952 37
I8650 0 8650 1.23684e-05
R10380 8650 0 0.1 49.28 49.28 37
*seg: 866
R10381 0 8651 0.1 49.28 49.28 37
R10382 8655 8665 6.16 0.8 49.28 37
I8651 0 8651 1.24921e-05
R10383 8651 8652 1.632 0.8 13.056 37
I8652 0 8652 1.26158e-05
R10384 8652 8653 1.664 0.8 13.312 37
I8653 0 8653 1.29868e-05
R10385 8653 8654 1.6 0.8 12.8 37
I8654 0 8654 1.33579e-05
R10386 8654 8655 1.728 0.8 13.824 37
I8655 0 8655 1.28631e-05
R10387 8655 8656 1.728 0.8 13.824 37
I8656 0 8656 1.28631e-05
R10388 8656 8657 1.696 0.8 13.568 37
I8657 0 8657 1.34816e-05
R10389 8657 8658 1.712 0.8 13.696 37
I8658 0 8658 1.32342e-05
R10390 8658 8659 1.728 0.8 13.824 37
I8659 0 8659 1.24921e-05
R10391 8659 8660 1.728 0.8 13.824 37
I8660 0 8660 1.23684e-05
R10392 8660 0 0.1 49.28 49.28 37
*seg: 867
R10393 0 8661 0.1 49.28 49.28 37
R10394 8665 8675 6.16 0.8 49.28 37
I8661 0 8661 1.29868e-05
R10395 8661 8662 1.696 0.8 13.568 37
I8662 0 8662 1.31105e-05
R10396 8662 8663 1.648 0.8 13.184 37
I8663 0 8663 1.28631e-05
R10397 8663 8664 1.632 0.8 13.056 37
I8664 0 8664 1.24921e-05
R10398 8664 8665 1.616 0.8 12.928 37
I8665 0 8665 1.31105e-05
R10399 8665 8666 1.696 0.8 13.568 37
I8666 0 8666 1.32342e-05
R10400 8666 8667 1.744 0.8 13.952 37
I8667 0 8667 1.24921e-05
R10401 8667 8668 1.616 0.8 12.928 37
I8668 0 8668 1.33579e-05
R10402 8668 8669 1.664 0.8 13.312 37
I8669 0 8669 1.34816e-05
R10403 8669 8670 1.648 0.8 13.184 37
I8670 0 8670 1.23684e-05
R10404 8670 0 0.1 49.28 49.28 37
*seg: 868
R10405 0 8671 0.1 49.28 49.28 37
R10406 8675 8685 6.16 0.8 49.28 37
I8671 0 8671 1.28631e-05
R10407 8671 8672 1.696 0.8 13.568 37
I8672 0 8672 1.32342e-05
R10408 8672 8673 1.648 0.8 13.184 37
I8673 0 8673 1.31105e-05
R10409 8673 8674 1.632 0.8 13.056 37
I8674 0 8674 1.28631e-05
R10410 8674 8675 1.664 0.8 13.312 37
I8675 0 8675 1.31105e-05
R10411 8675 8676 1.616 0.8 12.928 37
I8676 0 8676 1.26158e-05
R10412 8676 8677 1.648 0.8 13.184 37
I8677 0 8677 1.33579e-05
R10413 8677 8678 1.616 0.8 12.928 37
I8678 0 8678 1.28631e-05
R10414 8678 8679 1.6 0.8 12.8 37
I8679 0 8679 1.27395e-05
R10415 8679 8680 1.616 0.8 12.928 37
I8680 0 8680 1.23684e-05
R10416 8680 0 0.1 49.28 49.28 37
*seg: 869
R10417 0 8681 0.1 49.28 49.28 37
R10418 8685 8695 6.16 0.8 49.28 37
I8681 0 8681 1.29868e-05
R10419 8681 8682 1.648 0.8 13.184 37
I8682 0 8682 1.34816e-05
R10420 8682 8683 1.632 0.8 13.056 37
I8683 0 8683 1.26158e-05
R10421 8683 8684 1.68 0.8 13.44 37
I8684 0 8684 1.31105e-05
R10422 8684 8685 1.68 0.8 13.44 37
I8685 0 8685 1.27395e-05
R10423 8685 8686 1.648 0.8 13.184 37
I8686 0 8686 1.28631e-05
R10424 8686 8687 1.68 0.8 13.44 37
I8687 0 8687 1.24921e-05
R10425 8687 8688 1.728 0.8 13.824 37
I8688 0 8688 1.23684e-05
R10426 8688 8689 1.712 0.8 13.696 37
I8689 0 8689 1.26158e-05
R10427 8689 8690 1.632 0.8 13.056 37
I8690 0 8690 1.23684e-05
R10428 8690 0 0.1 49.28 49.28 37
*seg: 870
R10429 0 8691 0.1 49.28 49.28 37
R10430 8695 8705 6.16 0.8 49.28 37
I8691 0 8691 1.27395e-05
R10431 8691 8692 1.6 0.8 12.8 37
I8692 0 8692 1.27395e-05
R10432 8692 8693 1.744 0.8 13.952 37
I8693 0 8693 1.33579e-05
R10433 8693 8694 1.728 0.8 13.824 37
I8694 0 8694 1.24921e-05
R10434 8694 8695 1.648 0.8 13.184 37
I8695 0 8695 1.34816e-05
R10435 8695 8696 1.696 0.8 13.568 37
I8696 0 8696 1.32342e-05
R10436 8696 8697 1.6 0.8 12.8 37
I8697 0 8697 1.27395e-05
R10437 8697 8698 1.712 0.8 13.696 37
I8698 0 8698 1.31105e-05
R10438 8698 8699 1.664 0.8 13.312 37
I8699 0 8699 1.29868e-05
R10439 8699 8700 1.664 0.8 13.312 37
I8700 0 8700 1.23684e-05
R10440 8700 0 0.1 49.28 49.28 37
*seg: 871
R10441 0 8701 0.1 49.28 49.28 37
R10442 8705 8715 6.16 0.8 49.28 37
I8701 0 8701 1.27395e-05
R10443 8701 8702 1.728 0.8 13.824 37
I8702 0 8702 1.27395e-05
R10444 8702 8703 1.712 0.8 13.696 37
I8703 0 8703 1.31105e-05
R10445 8703 8704 1.696 0.8 13.568 37
I8704 0 8704 1.34816e-05
R10446 8704 8705 1.696 0.8 13.568 37
I8705 0 8705 1.28631e-05
R10447 8705 8706 1.664 0.8 13.312 37
I8706 0 8706 1.23684e-05
R10448 8706 8707 1.616 0.8 12.928 37
I8707 0 8707 1.24921e-05
R10449 8707 8708 1.68 0.8 13.44 37
I8708 0 8708 1.29868e-05
R10450 8708 8709 1.712 0.8 13.696 37
I8709 0 8709 1.23684e-05
R10451 8709 8710 1.6 0.8 12.8 37
I8710 0 8710 1.23684e-05
R10452 8710 0 0.1 49.28 49.28 37
*seg: 872
R10453 0 8711 0.1 49.28 49.28 37
R10454 8715 8725 6.16 0.8 49.28 37
I8711 0 8711 1.24921e-05
R10455 8711 8712 1.632 0.8 13.056 37
I8712 0 8712 1.34816e-05
R10456 8712 8713 1.712 0.8 13.696 37
I8713 0 8713 1.24921e-05
R10457 8713 8714 1.696 0.8 13.568 37
I8714 0 8714 1.32342e-05
R10458 8714 8715 1.744 0.8 13.952 37
I8715 0 8715 1.33579e-05
R10459 8715 8716 1.616 0.8 12.928 37
I8716 0 8716 1.28631e-05
R10460 8716 8717 1.664 0.8 13.312 37
I8717 0 8717 1.31105e-05
R10461 8717 8718 1.68 0.8 13.44 37
I8718 0 8718 1.34816e-05
R10462 8718 8719 1.712 0.8 13.696 37
I8719 0 8719 1.27395e-05
R10463 8719 8720 1.712 0.8 13.696 37
I8720 0 8720 1.23684e-05
R10464 8720 0 0.1 49.28 49.28 37
*seg: 873
R10465 0 8721 0.1 49.28 49.28 37
R10466 8725 8735 6.16 0.8 49.28 37
I8721 0 8721 1.31105e-05
R10467 8721 8722 1.712 0.8 13.696 37
I8722 0 8722 1.27395e-05
R10468 8722 8723 1.728 0.8 13.824 37
I8723 0 8723 1.26158e-05
R10469 8723 8724 1.728 0.8 13.824 37
I8724 0 8724 1.29868e-05
R10470 8724 8725 1.632 0.8 13.056 37
I8725 0 8725 1.31105e-05
R10471 8725 8726 1.616 0.8 12.928 37
I8726 0 8726 1.28631e-05
R10472 8726 8727 1.744 0.8 13.952 37
I8727 0 8727 1.31105e-05
R10473 8727 8728 1.632 0.8 13.056 37
I8728 0 8728 1.29868e-05
R10474 8728 8729 1.712 0.8 13.696 37
I8729 0 8729 1.34816e-05
R10475 8729 8730 1.744 0.8 13.952 37
I8730 0 8730 1.23684e-05
R10476 8730 0 0.1 49.28 49.28 37
*seg: 874
R10477 0 8731 0.1 49.28 49.28 37
R10478 8735 8745 6.16 0.8 49.28 37
I8731 0 8731 1.23684e-05
R10479 8731 8732 1.712 0.8 13.696 37
I8732 0 8732 1.32342e-05
R10480 8732 8733 1.712 0.8 13.696 37
I8733 0 8733 1.32342e-05
R10481 8733 8734 1.744 0.8 13.952 37
I8734 0 8734 1.34816e-05
R10482 8734 8735 1.696 0.8 13.568 37
I8735 0 8735 1.29868e-05
R10483 8735 8736 1.712 0.8 13.696 37
I8736 0 8736 1.31105e-05
R10484 8736 8737 1.616 0.8 12.928 37
I8737 0 8737 1.31105e-05
R10485 8737 8738 1.68 0.8 13.44 37
I8738 0 8738 1.29868e-05
R10486 8738 8739 1.712 0.8 13.696 37
I8739 0 8739 1.28631e-05
R10487 8739 8740 1.648 0.8 13.184 37
I8740 0 8740 1.23684e-05
R10488 8740 0 0.1 49.28 49.28 37
*seg: 875
R10489 0 8741 0.1 49.28 49.28 37
R10490 8745 8755 6.16 0.8 49.28 37
I8741 0 8741 1.23684e-05
R10491 8741 8742 1.744 0.8 13.952 37
I8742 0 8742 1.32342e-05
R10492 8742 8743 1.6 0.8 12.8 37
I8743 0 8743 1.28631e-05
R10493 8743 8744 1.664 0.8 13.312 37
I8744 0 8744 1.33579e-05
R10494 8744 8745 1.728 0.8 13.824 37
I8745 0 8745 1.27395e-05
R10495 8745 8746 1.6 0.8 12.8 37
I8746 0 8746 1.34816e-05
R10496 8746 8747 1.616 0.8 12.928 37
I8747 0 8747 1.23684e-05
R10497 8747 8748 1.664 0.8 13.312 37
I8748 0 8748 1.26158e-05
R10498 8748 8749 1.696 0.8 13.568 37
I8749 0 8749 1.26158e-05
R10499 8749 8750 1.68 0.8 13.44 37
I8750 0 8750 1.23684e-05
R10500 8750 0 0.1 49.28 49.28 37
*seg: 876
R10501 0 8751 0.1 49.28 49.28 37
R10502 8755 8765 6.16 0.8 49.28 37
I8751 0 8751 1.24921e-05
R10503 8751 8752 1.68 0.8 13.44 37
I8752 0 8752 1.32342e-05
R10504 8752 8753 1.648 0.8 13.184 37
I8753 0 8753 1.32342e-05
R10505 8753 8754 1.6 0.8 12.8 37
I8754 0 8754 1.32342e-05
R10506 8754 8755 1.664 0.8 13.312 37
I8755 0 8755 1.33579e-05
R10507 8755 8756 1.68 0.8 13.44 37
I8756 0 8756 1.26158e-05
R10508 8756 8757 1.68 0.8 13.44 37
I8757 0 8757 1.23684e-05
R10509 8757 8758 1.632 0.8 13.056 37
I8758 0 8758 1.28631e-05
R10510 8758 8759 1.728 0.8 13.824 37
I8759 0 8759 1.27395e-05
R10511 8759 8760 1.744 0.8 13.952 37
I8760 0 8760 1.23684e-05
R10512 8760 0 0.1 49.28 49.28 37
*seg: 877
R10513 0 8761 0.1 49.28 49.28 37
R10514 8765 8775 6.16 0.8 49.28 37
I8761 0 8761 1.34816e-05
R10515 8761 8762 1.616 0.8 12.928 37
I8762 0 8762 1.29868e-05
R10516 8762 8763 1.632 0.8 13.056 37
I8763 0 8763 1.34816e-05
R10517 8763 8764 1.68 0.8 13.44 37
I8764 0 8764 1.33579e-05
R10518 8764 8765 1.68 0.8 13.44 37
I8765 0 8765 1.23684e-05
R10519 8765 8766 1.616 0.8 12.928 37
I8766 0 8766 1.24921e-05
R10520 8766 8767 1.616 0.8 12.928 37
I8767 0 8767 1.32342e-05
R10521 8767 8768 1.6 0.8 12.8 37
I8768 0 8768 1.33579e-05
R10522 8768 8769 1.744 0.8 13.952 37
I8769 0 8769 1.24921e-05
R10523 8769 8770 1.696 0.8 13.568 37
I8770 0 8770 1.23684e-05
R10524 8770 0 0.1 49.28 49.28 37
*seg: 878
R10525 0 8771 0.1 49.28 49.28 37
R10526 8775 8785 6.16 0.8 49.28 37
I8771 0 8771 1.26158e-05
R10527 8771 8772 1.664 0.8 13.312 37
I8772 0 8772 1.34816e-05
R10528 8772 8773 1.616 0.8 12.928 37
I8773 0 8773 1.26158e-05
R10529 8773 8774 1.664 0.8 13.312 37
I8774 0 8774 1.34816e-05
R10530 8774 8775 1.744 0.8 13.952 37
I8775 0 8775 1.32342e-05
R10531 8775 8776 1.744 0.8 13.952 37
I8776 0 8776 1.23684e-05
R10532 8776 8777 1.728 0.8 13.824 37
I8777 0 8777 1.29868e-05
R10533 8777 8778 1.68 0.8 13.44 37
I8778 0 8778 1.24921e-05
R10534 8778 8779 1.664 0.8 13.312 37
I8779 0 8779 1.34816e-05
R10535 8779 8780 1.744 0.8 13.952 37
I8780 0 8780 1.23684e-05
R10536 8780 0 0.1 49.28 49.28 37
*seg: 879
R10537 0 8781 0.1 49.28 49.28 37
R10538 8785 8795 6.16 0.8 49.28 37
I8781 0 8781 1.24921e-05
R10539 8781 8782 1.728 0.8 13.824 37
I8782 0 8782 1.34816e-05
R10540 8782 8783 1.616 0.8 12.928 37
I8783 0 8783 1.29868e-05
R10541 8783 8784 1.648 0.8 13.184 37
I8784 0 8784 1.31105e-05
R10542 8784 8785 1.632 0.8 13.056 37
I8785 0 8785 1.32342e-05
R10543 8785 8786 1.616 0.8 12.928 37
I8786 0 8786 1.23684e-05
R10544 8786 8787 1.664 0.8 13.312 37
I8787 0 8787 1.24921e-05
R10545 8787 8788 1.728 0.8 13.824 37
I8788 0 8788 1.31105e-05
R10546 8788 8789 1.664 0.8 13.312 37
I8789 0 8789 1.23684e-05
R10547 8789 8790 1.744 0.8 13.952 37
I8790 0 8790 1.23684e-05
R10548 8790 0 0.1 49.28 49.28 37
*seg: 880
R10549 0 8791 0.1 49.28 49.28 37
R10550 8795 8805 6.16 0.8 49.28 37
I8791 0 8791 1.29868e-05
R10551 8791 8792 1.68 0.8 13.44 37
I8792 0 8792 1.28631e-05
R10552 8792 8793 1.728 0.8 13.824 37
I8793 0 8793 1.34816e-05
R10553 8793 8794 1.6 0.8 12.8 37
I8794 0 8794 1.32342e-05
R10554 8794 8795 1.744 0.8 13.952 37
I8795 0 8795 1.23684e-05
R10555 8795 8796 1.664 0.8 13.312 37
I8796 0 8796 1.24921e-05
R10556 8796 8797 1.696 0.8 13.568 37
I8797 0 8797 1.27395e-05
R10557 8797 8798 1.728 0.8 13.824 37
I8798 0 8798 1.24921e-05
R10558 8798 8799 1.6 0.8 12.8 37
I8799 0 8799 1.29868e-05
R10559 8799 8800 1.664 0.8 13.312 37
I8800 0 8800 1.23684e-05
R10560 8800 0 0.1 49.28 49.28 37
*seg: 881
R10561 0 8801 0.1 49.28 49.28 37
R10562 8805 8815 6.16 0.8 49.28 37
I8801 0 8801 1.27395e-05
R10563 8801 8802 1.712 0.8 13.696 37
I8802 0 8802 1.34816e-05
R10564 8802 8803 1.712 0.8 13.696 37
I8803 0 8803 1.24921e-05
R10565 8803 8804 1.616 0.8 12.928 37
I8804 0 8804 1.28631e-05
R10566 8804 8805 1.632 0.8 13.056 37
I8805 0 8805 1.24921e-05
R10567 8805 8806 1.664 0.8 13.312 37
I8806 0 8806 1.32342e-05
R10568 8806 8807 1.68 0.8 13.44 37
I8807 0 8807 1.28631e-05
R10569 8807 8808 1.712 0.8 13.696 37
I8808 0 8808 1.23684e-05
R10570 8808 8809 1.664 0.8 13.312 37
I8809 0 8809 1.26158e-05
R10571 8809 8810 1.712 0.8 13.696 37
I8810 0 8810 1.23684e-05
R10572 8810 0 0.1 49.28 49.28 37
*seg: 882
R10573 0 8811 0.1 49.28 49.28 37
R10574 8815 8825 6.16 0.8 49.28 37
I8811 0 8811 1.32342e-05
R10575 8811 8812 1.712 0.8 13.696 37
I8812 0 8812 1.34816e-05
R10576 8812 8813 1.632 0.8 13.056 37
I8813 0 8813 1.24921e-05
R10577 8813 8814 1.744 0.8 13.952 37
I8814 0 8814 1.26158e-05
R10578 8814 8815 1.696 0.8 13.568 37
I8815 0 8815 1.28631e-05
R10579 8815 8816 1.712 0.8 13.696 37
I8816 0 8816 1.34816e-05
R10580 8816 8817 1.68 0.8 13.44 37
I8817 0 8817 1.28631e-05
R10581 8817 8818 1.696 0.8 13.568 37
I8818 0 8818 1.31105e-05
R10582 8818 8819 1.632 0.8 13.056 37
I8819 0 8819 1.33579e-05
R10583 8819 8820 1.6 0.8 12.8 37
I8820 0 8820 1.23684e-05
R10584 8820 0 0.1 49.28 49.28 37
*seg: 883
R10585 0 8821 0.1 49.28 49.28 37
R10586 8825 8835 6.16 0.8 49.28 37
I8821 0 8821 1.31105e-05
R10587 8821 8822 1.664 0.8 13.312 37
I8822 0 8822 1.34816e-05
R10588 8822 8823 1.6 0.8 12.8 37
I8823 0 8823 1.32342e-05
R10589 8823 8824 1.632 0.8 13.056 37
I8824 0 8824 1.27395e-05
R10590 8824 8825 1.712 0.8 13.696 37
I8825 0 8825 1.24921e-05
R10591 8825 8826 1.632 0.8 13.056 37
I8826 0 8826 1.31105e-05
R10592 8826 8827 1.6 0.8 12.8 37
I8827 0 8827 1.31105e-05
R10593 8827 8828 1.744 0.8 13.952 37
I8828 0 8828 1.23684e-05
R10594 8828 8829 1.6 0.8 12.8 37
I8829 0 8829 1.34816e-05
R10595 8829 8830 1.696 0.8 13.568 37
I8830 0 8830 1.23684e-05
R10596 8830 0 0.1 49.28 49.28 37
*seg: 884
R10597 0 8831 0.1 49.28 49.28 37
R10598 8835 8845 6.16 0.8 49.28 37
I8831 0 8831 1.26158e-05
R10599 8831 8832 1.632 0.8 13.056 37
I8832 0 8832 1.23684e-05
R10600 8832 8833 1.648 0.8 13.184 37
I8833 0 8833 1.29868e-05
R10601 8833 8834 1.696 0.8 13.568 37
I8834 0 8834 1.26158e-05
R10602 8834 8835 1.632 0.8 13.056 37
I8835 0 8835 1.33579e-05
R10603 8835 8836 1.664 0.8 13.312 37
I8836 0 8836 1.33579e-05
R10604 8836 8837 1.616 0.8 12.928 37
I8837 0 8837 1.26158e-05
R10605 8837 8838 1.616 0.8 12.928 37
I8838 0 8838 1.28631e-05
R10606 8838 8839 1.616 0.8 12.928 37
I8839 0 8839 1.28631e-05
R10607 8839 8840 1.6 0.8 12.8 37
I8840 0 8840 1.23684e-05
R10608 8840 0 0.1 49.28 49.28 37
*seg: 885
R10609 0 8841 0.1 49.28 49.28 37
R10610 8845 8855 6.16 0.8 49.28 37
I8841 0 8841 1.28631e-05
R10611 8841 8842 1.712 0.8 13.696 37
I8842 0 8842 1.26158e-05
R10612 8842 8843 1.648 0.8 13.184 37
I8843 0 8843 1.26158e-05
R10613 8843 8844 1.616 0.8 12.928 37
I8844 0 8844 1.32342e-05
R10614 8844 8845 1.712 0.8 13.696 37
I8845 0 8845 1.29868e-05
R10615 8845 8846 1.712 0.8 13.696 37
I8846 0 8846 1.31105e-05
R10616 8846 8847 1.68 0.8 13.44 37
I8847 0 8847 1.32342e-05
R10617 8847 8848 1.696 0.8 13.568 37
I8848 0 8848 1.28631e-05
R10618 8848 8849 1.68 0.8 13.44 37
I8849 0 8849 1.24921e-05
R10619 8849 8850 1.632 0.8 13.056 37
I8850 0 8850 1.23684e-05
R10620 8850 0 0.1 49.28 49.28 37
*seg: 886
R10621 0 8851 0.1 49.28 49.28 37
R10622 8855 8865 6.16 0.8 49.28 37
I8851 0 8851 1.28631e-05
R10623 8851 8852 1.728 0.8 13.824 37
I8852 0 8852 1.31105e-05
R10624 8852 8853 1.696 0.8 13.568 37
I8853 0 8853 1.31105e-05
R10625 8853 8854 1.632 0.8 13.056 37
I8854 0 8854 1.24921e-05
R10626 8854 8855 1.632 0.8 13.056 37
I8855 0 8855 1.23684e-05
R10627 8855 8856 1.632 0.8 13.056 37
I8856 0 8856 1.34816e-05
R10628 8856 8857 1.696 0.8 13.568 37
I8857 0 8857 1.33579e-05
R10629 8857 8858 1.648 0.8 13.184 37
I8858 0 8858 1.32342e-05
R10630 8858 8859 1.664 0.8 13.312 37
I8859 0 8859 1.28631e-05
R10631 8859 8860 1.616 0.8 12.928 37
I8860 0 8860 1.23684e-05
R10632 8860 0 0.1 49.28 49.28 37
*seg: 887
R10633 0 8861 0.1 49.28 49.28 37
R10634 8865 8875 6.16 0.8 49.28 37
I8861 0 8861 1.34816e-05
R10635 8861 8862 1.712 0.8 13.696 37
I8862 0 8862 1.29868e-05
R10636 8862 8863 1.744 0.8 13.952 37
I8863 0 8863 1.32342e-05
R10637 8863 8864 1.664 0.8 13.312 37
I8864 0 8864 1.23684e-05
R10638 8864 8865 1.728 0.8 13.824 37
I8865 0 8865 1.24921e-05
R10639 8865 8866 1.68 0.8 13.44 37
I8866 0 8866 1.28631e-05
R10640 8866 8867 1.696 0.8 13.568 37
I8867 0 8867 1.31105e-05
R10641 8867 8868 1.648 0.8 13.184 37
I8868 0 8868 1.24921e-05
R10642 8868 8869 1.648 0.8 13.184 37
I8869 0 8869 1.34816e-05
R10643 8869 8870 1.728 0.8 13.824 37
I8870 0 8870 1.23684e-05
R10644 8870 0 0.1 49.28 49.28 37
*seg: 888
R10645 0 8871 0.1 49.28 49.28 37
R10646 8875 8885 6.16 0.8 49.28 37
I8871 0 8871 1.32342e-05
R10647 8871 8872 1.6 0.8 12.8 37
I8872 0 8872 1.24921e-05
R10648 8872 8873 1.664 0.8 13.312 37
I8873 0 8873 1.28631e-05
R10649 8873 8874 1.712 0.8 13.696 37
I8874 0 8874 1.32342e-05
R10650 8874 8875 1.696 0.8 13.568 37
I8875 0 8875 1.32342e-05
R10651 8875 8876 1.6 0.8 12.8 37
I8876 0 8876 1.24921e-05
R10652 8876 8877 1.664 0.8 13.312 37
I8877 0 8877 1.29868e-05
R10653 8877 8878 1.712 0.8 13.696 37
I8878 0 8878 1.33579e-05
R10654 8878 8879 1.6 0.8 12.8 37
I8879 0 8879 1.29868e-05
R10655 8879 8880 1.632 0.8 13.056 37
I8880 0 8880 1.23684e-05
R10656 8880 0 0.1 49.28 49.28 37
*seg: 889
R10657 0 8881 0.1 49.28 49.28 37
R10658 8885 8895 6.16 0.8 49.28 37
I8881 0 8881 1.28631e-05
R10659 8881 8882 1.68 0.8 13.44 37
I8882 0 8882 1.34816e-05
R10660 8882 8883 1.6 0.8 12.8 37
I8883 0 8883 1.33579e-05
R10661 8883 8884 1.712 0.8 13.696 37
I8884 0 8884 1.23684e-05
R10662 8884 8885 1.68 0.8 13.44 37
I8885 0 8885 1.32342e-05
R10663 8885 8886 1.68 0.8 13.44 37
I8886 0 8886 1.34816e-05
R10664 8886 8887 1.696 0.8 13.568 37
I8887 0 8887 1.31105e-05
R10665 8887 8888 1.648 0.8 13.184 37
I8888 0 8888 1.34816e-05
R10666 8888 8889 1.616 0.8 12.928 37
I8889 0 8889 1.31105e-05
R10667 8889 8890 1.6 0.8 12.8 37
I8890 0 8890 1.23684e-05
R10668 8890 0 0.1 49.28 49.28 37
*seg: 890
R10669 0 8891 0.1 49.28 49.28 37
R10670 8895 8905 6.16 0.8 49.28 37
I8891 0 8891 1.23684e-05
R10671 8891 8892 1.744 0.8 13.952 37
I8892 0 8892 1.29868e-05
R10672 8892 8893 1.68 0.8 13.44 37
I8893 0 8893 1.34816e-05
R10673 8893 8894 1.68 0.8 13.44 37
I8894 0 8894 1.27395e-05
R10674 8894 8895 1.728 0.8 13.824 37
I8895 0 8895 1.27395e-05
R10675 8895 8896 1.648 0.8 13.184 37
I8896 0 8896 1.31105e-05
R10676 8896 8897 1.68 0.8 13.44 37
I8897 0 8897 1.26158e-05
R10677 8897 8898 1.6 0.8 12.8 37
I8898 0 8898 1.33579e-05
R10678 8898 8899 1.632 0.8 13.056 37
I8899 0 8899 1.24921e-05
R10679 8899 8900 1.616 0.8 12.928 37
I8900 0 8900 1.23684e-05
R10680 8900 0 0.1 49.28 49.28 37
*seg: 891
R10681 0 8901 0.1 49.28 49.28 37
R10682 8905 8915 6.16 0.8 49.28 37
I8901 0 8901 1.28631e-05
R10683 8901 8902 1.68 0.8 13.44 37
I8902 0 8902 1.34816e-05
R10684 8902 8903 1.632 0.8 13.056 37
I8903 0 8903 1.33579e-05
R10685 8903 8904 1.648 0.8 13.184 37
I8904 0 8904 1.29868e-05
R10686 8904 8905 1.728 0.8 13.824 37
I8905 0 8905 1.29868e-05
R10687 8905 8906 1.696 0.8 13.568 37
I8906 0 8906 1.24921e-05
R10688 8906 8907 1.6 0.8 12.8 37
I8907 0 8907 1.24921e-05
R10689 8907 8908 1.712 0.8 13.696 37
I8908 0 8908 1.29868e-05
R10690 8908 8909 1.696 0.8 13.568 37
I8909 0 8909 1.31105e-05
R10691 8909 8910 1.664 0.8 13.312 37
I8910 0 8910 1.23684e-05
R10692 8910 0 0.1 49.28 49.28 37
*seg: 892
R10693 0 8911 0.1 49.28 49.28 37
R10694 8915 8925 6.16 0.8 49.28 37
I8911 0 8911 1.27395e-05
R10695 8911 8912 1.648 0.8 13.184 37
I8912 0 8912 1.33579e-05
R10696 8912 8913 1.68 0.8 13.44 37
I8913 0 8913 1.34816e-05
R10697 8913 8914 1.648 0.8 13.184 37
I8914 0 8914 1.28631e-05
R10698 8914 8915 1.728 0.8 13.824 37
I8915 0 8915 1.31105e-05
R10699 8915 8916 1.616 0.8 12.928 37
I8916 0 8916 1.34816e-05
R10700 8916 8917 1.696 0.8 13.568 37
I8917 0 8917 1.29868e-05
R10701 8917 8918 1.632 0.8 13.056 37
I8918 0 8918 1.26158e-05
R10702 8918 8919 1.744 0.8 13.952 37
I8919 0 8919 1.33579e-05
R10703 8919 8920 1.648 0.8 13.184 37
I8920 0 8920 1.23684e-05
R10704 8920 0 0.1 49.28 49.28 37
*seg: 893
R10705 0 8921 0.1 49.28 49.28 37
R10706 8925 8935 6.16 0.8 49.28 37
I8921 0 8921 1.29868e-05
R10707 8921 8922 1.728 0.8 13.824 37
I8922 0 8922 1.24921e-05
R10708 8922 8923 1.744 0.8 13.952 37
I8923 0 8923 1.31105e-05
R10709 8923 8924 1.6 0.8 12.8 37
I8924 0 8924 1.23684e-05
R10710 8924 8925 1.648 0.8 13.184 37
I8925 0 8925 1.34816e-05
R10711 8925 8926 1.728 0.8 13.824 37
I8926 0 8926 1.33579e-05
R10712 8926 8927 1.68 0.8 13.44 37
I8927 0 8927 1.32342e-05
R10713 8927 8928 1.696 0.8 13.568 37
I8928 0 8928 1.28631e-05
R10714 8928 8929 1.728 0.8 13.824 37
I8929 0 8929 1.32342e-05
R10715 8929 8930 1.632 0.8 13.056 37
I8930 0 8930 1.23684e-05
R10716 8930 0 0.1 49.28 49.28 37
*seg: 894
R10717 0 8931 0.1 49.28 49.28 37
R10718 8935 8945 6.16 0.8 49.28 37
I8931 0 8931 1.28631e-05
R10719 8931 8932 1.68 0.8 13.44 37
I8932 0 8932 1.26158e-05
R10720 8932 8933 1.68 0.8 13.44 37
I8933 0 8933 1.28631e-05
R10721 8933 8934 1.632 0.8 13.056 37
I8934 0 8934 1.33579e-05
R10722 8934 8935 1.744 0.8 13.952 37
I8935 0 8935 1.29868e-05
R10723 8935 8936 1.664 0.8 13.312 37
I8936 0 8936 1.31105e-05
R10724 8936 8937 1.696 0.8 13.568 37
I8937 0 8937 1.29868e-05
R10725 8937 8938 1.68 0.8 13.44 37
I8938 0 8938 1.32342e-05
R10726 8938 8939 1.728 0.8 13.824 37
I8939 0 8939 1.31105e-05
R10727 8939 8940 1.6 0.8 12.8 37
I8940 0 8940 1.23684e-05
R10728 8940 0 0.1 49.28 49.28 37
*seg: 895
R10729 0 8941 0.1 49.28 49.28 37
R10730 8945 8955 6.16 0.8 49.28 37
I8941 0 8941 1.31105e-05
R10731 8941 8942 1.744 0.8 13.952 37
I8942 0 8942 1.31105e-05
R10732 8942 8943 1.616 0.8 12.928 37
I8943 0 8943 1.32342e-05
R10733 8943 8944 1.664 0.8 13.312 37
I8944 0 8944 1.33579e-05
R10734 8944 8945 1.616 0.8 12.928 37
I8945 0 8945 1.24921e-05
R10735 8945 8946 1.632 0.8 13.056 37
I8946 0 8946 1.32342e-05
R10736 8946 8947 1.696 0.8 13.568 37
I8947 0 8947 1.29868e-05
R10737 8947 8948 1.68 0.8 13.44 37
I8948 0 8948 1.32342e-05
R10738 8948 8949 1.632 0.8 13.056 37
I8949 0 8949 1.26158e-05
R10739 8949 8950 1.712 0.8 13.696 37
I8950 0 8950 1.23684e-05
R10740 8950 0 0.1 49.28 49.28 37
*seg: 896
R10741 0 8951 0.1 49.28 49.28 37
R10742 8955 8965 6.16 0.8 49.28 37
I8951 0 8951 1.32342e-05
R10743 8951 8952 1.648 0.8 13.184 37
I8952 0 8952 1.27395e-05
R10744 8952 8953 1.696 0.8 13.568 37
I8953 0 8953 1.33579e-05
R10745 8953 8954 1.648 0.8 13.184 37
I8954 0 8954 1.26158e-05
R10746 8954 8955 1.664 0.8 13.312 37
I8955 0 8955 1.29868e-05
R10747 8955 8956 1.728 0.8 13.824 37
I8956 0 8956 1.29868e-05
R10748 8956 8957 1.744 0.8 13.952 37
I8957 0 8957 1.29868e-05
R10749 8957 8958 1.616 0.8 12.928 37
I8958 0 8958 1.28631e-05
R10750 8958 8959 1.728 0.8 13.824 37
I8959 0 8959 1.31105e-05
R10751 8959 8960 1.664 0.8 13.312 37
I8960 0 8960 1.23684e-05
R10752 8960 0 0.1 49.28 49.28 37
*seg: 897
R10753 0 8961 0.1 49.28 49.28 37
R10754 8965 8975 6.16 0.8 49.28 37
I8961 0 8961 1.29868e-05
R10755 8961 8962 1.632 0.8 13.056 37
I8962 0 8962 1.23684e-05
R10756 8962 8963 1.664 0.8 13.312 37
I8963 0 8963 1.32342e-05
R10757 8963 8964 1.648 0.8 13.184 37
I8964 0 8964 1.26158e-05
R10758 8964 8965 1.632 0.8 13.056 37
I8965 0 8965 1.27395e-05
R10759 8965 8966 1.744 0.8 13.952 37
I8966 0 8966 1.33579e-05
R10760 8966 8967 1.664 0.8 13.312 37
I8967 0 8967 1.32342e-05
R10761 8967 8968 1.68 0.8 13.44 37
I8968 0 8968 1.32342e-05
R10762 8968 8969 1.616 0.8 12.928 37
I8969 0 8969 1.33579e-05
R10763 8969 8970 1.648 0.8 13.184 37
I8970 0 8970 1.23684e-05
R10764 8970 0 0.1 49.28 49.28 37
*seg: 898
R10765 0 8971 0.1 49.28 49.28 37
R10766 8975 8985 6.16 0.8 49.28 37
I8971 0 8971 1.27395e-05
R10767 8971 8972 1.712 0.8 13.696 37
I8972 0 8972 1.29868e-05
R10768 8972 8973 1.728 0.8 13.824 37
I8973 0 8973 1.28631e-05
R10769 8973 8974 1.6 0.8 12.8 37
I8974 0 8974 1.24921e-05
R10770 8974 8975 1.616 0.8 12.928 37
I8975 0 8975 1.23684e-05
R10771 8975 8976 1.712 0.8 13.696 37
I8976 0 8976 1.28631e-05
R10772 8976 8977 1.648 0.8 13.184 37
I8977 0 8977 1.32342e-05
R10773 8977 8978 1.728 0.8 13.824 37
I8978 0 8978 1.24921e-05
R10774 8978 8979 1.664 0.8 13.312 37
I8979 0 8979 1.26158e-05
R10775 8979 8980 1.632 0.8 13.056 37
I8980 0 8980 1.23684e-05
R10776 8980 0 0.1 49.28 49.28 37
*seg: 899
R10777 0 8981 0.1 49.28 49.28 37
R10778 8985 8995 6.16 0.8 49.28 37
I8981 0 8981 1.33579e-05
R10779 8981 8982 1.744 0.8 13.952 37
I8982 0 8982 1.29868e-05
R10780 8982 8983 1.728 0.8 13.824 37
I8983 0 8983 1.34816e-05
R10781 8983 8984 1.68 0.8 13.44 37
I8984 0 8984 1.32342e-05
R10782 8984 8985 1.696 0.8 13.568 37
I8985 0 8985 1.32342e-05
R10783 8985 8986 1.648 0.8 13.184 37
I8986 0 8986 1.29868e-05
R10784 8986 8987 1.744 0.8 13.952 37
I8987 0 8987 1.29868e-05
R10785 8987 8988 1.744 0.8 13.952 37
I8988 0 8988 1.26158e-05
R10786 8988 8989 1.68 0.8 13.44 37
I8989 0 8989 1.34816e-05
R10787 8989 8990 1.616 0.8 12.928 37
I8990 0 8990 1.23684e-05
R10788 8990 0 0.1 49.28 49.28 37
*seg: 900
R10789 0 8991 0.1 49.28 49.28 37
R10790 8995 9005 6.16 0.8 49.28 37
I8991 0 8991 1.34816e-05
R10791 8991 8992 1.68 0.8 13.44 37
I8992 0 8992 1.34816e-05
R10792 8992 8993 1.728 0.8 13.824 37
I8993 0 8993 1.28631e-05
R10793 8993 8994 1.6 0.8 12.8 37
I8994 0 8994 1.33579e-05
R10794 8994 8995 1.664 0.8 13.312 37
I8995 0 8995 1.32342e-05
R10795 8995 8996 1.648 0.8 13.184 37
I8996 0 8996 1.23684e-05
R10796 8996 8997 1.648 0.8 13.184 37
I8997 0 8997 1.26158e-05
R10797 8997 8998 1.664 0.8 13.312 37
I8998 0 8998 1.27395e-05
R10798 8998 8999 1.744 0.8 13.952 37
I8999 0 8999 1.31105e-05
R10799 8999 9000 1.728 0.8 13.824 37
I9000 0 9000 1.23684e-05
R10800 9000 0 0.1 49.28 49.28 37
*seg: 901
R10801 0 9001 0.1 49.28 49.28 37
R10802 9005 9015 6.16 0.8 49.28 37
I9001 0 9001 1.24921e-05
R10803 9001 9002 1.728 0.8 13.824 37
I9002 0 9002 1.24921e-05
R10804 9002 9003 1.616 0.8 12.928 37
I9003 0 9003 1.23684e-05
R10805 9003 9004 1.616 0.8 12.928 37
I9004 0 9004 1.31105e-05
R10806 9004 9005 1.712 0.8 13.696 37
I9005 0 9005 1.32342e-05
R10807 9005 9006 1.648 0.8 13.184 37
I9006 0 9006 1.26158e-05
R10808 9006 9007 1.664 0.8 13.312 37
I9007 0 9007 1.31105e-05
R10809 9007 9008 1.696 0.8 13.568 37
I9008 0 9008 1.29868e-05
R10810 9008 9009 1.648 0.8 13.184 37
I9009 0 9009 1.34816e-05
R10811 9009 9010 1.744 0.8 13.952 37
I9010 0 9010 1.23684e-05
R10812 9010 0 0.1 49.28 49.28 37
*seg: 902
R10813 0 9011 0.1 49.28 49.28 37
R10814 9015 9025 6.16 0.8 49.28 37
I9011 0 9011 1.31105e-05
R10815 9011 9012 1.728 0.8 13.824 37
I9012 0 9012 1.27395e-05
R10816 9012 9013 1.664 0.8 13.312 37
I9013 0 9013 1.24921e-05
R10817 9013 9014 1.744 0.8 13.952 37
I9014 0 9014 1.32342e-05
R10818 9014 9015 1.744 0.8 13.952 37
I9015 0 9015 1.27395e-05
R10819 9015 9016 1.68 0.8 13.44 37
I9016 0 9016 1.34816e-05
R10820 9016 9017 1.6 0.8 12.8 37
I9017 0 9017 1.32342e-05
R10821 9017 9018 1.696 0.8 13.568 37
I9018 0 9018 1.23684e-05
R10822 9018 9019 1.648 0.8 13.184 37
I9019 0 9019 1.24921e-05
R10823 9019 9020 1.712 0.8 13.696 37
I9020 0 9020 1.23684e-05
R10824 9020 0 0.1 49.28 49.28 37
*seg: 903
R10825 0 9021 0.1 49.28 49.28 37
R10826 9025 9035 6.16 0.8 49.28 37
I9021 0 9021 1.23684e-05
R10827 9021 9022 1.632 0.8 13.056 37
I9022 0 9022 1.23684e-05
R10828 9022 9023 1.744 0.8 13.952 37
I9023 0 9023 1.27395e-05
R10829 9023 9024 1.744 0.8 13.952 37
I9024 0 9024 1.28631e-05
R10830 9024 9025 1.696 0.8 13.568 37
I9025 0 9025 1.32342e-05
R10831 9025 9026 1.632 0.8 13.056 37
I9026 0 9026 1.31105e-05
R10832 9026 9027 1.696 0.8 13.568 37
I9027 0 9027 1.33579e-05
R10833 9027 9028 1.728 0.8 13.824 37
I9028 0 9028 1.23684e-05
R10834 9028 9029 1.616 0.8 12.928 37
I9029 0 9029 1.34816e-05
R10835 9029 9030 1.6 0.8 12.8 37
I9030 0 9030 1.23684e-05
R10836 9030 0 0.1 49.28 49.28 37
*seg: 904
R10837 0 9031 0.1 49.28 49.28 37
R10838 9035 9045 6.16 0.8 49.28 37
I9031 0 9031 1.28631e-05
R10839 9031 9032 1.664 0.8 13.312 37
I9032 0 9032 1.34816e-05
R10840 9032 9033 1.6 0.8 12.8 37
I9033 0 9033 1.28631e-05
R10841 9033 9034 1.68 0.8 13.44 37
I9034 0 9034 1.31105e-05
R10842 9034 9035 1.68 0.8 13.44 37
I9035 0 9035 1.23684e-05
R10843 9035 9036 1.728 0.8 13.824 37
I9036 0 9036 1.34816e-05
R10844 9036 9037 1.616 0.8 12.928 37
I9037 0 9037 1.28631e-05
R10845 9037 9038 1.664 0.8 13.312 37
I9038 0 9038 1.26158e-05
R10846 9038 9039 1.6 0.8 12.8 37
I9039 0 9039 1.34816e-05
R10847 9039 9040 1.728 0.8 13.824 37
I9040 0 9040 1.23684e-05
R10848 9040 0 0.1 49.28 49.28 37
*seg: 905
R10849 0 9041 0.1 49.28 49.28 37
R10850 9045 9055 6.16 0.8 49.28 37
I9041 0 9041 1.28631e-05
R10851 9041 9042 1.728 0.8 13.824 37
I9042 0 9042 1.26158e-05
R10852 9042 9043 1.6 0.8 12.8 37
I9043 0 9043 1.26158e-05
R10853 9043 9044 1.616 0.8 12.928 37
I9044 0 9044 1.34816e-05
R10854 9044 9045 1.728 0.8 13.824 37
I9045 0 9045 1.24921e-05
R10855 9045 9046 1.696 0.8 13.568 37
I9046 0 9046 1.24921e-05
R10856 9046 9047 1.744 0.8 13.952 37
I9047 0 9047 1.31105e-05
R10857 9047 9048 1.728 0.8 13.824 37
I9048 0 9048 1.31105e-05
R10858 9048 9049 1.632 0.8 13.056 37
I9049 0 9049 1.32342e-05
R10859 9049 9050 1.648 0.8 13.184 37
I9050 0 9050 1.23684e-05
R10860 9050 0 0.1 49.28 49.28 37
*seg: 906
R10861 0 9051 0.1 49.28 49.28 37
R10862 9055 9065 6.16 0.8 49.28 37
I9051 0 9051 1.33579e-05
R10863 9051 9052 1.68 0.8 13.44 37
I9052 0 9052 1.33579e-05
R10864 9052 9053 1.712 0.8 13.696 37
I9053 0 9053 1.23684e-05
R10865 9053 9054 1.744 0.8 13.952 37
I9054 0 9054 1.27395e-05
R10866 9054 9055 1.744 0.8 13.952 37
I9055 0 9055 1.23684e-05
R10867 9055 9056 1.712 0.8 13.696 37
I9056 0 9056 1.29868e-05
R10868 9056 9057 1.664 0.8 13.312 37
I9057 0 9057 1.26158e-05
R10869 9057 9058 1.712 0.8 13.696 37
I9058 0 9058 1.32342e-05
R10870 9058 9059 1.728 0.8 13.824 37
I9059 0 9059 1.34816e-05
R10871 9059 9060 1.696 0.8 13.568 37
I9060 0 9060 1.23684e-05
R10872 9060 0 0.1 49.28 49.28 37
*seg: 907
R10873 0 9061 0.1 49.28 49.28 37
R10874 9065 9075 6.16 0.8 49.28 37
I9061 0 9061 1.34816e-05
R10875 9061 9062 1.728 0.8 13.824 37
I9062 0 9062 1.32342e-05
R10876 9062 9063 1.648 0.8 13.184 37
I9063 0 9063 1.33579e-05
R10877 9063 9064 1.744 0.8 13.952 37
I9064 0 9064 1.31105e-05
R10878 9064 9065 1.6 0.8 12.8 37
I9065 0 9065 1.33579e-05
R10879 9065 9066 1.728 0.8 13.824 37
I9066 0 9066 1.27395e-05
R10880 9066 9067 1.648 0.8 13.184 37
I9067 0 9067 1.26158e-05
R10881 9067 9068 1.648 0.8 13.184 37
I9068 0 9068 1.27395e-05
R10882 9068 9069 1.616 0.8 12.928 37
I9069 0 9069 1.26158e-05
R10883 9069 9070 1.744 0.8 13.952 37
I9070 0 9070 1.23684e-05
R10884 9070 0 0.1 49.28 49.28 37
*seg: 908
R10885 0 9071 0.1 49.28 49.28 37
R10886 9075 9085 6.16 0.8 49.28 37
I9071 0 9071 1.23684e-05
R10887 9071 9072 1.632 0.8 13.056 37
I9072 0 9072 1.33579e-05
R10888 9072 9073 1.6 0.8 12.8 37
I9073 0 9073 1.28631e-05
R10889 9073 9074 1.712 0.8 13.696 37
I9074 0 9074 1.27395e-05
R10890 9074 9075 1.744 0.8 13.952 37
I9075 0 9075 1.23684e-05
R10891 9075 9076 1.632 0.8 13.056 37
I9076 0 9076 1.24921e-05
R10892 9076 9077 1.632 0.8 13.056 37
I9077 0 9077 1.34816e-05
R10893 9077 9078 1.632 0.8 13.056 37
I9078 0 9078 1.34816e-05
R10894 9078 9079 1.616 0.8 12.928 37
I9079 0 9079 1.28631e-05
R10895 9079 9080 1.712 0.8 13.696 37
I9080 0 9080 1.23684e-05
R10896 9080 0 0.1 49.28 49.28 37
*seg: 909
R10897 0 9081 0.1 49.28 49.28 37
R10898 9085 9095 6.16 0.8 49.28 37
I9081 0 9081 1.32342e-05
R10899 9081 9082 1.68 0.8 13.44 37
I9082 0 9082 1.24921e-05
R10900 9082 9083 1.6 0.8 12.8 37
I9083 0 9083 1.23684e-05
R10901 9083 9084 1.744 0.8 13.952 37
I9084 0 9084 1.28631e-05
R10902 9084 9085 1.616 0.8 12.928 37
I9085 0 9085 1.32342e-05
R10903 9085 9086 1.664 0.8 13.312 37
I9086 0 9086 1.28631e-05
R10904 9086 9087 1.744 0.8 13.952 37
I9087 0 9087 1.23684e-05
R10905 9087 9088 1.6 0.8 12.8 37
I9088 0 9088 1.32342e-05
R10906 9088 9089 1.744 0.8 13.952 37
I9089 0 9089 1.23684e-05
R10907 9089 9090 1.744 0.8 13.952 37
I9090 0 9090 1.23684e-05
R10908 9090 0 0.1 49.28 49.28 37
*seg: 910
R10909 0 9091 0.1 49.28 49.28 37
R10910 9095 9105 6.16 0.8 49.28 37
I9091 0 9091 1.32342e-05
R10911 9091 9092 1.728 0.8 13.824 37
I9092 0 9092 1.28631e-05
R10912 9092 9093 1.728 0.8 13.824 37
I9093 0 9093 1.28631e-05
R10913 9093 9094 1.728 0.8 13.824 37
I9094 0 9094 1.34816e-05
R10914 9094 9095 1.632 0.8 13.056 37
I9095 0 9095 1.24921e-05
R10915 9095 9096 1.6 0.8 12.8 37
I9096 0 9096 1.28631e-05
R10916 9096 9097 1.648 0.8 13.184 37
I9097 0 9097 1.31105e-05
R10917 9097 9098 1.712 0.8 13.696 37
I9098 0 9098 1.28631e-05
R10918 9098 9099 1.744 0.8 13.952 37
I9099 0 9099 1.23684e-05
R10919 9099 9100 1.6 0.8 12.8 37
I9100 0 9100 1.23684e-05
R10920 9100 0 0.1 49.28 49.28 37
*seg: 911
R10921 0 9101 0.1 49.28 49.28 37
R10922 9105 9115 6.16 0.8 49.28 37
I9101 0 9101 1.24921e-05
R10923 9101 9102 1.744 0.8 13.952 37
I9102 0 9102 1.23684e-05
R10924 9102 9103 1.744 0.8 13.952 37
I9103 0 9103 1.24921e-05
R10925 9103 9104 1.728 0.8 13.824 37
I9104 0 9104 1.26158e-05
R10926 9104 9105 1.648 0.8 13.184 37
I9105 0 9105 1.28631e-05
R10927 9105 9106 1.616 0.8 12.928 37
I9106 0 9106 1.24921e-05
R10928 9106 9107 1.648 0.8 13.184 37
I9107 0 9107 1.24921e-05
R10929 9107 9108 1.696 0.8 13.568 37
I9108 0 9108 1.27395e-05
R10930 9108 9109 1.648 0.8 13.184 37
I9109 0 9109 1.31105e-05
R10931 9109 9110 1.664 0.8 13.312 37
I9110 0 9110 1.23684e-05
R10932 9110 0 0.1 49.28 49.28 37
*seg: 912
R10933 0 9111 0.1 49.28 49.28 37
R10934 9115 9125 6.16 0.8 49.28 37
I9111 0 9111 1.28631e-05
R10935 9111 9112 1.648 0.8 13.184 37
I9112 0 9112 1.33579e-05
R10936 9112 9113 1.712 0.8 13.696 37
I9113 0 9113 1.26158e-05
R10937 9113 9114 1.6 0.8 12.8 37
I9114 0 9114 1.24921e-05
R10938 9114 9115 1.696 0.8 13.568 37
I9115 0 9115 1.28631e-05
R10939 9115 9116 1.616 0.8 12.928 37
I9116 0 9116 1.28631e-05
R10940 9116 9117 1.664 0.8 13.312 37
I9117 0 9117 1.31105e-05
R10941 9117 9118 1.6 0.8 12.8 37
I9118 0 9118 1.32342e-05
R10942 9118 9119 1.712 0.8 13.696 37
I9119 0 9119 1.28631e-05
R10943 9119 9120 1.68 0.8 13.44 37
I9120 0 9120 1.23684e-05
R10944 9120 0 0.1 49.28 49.28 37
*seg: 913
R10945 0 9121 0.1 49.28 49.28 37
R10946 9125 9135 6.16 0.8 49.28 37
I9121 0 9121 1.34816e-05
R10947 9121 9122 1.696 0.8 13.568 37
I9122 0 9122 1.32342e-05
R10948 9122 9123 1.616 0.8 12.928 37
I9123 0 9123 1.32342e-05
R10949 9123 9124 1.712 0.8 13.696 37
I9124 0 9124 1.34816e-05
R10950 9124 9125 1.632 0.8 13.056 37
I9125 0 9125 1.27395e-05
R10951 9125 9126 1.632 0.8 13.056 37
I9126 0 9126 1.34816e-05
R10952 9126 9127 1.632 0.8 13.056 37
I9127 0 9127 1.23684e-05
R10953 9127 9128 1.696 0.8 13.568 37
I9128 0 9128 1.34816e-05
R10954 9128 9129 1.712 0.8 13.696 37
I9129 0 9129 1.24921e-05
R10955 9129 9130 1.664 0.8 13.312 37
I9130 0 9130 1.23684e-05
R10956 9130 0 0.1 49.28 49.28 37
*seg: 914
R10957 0 9131 0.1 49.28 49.28 37
R10958 9135 9145 6.16 0.8 49.28 37
I9131 0 9131 1.23684e-05
R10959 9131 9132 1.696 0.8 13.568 37
I9132 0 9132 1.33579e-05
R10960 9132 9133 1.664 0.8 13.312 37
I9133 0 9133 1.27395e-05
R10961 9133 9134 1.68 0.8 13.44 37
I9134 0 9134 1.29868e-05
R10962 9134 9135 1.632 0.8 13.056 37
I9135 0 9135 1.31105e-05
R10963 9135 9136 1.6 0.8 12.8 37
I9136 0 9136 1.28631e-05
R10964 9136 9137 1.648 0.8 13.184 37
I9137 0 9137 1.26158e-05
R10965 9137 9138 1.616 0.8 12.928 37
I9138 0 9138 1.29868e-05
R10966 9138 9139 1.728 0.8 13.824 37
I9139 0 9139 1.34816e-05
R10967 9139 9140 1.744 0.8 13.952 37
I9140 0 9140 1.23684e-05
R10968 9140 0 0.1 49.28 49.28 37
*seg: 915
R10969 0 9141 0.1 49.28 49.28 37
R10970 9145 9155 6.16 0.8 49.28 37
I9141 0 9141 1.34816e-05
R10971 9141 9142 1.664 0.8 13.312 37
I9142 0 9142 1.27395e-05
R10972 9142 9143 1.728 0.8 13.824 37
I9143 0 9143 1.33579e-05
R10973 9143 9144 1.728 0.8 13.824 37
I9144 0 9144 1.27395e-05
R10974 9144 9145 1.744 0.8 13.952 37
I9145 0 9145 1.32342e-05
R10975 9145 9146 1.648 0.8 13.184 37
I9146 0 9146 1.23684e-05
R10976 9146 9147 1.696 0.8 13.568 37
I9147 0 9147 1.26158e-05
R10977 9147 9148 1.6 0.8 12.8 37
I9148 0 9148 1.33579e-05
R10978 9148 9149 1.728 0.8 13.824 37
I9149 0 9149 1.27395e-05
R10979 9149 9150 1.68 0.8 13.44 37
I9150 0 9150 1.23684e-05
R10980 9150 0 0.1 49.28 49.28 37
*seg: 916
R10981 0 9151 0.1 49.28 49.28 37
R10982 9155 9165 6.16 0.8 49.28 37
I9151 0 9151 1.31105e-05
R10983 9151 9152 1.744 0.8 13.952 37
I9152 0 9152 1.27395e-05
R10984 9152 9153 1.68 0.8 13.44 37
I9153 0 9153 1.24921e-05
R10985 9153 9154 1.696 0.8 13.568 37
I9154 0 9154 1.26158e-05
R10986 9154 9155 1.616 0.8 12.928 37
I9155 0 9155 1.31105e-05
R10987 9155 9156 1.744 0.8 13.952 37
I9156 0 9156 1.34816e-05
R10988 9156 9157 1.744 0.8 13.952 37
I9157 0 9157 1.27395e-05
R10989 9157 9158 1.696 0.8 13.568 37
I9158 0 9158 1.24921e-05
R10990 9158 9159 1.68 0.8 13.44 37
I9159 0 9159 1.32342e-05
R10991 9159 9160 1.68 0.8 13.44 37
I9160 0 9160 1.23684e-05
R10992 9160 0 0.1 49.28 49.28 37
*seg: 917
R10993 0 9161 0.1 49.28 49.28 37
R10994 9165 9175 6.16 0.8 49.28 37
I9161 0 9161 1.31105e-05
R10995 9161 9162 1.712 0.8 13.696 37
I9162 0 9162 1.24921e-05
R10996 9162 9163 1.6 0.8 12.8 37
I9163 0 9163 1.29868e-05
R10997 9163 9164 1.648 0.8 13.184 37
I9164 0 9164 1.27395e-05
R10998 9164 9165 1.632 0.8 13.056 37
I9165 0 9165 1.34816e-05
R10999 9165 9166 1.664 0.8 13.312 37
I9166 0 9166 1.29868e-05
R11000 9166 9167 1.616 0.8 12.928 37
I9167 0 9167 1.34816e-05
R11001 9167 9168 1.696 0.8 13.568 37
I9168 0 9168 1.28631e-05
R11002 9168 9169 1.648 0.8 13.184 37
I9169 0 9169 1.32342e-05
R11003 9169 9170 1.6 0.8 12.8 37
I9170 0 9170 1.23684e-05
R11004 9170 0 0.1 49.28 49.28 37
*seg: 918
R11005 0 9171 0.1 49.28 49.28 37
R11006 9175 9185 6.16 0.8 49.28 37
I9171 0 9171 1.28631e-05
R11007 9171 9172 1.696 0.8 13.568 37
I9172 0 9172 1.24921e-05
R11008 9172 9173 1.696 0.8 13.568 37
I9173 0 9173 1.33579e-05
R11009 9173 9174 1.648 0.8 13.184 37
I9174 0 9174 1.32342e-05
R11010 9174 9175 1.744 0.8 13.952 37
I9175 0 9175 1.28631e-05
R11011 9175 9176 1.632 0.8 13.056 37
I9176 0 9176 1.29868e-05
R11012 9176 9177 1.68 0.8 13.44 37
I9177 0 9177 1.34816e-05
R11013 9177 9178 1.68 0.8 13.44 37
I9178 0 9178 1.31105e-05
R11014 9178 9179 1.6 0.8 12.8 37
I9179 0 9179 1.23684e-05
R11015 9179 9180 1.712 0.8 13.696 37
I9180 0 9180 1.23684e-05
R11016 9180 0 0.1 49.28 49.28 37
*seg: 919
R11017 0 9181 0.1 49.28 49.28 37
R11018 9185 9195 6.16 0.8 49.28 37
I9181 0 9181 1.23684e-05
R11019 9181 9182 1.648 0.8 13.184 37
I9182 0 9182 1.34816e-05
R11020 9182 9183 1.68 0.8 13.44 37
I9183 0 9183 1.34816e-05
R11021 9183 9184 1.696 0.8 13.568 37
I9184 0 9184 1.29868e-05
R11022 9184 9185 1.616 0.8 12.928 37
I9185 0 9185 1.23684e-05
R11023 9185 9186 1.68 0.8 13.44 37
I9186 0 9186 1.24921e-05
R11024 9186 9187 1.616 0.8 12.928 37
I9187 0 9187 1.27395e-05
R11025 9187 9188 1.68 0.8 13.44 37
I9188 0 9188 1.27395e-05
R11026 9188 9189 1.728 0.8 13.824 37
I9189 0 9189 1.33579e-05
R11027 9189 9190 1.648 0.8 13.184 37
I9190 0 9190 1.23684e-05
R11028 9190 0 0.1 49.28 49.28 37
*seg: 920
R11029 0 9191 0.1 49.28 49.28 37
R11030 9195 9205 6.16 0.8 49.28 37
I9191 0 9191 1.33579e-05
R11031 9191 9192 1.6 0.8 12.8 37
I9192 0 9192 1.31105e-05
R11032 9192 9193 1.728 0.8 13.824 37
I9193 0 9193 1.26158e-05
R11033 9193 9194 1.6 0.8 12.8 37
I9194 0 9194 1.32342e-05
R11034 9194 9195 1.616 0.8 12.928 37
I9195 0 9195 1.31105e-05
R11035 9195 9196 1.6 0.8 12.8 37
I9196 0 9196 1.29868e-05
R11036 9196 9197 1.664 0.8 13.312 37
I9197 0 9197 1.26158e-05
R11037 9197 9198 1.728 0.8 13.824 37
I9198 0 9198 1.26158e-05
R11038 9198 9199 1.68 0.8 13.44 37
I9199 0 9199 1.31105e-05
R11039 9199 9200 1.712 0.8 13.696 37
I9200 0 9200 1.23684e-05
R11040 9200 0 0.1 49.28 49.28 37
*seg: 921
R11041 0 9201 0.1 49.28 49.28 37
R11042 9205 9215 6.16 0.8 49.28 37
I9201 0 9201 1.26158e-05
R11043 9201 9202 1.648 0.8 13.184 37
I9202 0 9202 1.31105e-05
R11044 9202 9203 1.68 0.8 13.44 37
I9203 0 9203 1.27395e-05
R11045 9203 9204 1.728 0.8 13.824 37
I9204 0 9204 1.34816e-05
R11046 9204 9205 1.616 0.8 12.928 37
I9205 0 9205 1.31105e-05
R11047 9205 9206 1.68 0.8 13.44 37
I9206 0 9206 1.33579e-05
R11048 9206 9207 1.664 0.8 13.312 37
I9207 0 9207 1.28631e-05
R11049 9207 9208 1.664 0.8 13.312 37
I9208 0 9208 1.26158e-05
R11050 9208 9209 1.712 0.8 13.696 37
I9209 0 9209 1.33579e-05
R11051 9209 9210 1.632 0.8 13.056 37
I9210 0 9210 1.23684e-05
R11052 9210 0 0.1 49.28 49.28 37
*seg: 922
R11053 0 9211 0.1 49.28 49.28 37
R11054 9215 9225 6.16 0.8 49.28 37
I9211 0 9211 1.26158e-05
R11055 9211 9212 1.68 0.8 13.44 37
I9212 0 9212 1.31105e-05
R11056 9212 9213 1.664 0.8 13.312 37
I9213 0 9213 1.33579e-05
R11057 9213 9214 1.744 0.8 13.952 37
I9214 0 9214 1.24921e-05
R11058 9214 9215 1.728 0.8 13.824 37
I9215 0 9215 1.32342e-05
R11059 9215 9216 1.648 0.8 13.184 37
I9216 0 9216 1.27395e-05
R11060 9216 9217 1.616 0.8 12.928 37
I9217 0 9217 1.24921e-05
R11061 9217 9218 1.744 0.8 13.952 37
I9218 0 9218 1.23684e-05
R11062 9218 9219 1.68 0.8 13.44 37
I9219 0 9219 1.23684e-05
R11063 9219 9220 1.696 0.8 13.568 37
I9220 0 9220 1.23684e-05
R11064 9220 0 0.1 49.28 49.28 37
*seg: 923
R11065 0 9221 0.1 49.28 49.28 37
R11066 9225 9235 6.16 0.8 49.28 37
I9221 0 9221 1.28631e-05
R11067 9221 9222 1.696 0.8 13.568 37
I9222 0 9222 1.34816e-05
R11068 9222 9223 1.696 0.8 13.568 37
I9223 0 9223 1.31105e-05
R11069 9223 9224 1.68 0.8 13.44 37
I9224 0 9224 1.23684e-05
R11070 9224 9225 1.632 0.8 13.056 37
I9225 0 9225 1.24921e-05
R11071 9225 9226 1.712 0.8 13.696 37
I9226 0 9226 1.33579e-05
R11072 9226 9227 1.728 0.8 13.824 37
I9227 0 9227 1.34816e-05
R11073 9227 9228 1.616 0.8 12.928 37
I9228 0 9228 1.32342e-05
R11074 9228 9229 1.712 0.8 13.696 37
I9229 0 9229 1.33579e-05
R11075 9229 9230 1.68 0.8 13.44 37
I9230 0 9230 1.23684e-05
R11076 9230 0 0.1 49.28 49.28 37
*seg: 924
R11077 0 9231 0.1 49.28 49.28 37
R11078 9235 9245 6.16 0.8 49.28 37
I9231 0 9231 1.32342e-05
R11079 9231 9232 1.664 0.8 13.312 37
I9232 0 9232 1.33579e-05
R11080 9232 9233 1.6 0.8 12.8 37
I9233 0 9233 1.29868e-05
R11081 9233 9234 1.664 0.8 13.312 37
I9234 0 9234 1.31105e-05
R11082 9234 9235 1.664 0.8 13.312 37
I9235 0 9235 1.27395e-05
R11083 9235 9236 1.712 0.8 13.696 37
I9236 0 9236 1.28631e-05
R11084 9236 9237 1.616 0.8 12.928 37
I9237 0 9237 1.32342e-05
R11085 9237 9238 1.728 0.8 13.824 37
I9238 0 9238 1.32342e-05
R11086 9238 9239 1.648 0.8 13.184 37
I9239 0 9239 1.28631e-05
R11087 9239 9240 1.632 0.8 13.056 37
I9240 0 9240 1.23684e-05
R11088 9240 0 0.1 49.28 49.28 37
*seg: 925
R11089 0 9241 0.1 49.28 49.28 37
R11090 9245 9255 6.16 0.8 49.28 37
I9241 0 9241 1.24921e-05
R11091 9241 9242 1.728 0.8 13.824 37
I9242 0 9242 1.28631e-05
R11092 9242 9243 1.696 0.8 13.568 37
I9243 0 9243 1.29868e-05
R11093 9243 9244 1.616 0.8 12.928 37
I9244 0 9244 1.31105e-05
R11094 9244 9245 1.696 0.8 13.568 37
I9245 0 9245 1.23684e-05
R11095 9245 9246 1.696 0.8 13.568 37
I9246 0 9246 1.31105e-05
R11096 9246 9247 1.664 0.8 13.312 37
I9247 0 9247 1.34816e-05
R11097 9247 9248 1.648 0.8 13.184 37
I9248 0 9248 1.28631e-05
R11098 9248 9249 1.664 0.8 13.312 37
I9249 0 9249 1.34816e-05
R11099 9249 9250 1.744 0.8 13.952 37
I9250 0 9250 1.23684e-05
R11100 9250 0 0.1 49.28 49.28 37
*seg: 926
R11101 0 9251 0.1 49.28 49.28 37
R11102 9255 9265 6.16 0.8 49.28 37
I9251 0 9251 1.29868e-05
R11103 9251 9252 1.632 0.8 13.056 37
I9252 0 9252 1.33579e-05
R11104 9252 9253 1.648 0.8 13.184 37
I9253 0 9253 1.33579e-05
R11105 9253 9254 1.664 0.8 13.312 37
I9254 0 9254 1.28631e-05
R11106 9254 9255 1.712 0.8 13.696 37
I9255 0 9255 1.29868e-05
R11107 9255 9256 1.648 0.8 13.184 37
I9256 0 9256 1.29868e-05
R11108 9256 9257 1.728 0.8 13.824 37
I9257 0 9257 1.26158e-05
R11109 9257 9258 1.648 0.8 13.184 37
I9258 0 9258 1.33579e-05
R11110 9258 9259 1.68 0.8 13.44 37
I9259 0 9259 1.26158e-05
R11111 9259 9260 1.712 0.8 13.696 37
I9260 0 9260 1.23684e-05
R11112 9260 0 0.1 49.28 49.28 37
*seg: 927
R11113 0 9261 0.1 49.28 49.28 37
R11114 9265 9275 6.16 0.8 49.28 37
I9261 0 9261 1.27395e-05
R11115 9261 9262 1.696 0.8 13.568 37
I9262 0 9262 1.23684e-05
R11116 9262 9263 1.68 0.8 13.44 37
I9263 0 9263 1.23684e-05
R11117 9263 9264 1.632 0.8 13.056 37
I9264 0 9264 1.29868e-05
R11118 9264 9265 1.632 0.8 13.056 37
I9265 0 9265 1.33579e-05
R11119 9265 9266 1.728 0.8 13.824 37
I9266 0 9266 1.23684e-05
R11120 9266 9267 1.696 0.8 13.568 37
I9267 0 9267 1.26158e-05
R11121 9267 9268 1.632 0.8 13.056 37
I9268 0 9268 1.33579e-05
R11122 9268 9269 1.648 0.8 13.184 37
I9269 0 9269 1.32342e-05
R11123 9269 9270 1.664 0.8 13.312 37
I9270 0 9270 1.23684e-05
R11124 9270 0 0.1 49.28 49.28 37
*seg: 928
R11125 0 9271 0.1 49.28 49.28 37
R11126 9275 9285 6.16 0.8 49.28 37
I9271 0 9271 1.31105e-05
R11127 9271 9272 1.712 0.8 13.696 37
I9272 0 9272 1.29868e-05
R11128 9272 9273 1.696 0.8 13.568 37
I9273 0 9273 1.28631e-05
R11129 9273 9274 1.664 0.8 13.312 37
I9274 0 9274 1.23684e-05
R11130 9274 9275 1.6 0.8 12.8 37
I9275 0 9275 1.31105e-05
R11131 9275 9276 1.712 0.8 13.696 37
I9276 0 9276 1.29868e-05
R11132 9276 9277 1.648 0.8 13.184 37
I9277 0 9277 1.27395e-05
R11133 9277 9278 1.648 0.8 13.184 37
I9278 0 9278 1.28631e-05
R11134 9278 9279 1.744 0.8 13.952 37
I9279 0 9279 1.33579e-05
R11135 9279 9280 1.744 0.8 13.952 37
I9280 0 9280 1.23684e-05
R11136 9280 0 0.1 49.28 49.28 37
*seg: 929
R11137 0 9281 0.1 49.28 49.28 37
R11138 9285 9295 6.16 0.8 49.28 37
I9281 0 9281 1.24921e-05
R11139 9281 9282 1.6 0.8 12.8 37
I9282 0 9282 1.28631e-05
R11140 9282 9283 1.712 0.8 13.696 37
I9283 0 9283 1.33579e-05
R11141 9283 9284 1.648 0.8 13.184 37
I9284 0 9284 1.32342e-05
R11142 9284 9285 1.6 0.8 12.8 37
I9285 0 9285 1.29868e-05
R11143 9285 9286 1.6 0.8 12.8 37
I9286 0 9286 1.26158e-05
R11144 9286 9287 1.728 0.8 13.824 37
I9287 0 9287 1.27395e-05
R11145 9287 9288 1.712 0.8 13.696 37
I9288 0 9288 1.23684e-05
R11146 9288 9289 1.6 0.8 12.8 37
I9289 0 9289 1.29868e-05
R11147 9289 9290 1.68 0.8 13.44 37
I9290 0 9290 1.23684e-05
R11148 9290 0 0.1 49.28 49.28 37
*seg: 930
R11149 0 9291 0.1 49.28 49.28 37
R11150 9295 9305 6.16 0.8 49.28 37
I9291 0 9291 1.28631e-05
R11151 9291 9292 1.664 0.8 13.312 37
I9292 0 9292 1.26158e-05
R11152 9292 9293 1.68 0.8 13.44 37
I9293 0 9293 1.32342e-05
R11153 9293 9294 1.696 0.8 13.568 37
I9294 0 9294 1.34816e-05
R11154 9294 9295 1.68 0.8 13.44 37
I9295 0 9295 1.26158e-05
R11155 9295 9296 1.632 0.8 13.056 37
I9296 0 9296 1.34816e-05
R11156 9296 9297 1.712 0.8 13.696 37
I9297 0 9297 1.33579e-05
R11157 9297 9298 1.632 0.8 13.056 37
I9298 0 9298 1.27395e-05
R11158 9298 9299 1.6 0.8 12.8 37
I9299 0 9299 1.31105e-05
R11159 9299 9300 1.664 0.8 13.312 37
I9300 0 9300 1.23684e-05
R11160 9300 0 0.1 49.28 49.28 37
*seg: 931
R11161 0 9301 0.1 49.28 49.28 37
R11162 9305 9315 6.16 0.8 49.28 37
I9301 0 9301 1.23684e-05
R11163 9301 9302 1.696 0.8 13.568 37
I9302 0 9302 1.26158e-05
R11164 9302 9303 1.664 0.8 13.312 37
I9303 0 9303 1.32342e-05
R11165 9303 9304 1.616 0.8 12.928 37
I9304 0 9304 1.31105e-05
R11166 9304 9305 1.664 0.8 13.312 37
I9305 0 9305 1.34816e-05
R11167 9305 9306 1.648 0.8 13.184 37
I9306 0 9306 1.33579e-05
R11168 9306 9307 1.68 0.8 13.44 37
I9307 0 9307 1.26158e-05
R11169 9307 9308 1.632 0.8 13.056 37
I9308 0 9308 1.24921e-05
R11170 9308 9309 1.616 0.8 12.928 37
I9309 0 9309 1.23684e-05
R11171 9309 9310 1.648 0.8 13.184 37
I9310 0 9310 1.23684e-05
R11172 9310 0 0.1 49.28 49.28 37
*seg: 932
R11173 0 9311 0.1 49.28 49.28 37
R11174 9315 9325 6.16 0.8 49.28 37
I9311 0 9311 1.27395e-05
R11175 9311 9312 1.664 0.8 13.312 37
I9312 0 9312 1.23684e-05
R11176 9312 9313 1.616 0.8 12.928 37
I9313 0 9313 1.32342e-05
R11177 9313 9314 1.696 0.8 13.568 37
I9314 0 9314 1.26158e-05
R11178 9314 9315 1.648 0.8 13.184 37
I9315 0 9315 1.33579e-05
R11179 9315 9316 1.728 0.8 13.824 37
I9316 0 9316 1.34816e-05
R11180 9316 9317 1.616 0.8 12.928 37
I9317 0 9317 1.33579e-05
R11181 9317 9318 1.744 0.8 13.952 37
I9318 0 9318 1.23684e-05
R11182 9318 9319 1.744 0.8 13.952 37
I9319 0 9319 1.33579e-05
R11183 9319 9320 1.6 0.8 12.8 37
I9320 0 9320 1.23684e-05
R11184 9320 0 0.1 49.28 49.28 37
*seg: 933
R11185 0 9321 0.1 49.28 49.28 37
R11186 9325 9335 6.16 0.8 49.28 37
I9321 0 9321 1.28631e-05
R11187 9321 9322 1.648 0.8 13.184 37
I9322 0 9322 1.32342e-05
R11188 9322 9323 1.696 0.8 13.568 37
I9323 0 9323 1.24921e-05
R11189 9323 9324 1.728 0.8 13.824 37
I9324 0 9324 1.23684e-05
R11190 9324 9325 1.696 0.8 13.568 37
I9325 0 9325 1.32342e-05
R11191 9325 9326 1.6 0.8 12.8 37
I9326 0 9326 1.29868e-05
R11192 9326 9327 1.728 0.8 13.824 37
I9327 0 9327 1.28631e-05
R11193 9327 9328 1.648 0.8 13.184 37
I9328 0 9328 1.32342e-05
R11194 9328 9329 1.648 0.8 13.184 37
I9329 0 9329 1.33579e-05
R11195 9329 9330 1.632 0.8 13.056 37
I9330 0 9330 1.23684e-05
R11196 9330 0 0.1 49.28 49.28 37
*seg: 934
R11197 0 9331 0.1 49.28 49.28 37
R11198 9335 9345 6.16 0.8 49.28 37
I9331 0 9331 1.34816e-05
R11199 9331 9332 1.712 0.8 13.696 37
I9332 0 9332 1.24921e-05
R11200 9332 9333 1.728 0.8 13.824 37
I9333 0 9333 1.32342e-05
R11201 9333 9334 1.648 0.8 13.184 37
I9334 0 9334 1.34816e-05
R11202 9334 9335 1.6 0.8 12.8 37
I9335 0 9335 1.27395e-05
R11203 9335 9336 1.632 0.8 13.056 37
I9336 0 9336 1.33579e-05
R11204 9336 9337 1.616 0.8 12.928 37
I9337 0 9337 1.27395e-05
R11205 9337 9338 1.728 0.8 13.824 37
I9338 0 9338 1.23684e-05
R11206 9338 9339 1.696 0.8 13.568 37
I9339 0 9339 1.29868e-05
R11207 9339 9340 1.648 0.8 13.184 37
I9340 0 9340 1.23684e-05
R11208 9340 0 0.1 49.28 49.28 37
*seg: 935
R11209 0 9341 0.1 49.28 49.28 37
R11210 9345 9355 6.16 0.8 49.28 37
I9341 0 9341 1.27395e-05
R11211 9341 9342 1.648 0.8 13.184 37
I9342 0 9342 1.31105e-05
R11212 9342 9343 1.648 0.8 13.184 37
I9343 0 9343 1.26158e-05
R11213 9343 9344 1.712 0.8 13.696 37
I9344 0 9344 1.31105e-05
R11214 9344 9345 1.616 0.8 12.928 37
I9345 0 9345 1.23684e-05
R11215 9345 9346 1.744 0.8 13.952 37
I9346 0 9346 1.28631e-05
R11216 9346 9347 1.712 0.8 13.696 37
I9347 0 9347 1.33579e-05
R11217 9347 9348 1.68 0.8 13.44 37
I9348 0 9348 1.26158e-05
R11218 9348 9349 1.664 0.8 13.312 37
I9349 0 9349 1.26158e-05
R11219 9349 9350 1.664 0.8 13.312 37
I9350 0 9350 1.23684e-05
R11220 9350 0 0.1 49.28 49.28 37
*seg: 936
R11221 0 9351 0.1 49.28 49.28 37
R11222 9355 9365 6.16 0.8 49.28 37
I9351 0 9351 1.23684e-05
R11223 9351 9352 1.712 0.8 13.696 37
I9352 0 9352 1.32342e-05
R11224 9352 9353 1.6 0.8 12.8 37
I9353 0 9353 1.24921e-05
R11225 9353 9354 1.616 0.8 12.928 37
I9354 0 9354 1.26158e-05
R11226 9354 9355 1.712 0.8 13.696 37
I9355 0 9355 1.33579e-05
R11227 9355 9356 1.648 0.8 13.184 37
I9356 0 9356 1.28631e-05
R11228 9356 9357 1.6 0.8 12.8 37
I9357 0 9357 1.32342e-05
R11229 9357 9358 1.744 0.8 13.952 37
I9358 0 9358 1.33579e-05
R11230 9358 9359 1.712 0.8 13.696 37
I9359 0 9359 1.27395e-05
R11231 9359 9360 1.712 0.8 13.696 37
I9360 0 9360 1.23684e-05
R11232 9360 0 0.1 49.28 49.28 37
*seg: 937
R11233 0 9361 0.1 49.28 49.28 37
R11234 9365 9375 6.16 0.8 49.28 37
I9361 0 9361 1.31105e-05
R11235 9361 9362 1.6 0.8 12.8 37
I9362 0 9362 1.33579e-05
R11236 9362 9363 1.6 0.8 12.8 37
I9363 0 9363 1.27395e-05
R11237 9363 9364 1.664 0.8 13.312 37
I9364 0 9364 1.33579e-05
R11238 9364 9365 1.664 0.8 13.312 37
I9365 0 9365 1.31105e-05
R11239 9365 9366 1.744 0.8 13.952 37
I9366 0 9366 1.24921e-05
R11240 9366 9367 1.728 0.8 13.824 37
I9367 0 9367 1.32342e-05
R11241 9367 9368 1.6 0.8 12.8 37
I9368 0 9368 1.29868e-05
R11242 9368 9369 1.68 0.8 13.44 37
I9369 0 9369 1.29868e-05
R11243 9369 9370 1.6 0.8 12.8 37
I9370 0 9370 1.23684e-05
R11244 9370 0 0.1 49.28 49.28 37
*seg: 938
R11245 0 9371 0.1 49.28 49.28 37
R11246 9375 9385 6.16 0.8 49.28 37
I9371 0 9371 1.28631e-05
R11247 9371 9372 1.696 0.8 13.568 37
I9372 0 9372 1.28631e-05
R11248 9372 9373 1.648 0.8 13.184 37
I9373 0 9373 1.24921e-05
R11249 9373 9374 1.68 0.8 13.44 37
I9374 0 9374 1.23684e-05
R11250 9374 9375 1.632 0.8 13.056 37
I9375 0 9375 1.27395e-05
R11251 9375 9376 1.712 0.8 13.696 37
I9376 0 9376 1.31105e-05
R11252 9376 9377 1.744 0.8 13.952 37
I9377 0 9377 1.33579e-05
R11253 9377 9378 1.6 0.8 12.8 37
I9378 0 9378 1.27395e-05
R11254 9378 9379 1.648 0.8 13.184 37
I9379 0 9379 1.26158e-05
R11255 9379 9380 1.68 0.8 13.44 37
I9380 0 9380 1.23684e-05
R11256 9380 0 0.1 49.28 49.28 37
*seg: 939
R11257 0 9381 0.1 49.28 49.28 37
R11258 9385 9395 6.16 0.8 49.28 37
I9381 0 9381 1.34816e-05
R11259 9381 9382 1.68 0.8 13.44 37
I9382 0 9382 1.32342e-05
R11260 9382 9383 1.68 0.8 13.44 37
I9383 0 9383 1.23684e-05
R11261 9383 9384 1.712 0.8 13.696 37
I9384 0 9384 1.34816e-05
R11262 9384 9385 1.648 0.8 13.184 37
I9385 0 9385 1.33579e-05
R11263 9385 9386 1.696 0.8 13.568 37
I9386 0 9386 1.34816e-05
R11264 9386 9387 1.744 0.8 13.952 37
I9387 0 9387 1.26158e-05
R11265 9387 9388 1.696 0.8 13.568 37
I9388 0 9388 1.33579e-05
R11266 9388 9389 1.744 0.8 13.952 37
I9389 0 9389 1.34816e-05
R11267 9389 9390 1.648 0.8 13.184 37
I9390 0 9390 1.23684e-05
R11268 9390 0 0.1 49.28 49.28 37
*seg: 940
R11269 0 9391 0.1 49.28 49.28 37
R11270 9395 9405 6.16 0.8 49.28 37
I9391 0 9391 1.24921e-05
R11271 9391 9392 1.632 0.8 13.056 37
I9392 0 9392 1.32342e-05
R11272 9392 9393 1.6 0.8 12.8 37
I9393 0 9393 1.28631e-05
R11273 9393 9394 1.664 0.8 13.312 37
I9394 0 9394 1.26158e-05
R11274 9394 9395 1.696 0.8 13.568 37
I9395 0 9395 1.32342e-05
R11275 9395 9396 1.632 0.8 13.056 37
I9396 0 9396 1.29868e-05
R11276 9396 9397 1.648 0.8 13.184 37
I9397 0 9397 1.24921e-05
R11277 9397 9398 1.728 0.8 13.824 37
I9398 0 9398 1.29868e-05
R11278 9398 9399 1.632 0.8 13.056 37
I9399 0 9399 1.31105e-05
R11279 9399 9400 1.696 0.8 13.568 37
I9400 0 9400 1.23684e-05
R11280 9400 0 0.1 49.28 49.28 37
*seg: 941
R11281 0 9401 0.1 49.28 49.28 37
R11282 9405 9415 6.16 0.8 49.28 37
I9401 0 9401 1.24921e-05
R11283 9401 9402 1.664 0.8 13.312 37
I9402 0 9402 1.31105e-05
R11284 9402 9403 1.664 0.8 13.312 37
I9403 0 9403 1.32342e-05
R11285 9403 9404 1.68 0.8 13.44 37
I9404 0 9404 1.34816e-05
R11286 9404 9405 1.696 0.8 13.568 37
I9405 0 9405 1.29868e-05
R11287 9405 9406 1.648 0.8 13.184 37
I9406 0 9406 1.32342e-05
R11288 9406 9407 1.6 0.8 12.8 37
I9407 0 9407 1.27395e-05
R11289 9407 9408 1.728 0.8 13.824 37
I9408 0 9408 1.32342e-05
R11290 9408 9409 1.696 0.8 13.568 37
I9409 0 9409 1.29868e-05
R11291 9409 9410 1.616 0.8 12.928 37
I9410 0 9410 1.23684e-05
R11292 9410 0 0.1 49.28 49.28 37
*seg: 942
R11293 0 9411 0.1 49.28 49.28 37
R11294 9415 9425 6.16 0.8 49.28 37
I9411 0 9411 1.27395e-05
R11295 9411 9412 1.632 0.8 13.056 37
I9412 0 9412 1.33579e-05
R11296 9412 9413 1.648 0.8 13.184 37
I9413 0 9413 1.26158e-05
R11297 9413 9414 1.744 0.8 13.952 37
I9414 0 9414 1.27395e-05
R11298 9414 9415 1.744 0.8 13.952 37
I9415 0 9415 1.29868e-05
R11299 9415 9416 1.616 0.8 12.928 37
I9416 0 9416 1.32342e-05
R11300 9416 9417 1.744 0.8 13.952 37
I9417 0 9417 1.33579e-05
R11301 9417 9418 1.712 0.8 13.696 37
I9418 0 9418 1.26158e-05
R11302 9418 9419 1.616 0.8 12.928 37
I9419 0 9419 1.34816e-05
R11303 9419 9420 1.744 0.8 13.952 37
I9420 0 9420 1.23684e-05
R11304 9420 0 0.1 49.28 49.28 37
*seg: 943
R11305 0 9421 0.1 49.28 49.28 37
R11306 9425 9435 6.16 0.8 49.28 37
I9421 0 9421 1.29868e-05
R11307 9421 9422 1.616 0.8 12.928 37
I9422 0 9422 1.34816e-05
R11308 9422 9423 1.616 0.8 12.928 37
I9423 0 9423 1.26158e-05
R11309 9423 9424 1.744 0.8 13.952 37
I9424 0 9424 1.32342e-05
R11310 9424 9425 1.648 0.8 13.184 37
I9425 0 9425 1.31105e-05
R11311 9425 9426 1.6 0.8 12.8 37
I9426 0 9426 1.29868e-05
R11312 9426 9427 1.68 0.8 13.44 37
I9427 0 9427 1.26158e-05
R11313 9427 9428 1.696 0.8 13.568 37
I9428 0 9428 1.28631e-05
R11314 9428 9429 1.664 0.8 13.312 37
I9429 0 9429 1.28631e-05
R11315 9429 9430 1.68 0.8 13.44 37
I9430 0 9430 1.23684e-05
R11316 9430 0 0.1 49.28 49.28 37
*seg: 944
R11317 0 9431 0.1 49.28 49.28 37
R11318 9435 9445 6.16 0.8 49.28 37
I9431 0 9431 1.32342e-05
R11319 9431 9432 1.648 0.8 13.184 37
I9432 0 9432 1.27395e-05
R11320 9432 9433 1.664 0.8 13.312 37
I9433 0 9433 1.34816e-05
R11321 9433 9434 1.728 0.8 13.824 37
I9434 0 9434 1.27395e-05
R11322 9434 9435 1.632 0.8 13.056 37
I9435 0 9435 1.31105e-05
R11323 9435 9436 1.632 0.8 13.056 37
I9436 0 9436 1.26158e-05
R11324 9436 9437 1.728 0.8 13.824 37
I9437 0 9437 1.34816e-05
R11325 9437 9438 1.6 0.8 12.8 37
I9438 0 9438 1.34816e-05
R11326 9438 9439 1.616 0.8 12.928 37
I9439 0 9439 1.23684e-05
R11327 9439 9440 1.616 0.8 12.928 37
I9440 0 9440 1.23684e-05
R11328 9440 0 0.1 49.28 49.28 37
*seg: 945
R11329 0 9441 0.1 49.28 49.28 37
R11330 9445 9455 6.16 0.8 49.28 37
I9441 0 9441 1.24921e-05
R11331 9441 9442 1.648 0.8 13.184 37
I9442 0 9442 1.31105e-05
R11332 9442 9443 1.6 0.8 12.8 37
I9443 0 9443 1.31105e-05
R11333 9443 9444 1.696 0.8 13.568 37
I9444 0 9444 1.31105e-05
R11334 9444 9445 1.68 0.8 13.44 37
I9445 0 9445 1.27395e-05
R11335 9445 9446 1.728 0.8 13.824 37
I9446 0 9446 1.26158e-05
R11336 9446 9447 1.6 0.8 12.8 37
I9447 0 9447 1.24921e-05
R11337 9447 9448 1.664 0.8 13.312 37
I9448 0 9448 1.34816e-05
R11338 9448 9449 1.728 0.8 13.824 37
I9449 0 9449 1.34816e-05
R11339 9449 9450 1.712 0.8 13.696 37
I9450 0 9450 1.23684e-05
R11340 9450 0 0.1 49.28 49.28 37
*seg: 946
R11341 0 9451 0.1 49.28 49.28 37
R11342 9455 9465 6.16 0.8 49.28 37
I9451 0 9451 1.23684e-05
R11343 9451 9452 1.6 0.8 12.8 37
I9452 0 9452 1.33579e-05
R11344 9452 9453 1.68 0.8 13.44 37
I9453 0 9453 1.24921e-05
R11345 9453 9454 1.744 0.8 13.952 37
I9454 0 9454 1.32342e-05
R11346 9454 9455 1.696 0.8 13.568 37
I9455 0 9455 1.26158e-05
R11347 9455 9456 1.648 0.8 13.184 37
I9456 0 9456 1.24921e-05
R11348 9456 9457 1.664 0.8 13.312 37
I9457 0 9457 1.23684e-05
R11349 9457 9458 1.68 0.8 13.44 37
I9458 0 9458 1.23684e-05
R11350 9458 9459 1.712 0.8 13.696 37
I9459 0 9459 1.31105e-05
R11351 9459 9460 1.712 0.8 13.696 37
I9460 0 9460 1.23684e-05
R11352 9460 0 0.1 49.28 49.28 37
*seg: 947
R11353 0 9461 0.1 49.28 49.28 37
R11354 9465 9475 6.16 0.8 49.28 37
I9461 0 9461 1.23684e-05
R11355 9461 9462 1.664 0.8 13.312 37
I9462 0 9462 1.27395e-05
R11356 9462 9463 1.728 0.8 13.824 37
I9463 0 9463 1.26158e-05
R11357 9463 9464 1.728 0.8 13.824 37
I9464 0 9464 1.31105e-05
R11358 9464 9465 1.664 0.8 13.312 37
I9465 0 9465 1.24921e-05
R11359 9465 9466 1.744 0.8 13.952 37
I9466 0 9466 1.33579e-05
R11360 9466 9467 1.632 0.8 13.056 37
I9467 0 9467 1.34816e-05
R11361 9467 9468 1.664 0.8 13.312 37
I9468 0 9468 1.28631e-05
R11362 9468 9469 1.68 0.8 13.44 37
I9469 0 9469 1.28631e-05
R11363 9469 9470 1.712 0.8 13.696 37
I9470 0 9470 1.23684e-05
R11364 9470 0 0.1 49.28 49.28 37
*seg: 948
R11365 0 9471 0.1 49.28 49.28 37
R11366 9475 9485 6.16 0.8 49.28 37
I9471 0 9471 1.24921e-05
R11367 9471 9472 1.6 0.8 12.8 37
I9472 0 9472 1.24921e-05
R11368 9472 9473 1.616 0.8 12.928 37
I9473 0 9473 1.23684e-05
R11369 9473 9474 1.632 0.8 13.056 37
I9474 0 9474 1.27395e-05
R11370 9474 9475 1.616 0.8 12.928 37
I9475 0 9475 1.33579e-05
R11371 9475 9476 1.616 0.8 12.928 37
I9476 0 9476 1.28631e-05
R11372 9476 9477 1.6 0.8 12.8 37
I9477 0 9477 1.24921e-05
R11373 9477 9478 1.744 0.8 13.952 37
I9478 0 9478 1.23684e-05
R11374 9478 9479 1.6 0.8 12.8 37
I9479 0 9479 1.23684e-05
R11375 9479 9480 1.728 0.8 13.824 37
I9480 0 9480 1.23684e-05
R11376 9480 0 0.1 49.28 49.28 37
*seg: 949
R11377 0 9481 0.1 49.28 49.28 37
R11378 9485 9495 6.16 0.8 49.28 37
I9481 0 9481 1.23684e-05
R11379 9481 9482 1.68 0.8 13.44 37
I9482 0 9482 1.23684e-05
R11380 9482 9483 1.616 0.8 12.928 37
I9483 0 9483 1.33579e-05
R11381 9483 9484 1.664 0.8 13.312 37
I9484 0 9484 1.26158e-05
R11382 9484 9485 1.616 0.8 12.928 37
I9485 0 9485 1.33579e-05
R11383 9485 9486 1.664 0.8 13.312 37
I9486 0 9486 1.31105e-05
R11384 9486 9487 1.728 0.8 13.824 37
I9487 0 9487 1.23684e-05
R11385 9487 9488 1.728 0.8 13.824 37
I9488 0 9488 1.26158e-05
R11386 9488 9489 1.712 0.8 13.696 37
I9489 0 9489 1.31105e-05
R11387 9489 9490 1.728 0.8 13.824 37
I9490 0 9490 1.23684e-05
R11388 9490 0 0.1 49.28 49.28 37
*seg: 950
R11389 0 9491 0.1 49.28 49.28 37
R11390 9495 9505 6.16 0.8 49.28 37
I9491 0 9491 1.32342e-05
R11391 9491 9492 1.744 0.8 13.952 37
I9492 0 9492 1.28631e-05
R11392 9492 9493 1.616 0.8 12.928 37
I9493 0 9493 1.27395e-05
R11393 9493 9494 1.696 0.8 13.568 37
I9494 0 9494 1.32342e-05
R11394 9494 9495 1.744 0.8 13.952 37
I9495 0 9495 1.26158e-05
R11395 9495 9496 1.632 0.8 13.056 37
I9496 0 9496 1.31105e-05
R11396 9496 9497 1.6 0.8 12.8 37
I9497 0 9497 1.34816e-05
R11397 9497 9498 1.712 0.8 13.696 37
I9498 0 9498 1.27395e-05
R11398 9498 9499 1.728 0.8 13.824 37
I9499 0 9499 1.33579e-05
R11399 9499 9500 1.712 0.8 13.696 37
I9500 0 9500 1.23684e-05
R11400 9500 0 0.1 49.28 49.28 37
*seg: 951
R11401 0 9501 0.1 49.28 49.28 37
R11402 9505 9515 6.16 0.8 49.28 37
I9501 0 9501 1.24921e-05
R11403 9501 9502 1.744 0.8 13.952 37
I9502 0 9502 1.33579e-05
R11404 9502 9503 1.616 0.8 12.928 37
I9503 0 9503 1.29868e-05
R11405 9503 9504 1.616 0.8 12.928 37
I9504 0 9504 1.26158e-05
R11406 9504 9505 1.728 0.8 13.824 37
I9505 0 9505 1.23684e-05
R11407 9505 9506 1.616 0.8 12.928 37
I9506 0 9506 1.24921e-05
R11408 9506 9507 1.648 0.8 13.184 37
I9507 0 9507 1.28631e-05
R11409 9507 9508 1.616 0.8 12.928 37
I9508 0 9508 1.26158e-05
R11410 9508 9509 1.632 0.8 13.056 37
I9509 0 9509 1.33579e-05
R11411 9509 9510 1.696 0.8 13.568 37
I9510 0 9510 1.23684e-05
R11412 9510 0 0.1 49.28 49.28 37
*seg: 952
R11413 0 9511 0.1 49.28 49.28 37
R11414 9515 9525 6.16 0.8 49.28 37
I9511 0 9511 1.27395e-05
R11415 9511 9512 1.712 0.8 13.696 37
I9512 0 9512 1.27395e-05
R11416 9512 9513 1.632 0.8 13.056 37
I9513 0 9513 1.31105e-05
R11417 9513 9514 1.664 0.8 13.312 37
I9514 0 9514 1.31105e-05
R11418 9514 9515 1.664 0.8 13.312 37
I9515 0 9515 1.31105e-05
R11419 9515 9516 1.696 0.8 13.568 37
I9516 0 9516 1.34816e-05
R11420 9516 9517 1.744 0.8 13.952 37
I9517 0 9517 1.32342e-05
R11421 9517 9518 1.744 0.8 13.952 37
I9518 0 9518 1.28631e-05
R11422 9518 9519 1.712 0.8 13.696 37
I9519 0 9519 1.28631e-05
R11423 9519 9520 1.648 0.8 13.184 37
I9520 0 9520 1.23684e-05
R11424 9520 0 0.1 49.28 49.28 37
*seg: 953
R11425 0 9521 0.1 49.28 49.28 37
R11426 9525 9535 6.16 0.8 49.28 37
I9521 0 9521 1.31105e-05
R11427 9521 9522 1.648 0.8 13.184 37
I9522 0 9522 1.27395e-05
R11428 9522 9523 1.712 0.8 13.696 37
I9523 0 9523 1.23684e-05
R11429 9523 9524 1.728 0.8 13.824 37
I9524 0 9524 1.27395e-05
R11430 9524 9525 1.6 0.8 12.8 37
I9525 0 9525 1.31105e-05
R11431 9525 9526 1.664 0.8 13.312 37
I9526 0 9526 1.27395e-05
R11432 9526 9527 1.696 0.8 13.568 37
I9527 0 9527 1.29868e-05
R11433 9527 9528 1.712 0.8 13.696 37
I9528 0 9528 1.27395e-05
R11434 9528 9529 1.6 0.8 12.8 37
I9529 0 9529 1.29868e-05
R11435 9529 9530 1.664 0.8 13.312 37
I9530 0 9530 1.23684e-05
R11436 9530 0 0.1 49.28 49.28 37
*seg: 954
R11437 0 9531 0.1 49.28 49.28 37
R11438 9535 9545 6.16 0.8 49.28 37
I9531 0 9531 1.33579e-05
R11439 9531 9532 1.68 0.8 13.44 37
I9532 0 9532 1.26158e-05
R11440 9532 9533 1.648 0.8 13.184 37
I9533 0 9533 1.34816e-05
R11441 9533 9534 1.744 0.8 13.952 37
I9534 0 9534 1.29868e-05
R11442 9534 9535 1.68 0.8 13.44 37
I9535 0 9535 1.23684e-05
R11443 9535 9536 1.616 0.8 12.928 37
I9536 0 9536 1.27395e-05
R11444 9536 9537 1.712 0.8 13.696 37
I9537 0 9537 1.24921e-05
R11445 9537 9538 1.68 0.8 13.44 37
I9538 0 9538 1.24921e-05
R11446 9538 9539 1.616 0.8 12.928 37
I9539 0 9539 1.23684e-05
R11447 9539 9540 1.616 0.8 12.928 37
I9540 0 9540 1.23684e-05
R11448 9540 0 0.1 49.28 49.28 37
*seg: 955
R11449 0 9541 0.1 49.28 49.28 37
R11450 9545 9555 6.16 0.8 49.28 37
I9541 0 9541 1.34816e-05
R11451 9541 9542 1.68 0.8 13.44 37
I9542 0 9542 1.31105e-05
R11452 9542 9543 1.728 0.8 13.824 37
I9543 0 9543 1.26158e-05
R11453 9543 9544 1.744 0.8 13.952 37
I9544 0 9544 1.33579e-05
R11454 9544 9545 1.744 0.8 13.952 37
I9545 0 9545 1.26158e-05
R11455 9545 9546 1.696 0.8 13.568 37
I9546 0 9546 1.28631e-05
R11456 9546 9547 1.6 0.8 12.8 37
I9547 0 9547 1.23684e-05
R11457 9547 9548 1.712 0.8 13.696 37
I9548 0 9548 1.23684e-05
R11458 9548 9549 1.744 0.8 13.952 37
I9549 0 9549 1.34816e-05
R11459 9549 9550 1.6 0.8 12.8 37
I9550 0 9550 1.23684e-05
R11460 9550 0 0.1 49.28 49.28 37
*seg: 956
R11461 0 9551 0.1 49.28 49.28 37
R11462 9555 9565 6.16 0.8 49.28 37
I9551 0 9551 1.28631e-05
R11463 9551 9552 1.68 0.8 13.44 37
I9552 0 9552 1.24921e-05
R11464 9552 9553 1.6 0.8 12.8 37
I9553 0 9553 1.26158e-05
R11465 9553 9554 1.664 0.8 13.312 37
I9554 0 9554 1.24921e-05
R11466 9554 9555 1.68 0.8 13.44 37
I9555 0 9555 1.23684e-05
R11467 9555 9556 1.744 0.8 13.952 37
I9556 0 9556 1.28631e-05
R11468 9556 9557 1.664 0.8 13.312 37
I9557 0 9557 1.27395e-05
R11469 9557 9558 1.648 0.8 13.184 37
I9558 0 9558 1.29868e-05
R11470 9558 9559 1.744 0.8 13.952 37
I9559 0 9559 1.27395e-05
R11471 9559 9560 1.68 0.8 13.44 37
I9560 0 9560 1.23684e-05
R11472 9560 0 0.1 49.28 49.28 37
*seg: 957
R11473 0 9561 0.1 49.28 49.28 37
R11474 9565 9575 6.16 0.8 49.28 37
I9561 0 9561 1.23684e-05
R11475 9561 9562 1.616 0.8 12.928 37
I9562 0 9562 1.24921e-05
R11476 9562 9563 1.664 0.8 13.312 37
I9563 0 9563 1.34816e-05
R11477 9563 9564 1.648 0.8 13.184 37
I9564 0 9564 1.23684e-05
R11478 9564 9565 1.744 0.8 13.952 37
I9565 0 9565 1.28631e-05
R11479 9565 9566 1.664 0.8 13.312 37
I9566 0 9566 1.28631e-05
R11480 9566 9567 1.616 0.8 12.928 37
I9567 0 9567 1.26158e-05
R11481 9567 9568 1.712 0.8 13.696 37
I9568 0 9568 1.32342e-05
R11482 9568 9569 1.744 0.8 13.952 37
I9569 0 9569 1.29868e-05
R11483 9569 9570 1.632 0.8 13.056 37
I9570 0 9570 1.23684e-05
R11484 9570 0 0.1 49.28 49.28 37
*seg: 958
R11485 0 9571 0.1 49.28 49.28 37
R11486 9575 9585 6.16 0.8 49.28 37
I9571 0 9571 1.33579e-05
R11487 9571 9572 1.728 0.8 13.824 37
I9572 0 9572 1.23684e-05
R11488 9572 9573 1.648 0.8 13.184 37
I9573 0 9573 1.27395e-05
R11489 9573 9574 1.712 0.8 13.696 37
I9574 0 9574 1.28631e-05
R11490 9574 9575 1.616 0.8 12.928 37
I9575 0 9575 1.32342e-05
R11491 9575 9576 1.632 0.8 13.056 37
I9576 0 9576 1.26158e-05
R11492 9576 9577 1.744 0.8 13.952 37
I9577 0 9577 1.27395e-05
R11493 9577 9578 1.68 0.8 13.44 37
I9578 0 9578 1.31105e-05
R11494 9578 9579 1.664 0.8 13.312 37
I9579 0 9579 1.24921e-05
R11495 9579 9580 1.664 0.8 13.312 37
I9580 0 9580 1.23684e-05
R11496 9580 0 0.1 49.28 49.28 37
*seg: 959
R11497 0 9581 0.1 49.28 49.28 37
R11498 9585 9595 6.16 0.8 49.28 37
I9581 0 9581 1.28631e-05
R11499 9581 9582 1.616 0.8 12.928 37
I9582 0 9582 1.34816e-05
R11500 9582 9583 1.68 0.8 13.44 37
I9583 0 9583 1.34816e-05
R11501 9583 9584 1.616 0.8 12.928 37
I9584 0 9584 1.32342e-05
R11502 9584 9585 1.632 0.8 13.056 37
I9585 0 9585 1.23684e-05
R11503 9585 9586 1.712 0.8 13.696 37
I9586 0 9586 1.28631e-05
R11504 9586 9587 1.68 0.8 13.44 37
I9587 0 9587 1.26158e-05
R11505 9587 9588 1.632 0.8 13.056 37
I9588 0 9588 1.23684e-05
R11506 9588 9589 1.616 0.8 12.928 37
I9589 0 9589 1.24921e-05
R11507 9589 9590 1.6 0.8 12.8 37
I9590 0 9590 1.23684e-05
R11508 9590 0 0.1 49.28 49.28 37
*seg: 960
R11509 0 9591 0.1 49.28 49.28 37
R11510 9595 9605 6.16 0.8 49.28 37
I9591 0 9591 1.24921e-05
R11511 9591 9592 1.744 0.8 13.952 37
I9592 0 9592 1.33579e-05
R11512 9592 9593 1.616 0.8 12.928 37
I9593 0 9593 1.27395e-05
R11513 9593 9594 1.6 0.8 12.8 37
I9594 0 9594 1.29868e-05
R11514 9594 9595 1.712 0.8 13.696 37
I9595 0 9595 1.23684e-05
R11515 9595 9596 1.632 0.8 13.056 37
I9596 0 9596 1.34816e-05
R11516 9596 9597 1.6 0.8 12.8 37
I9597 0 9597 1.23684e-05
R11517 9597 9598 1.68 0.8 13.44 37
I9598 0 9598 1.28631e-05
R11518 9598 9599 1.712 0.8 13.696 37
I9599 0 9599 1.31105e-05
R11519 9599 9600 1.728 0.8 13.824 37
I9600 0 9600 1.23684e-05
R11520 9600 0 0.1 49.28 49.28 37
*seg: 961
R11521 0 9601 0.1 49.28 49.28 37
R11522 9605 9615 6.16 0.8 49.28 37
I9601 0 9601 1.31105e-05
R11523 9601 9602 1.648 0.8 13.184 37
I9602 0 9602 1.31105e-05
R11524 9602 9603 1.632 0.8 13.056 37
I9603 0 9603 1.27395e-05
R11525 9603 9604 1.632 0.8 13.056 37
I9604 0 9604 1.32342e-05
R11526 9604 9605 1.648 0.8 13.184 37
I9605 0 9605 1.33579e-05
R11527 9605 9606 1.744 0.8 13.952 37
I9606 0 9606 1.28631e-05
R11528 9606 9607 1.648 0.8 13.184 37
I9607 0 9607 1.24921e-05
R11529 9607 9608 1.632 0.8 13.056 37
I9608 0 9608 1.32342e-05
R11530 9608 9609 1.744 0.8 13.952 37
I9609 0 9609 1.33579e-05
R11531 9609 9610 1.632 0.8 13.056 37
I9610 0 9610 1.23684e-05
R11532 9610 0 0.1 49.28 49.28 37
*seg: 962
R11533 0 9611 0.1 49.28 49.28 37
R11534 9615 9625 6.16 0.8 49.28 37
I9611 0 9611 1.24921e-05
R11535 9611 9612 1.728 0.8 13.824 37
I9612 0 9612 1.33579e-05
R11536 9612 9613 1.616 0.8 12.928 37
I9613 0 9613 1.32342e-05
R11537 9613 9614 1.696 0.8 13.568 37
I9614 0 9614 1.24921e-05
R11538 9614 9615 1.696 0.8 13.568 37
I9615 0 9615 1.23684e-05
R11539 9615 9616 1.68 0.8 13.44 37
I9616 0 9616 1.27395e-05
R11540 9616 9617 1.616 0.8 12.928 37
I9617 0 9617 1.23684e-05
R11541 9617 9618 1.6 0.8 12.8 37
I9618 0 9618 1.24921e-05
R11542 9618 9619 1.616 0.8 12.928 37
I9619 0 9619 1.31105e-05
R11543 9619 9620 1.664 0.8 13.312 37
I9620 0 9620 1.23684e-05
R11544 9620 0 0.1 49.28 49.28 37
*seg: 963
R11545 0 9621 0.1 49.28 49.28 37
R11546 9625 9635 6.16 0.8 49.28 37
I9621 0 9621 1.27395e-05
R11547 9621 9622 1.664 0.8 13.312 37
I9622 0 9622 1.26158e-05
R11548 9622 9623 1.632 0.8 13.056 37
I9623 0 9623 1.27395e-05
R11549 9623 9624 1.712 0.8 13.696 37
I9624 0 9624 1.24921e-05
R11550 9624 9625 1.6 0.8 12.8 37
I9625 0 9625 1.29868e-05
R11551 9625 9626 1.728 0.8 13.824 37
I9626 0 9626 1.26158e-05
R11552 9626 9627 1.648 0.8 13.184 37
I9627 0 9627 1.31105e-05
R11553 9627 9628 1.728 0.8 13.824 37
I9628 0 9628 1.31105e-05
R11554 9628 9629 1.632 0.8 13.056 37
I9629 0 9629 1.24921e-05
R11555 9629 9630 1.6 0.8 12.8 37
I9630 0 9630 1.23684e-05
R11556 9630 0 0.1 49.28 49.28 37
*seg: 964
R11557 0 9631 0.1 49.28 49.28 37
R11558 9635 9645 6.16 0.8 49.28 37
I9631 0 9631 1.34816e-05
R11559 9631 9632 1.68 0.8 13.44 37
I9632 0 9632 1.31105e-05
R11560 9632 9633 1.664 0.8 13.312 37
I9633 0 9633 1.24921e-05
R11561 9633 9634 1.712 0.8 13.696 37
I9634 0 9634 1.28631e-05
R11562 9634 9635 1.712 0.8 13.696 37
I9635 0 9635 1.26158e-05
R11563 9635 9636 1.632 0.8 13.056 37
I9636 0 9636 1.23684e-05
R11564 9636 9637 1.664 0.8 13.312 37
I9637 0 9637 1.27395e-05
R11565 9637 9638 1.632 0.8 13.056 37
I9638 0 9638 1.34816e-05
R11566 9638 9639 1.696 0.8 13.568 37
I9639 0 9639 1.29868e-05
R11567 9639 9640 1.696 0.8 13.568 37
I9640 0 9640 1.23684e-05
R11568 9640 0 0.1 49.28 49.28 37
*seg: 965
R11569 0 9641 0.1 49.28 49.28 37
R11570 9645 9655 6.16 0.8 49.28 37
I9641 0 9641 1.26158e-05
R11571 9641 9642 1.696 0.8 13.568 37
I9642 0 9642 1.28631e-05
R11572 9642 9643 1.616 0.8 12.928 37
I9643 0 9643 1.29868e-05
R11573 9643 9644 1.648 0.8 13.184 37
I9644 0 9644 1.28631e-05
R11574 9644 9645 1.632 0.8 13.056 37
I9645 0 9645 1.33579e-05
R11575 9645 9646 1.6 0.8 12.8 37
I9646 0 9646 1.33579e-05
R11576 9646 9647 1.632 0.8 13.056 37
I9647 0 9647 1.32342e-05
R11577 9647 9648 1.728 0.8 13.824 37
I9648 0 9648 1.28631e-05
R11578 9648 9649 1.6 0.8 12.8 37
I9649 0 9649 1.34816e-05
R11579 9649 9650 1.68 0.8 13.44 37
I9650 0 9650 1.23684e-05
R11580 9650 0 0.1 49.28 49.28 37
*seg: 966
R11581 0 9651 0.1 49.28 49.28 37
R11582 9655 9665 6.16 0.8 49.28 37
I9651 0 9651 1.26158e-05
R11583 9651 9652 1.728 0.8 13.824 37
I9652 0 9652 1.34816e-05
R11584 9652 9653 1.6 0.8 12.8 37
I9653 0 9653 1.27395e-05
R11585 9653 9654 1.728 0.8 13.824 37
I9654 0 9654 1.27395e-05
R11586 9654 9655 1.648 0.8 13.184 37
I9655 0 9655 1.24921e-05
R11587 9655 9656 1.632 0.8 13.056 37
I9656 0 9656 1.27395e-05
R11588 9656 9657 1.744 0.8 13.952 37
I9657 0 9657 1.23684e-05
R11589 9657 9658 1.632 0.8 13.056 37
I9658 0 9658 1.32342e-05
R11590 9658 9659 1.68 0.8 13.44 37
I9659 0 9659 1.32342e-05
R11591 9659 9660 1.648 0.8 13.184 37
I9660 0 9660 1.23684e-05
R11592 9660 0 0.1 49.28 49.28 37
*seg: 967
R11593 0 9661 0.1 49.28 49.28 37
R11594 9665 9675 6.16 0.8 49.28 37
I9661 0 9661 1.23684e-05
R11595 9661 9662 1.6 0.8 12.8 37
I9662 0 9662 1.32342e-05
R11596 9662 9663 1.728 0.8 13.824 37
I9663 0 9663 1.27395e-05
R11597 9663 9664 1.728 0.8 13.824 37
I9664 0 9664 1.28631e-05
R11598 9664 9665 1.728 0.8 13.824 37
I9665 0 9665 1.31105e-05
R11599 9665 9666 1.632 0.8 13.056 37
I9666 0 9666 1.26158e-05
R11600 9666 9667 1.616 0.8 12.928 37
I9667 0 9667 1.24921e-05
R11601 9667 9668 1.632 0.8 13.056 37
I9668 0 9668 1.28631e-05
R11602 9668 9669 1.696 0.8 13.568 37
I9669 0 9669 1.23684e-05
R11603 9669 9670 1.6 0.8 12.8 37
I9670 0 9670 1.23684e-05
R11604 9670 0 0.1 49.28 49.28 37
*seg: 968
R11605 0 9671 0.1 49.28 49.28 37
R11606 9675 9685 6.16 0.8 49.28 37
I9671 0 9671 1.27395e-05
R11607 9671 9672 1.648 0.8 13.184 37
I9672 0 9672 1.34816e-05
R11608 9672 9673 1.68 0.8 13.44 37
I9673 0 9673 1.31105e-05
R11609 9673 9674 1.6 0.8 12.8 37
I9674 0 9674 1.34816e-05
R11610 9674 9675 1.744 0.8 13.952 37
I9675 0 9675 1.33579e-05
R11611 9675 9676 1.728 0.8 13.824 37
I9676 0 9676 1.34816e-05
R11612 9676 9677 1.696 0.8 13.568 37
I9677 0 9677 1.34816e-05
R11613 9677 9678 1.728 0.8 13.824 37
I9678 0 9678 1.32342e-05
R11614 9678 9679 1.6 0.8 12.8 37
I9679 0 9679 1.31105e-05
R11615 9679 9680 1.696 0.8 13.568 37
I9680 0 9680 1.23684e-05
R11616 9680 0 0.1 49.28 49.28 37
*seg: 969
R11617 0 9681 0.1 49.28 49.28 37
R11618 9685 9695 6.16 0.8 49.28 37
I9681 0 9681 1.34816e-05
R11619 9681 9682 1.648 0.8 13.184 37
I9682 0 9682 1.34816e-05
R11620 9682 9683 1.664 0.8 13.312 37
I9683 0 9683 1.32342e-05
R11621 9683 9684 1.648 0.8 13.184 37
I9684 0 9684 1.33579e-05
R11622 9684 9685 1.68 0.8 13.44 37
I9685 0 9685 1.23684e-05
R11623 9685 9686 1.744 0.8 13.952 37
I9686 0 9686 1.31105e-05
R11624 9686 9687 1.632 0.8 13.056 37
I9687 0 9687 1.28631e-05
R11625 9687 9688 1.664 0.8 13.312 37
I9688 0 9688 1.26158e-05
R11626 9688 9689 1.6 0.8 12.8 37
I9689 0 9689 1.29868e-05
R11627 9689 9690 1.68 0.8 13.44 37
I9690 0 9690 1.23684e-05
R11628 9690 0 0.1 49.28 49.28 37
*seg: 970
R11629 0 9691 0.1 49.28 49.28 37
R11630 9695 9705 6.16 0.8 49.28 37
I9691 0 9691 1.26158e-05
R11631 9691 9692 1.632 0.8 13.056 37
I9692 0 9692 1.28631e-05
R11632 9692 9693 1.68 0.8 13.44 37
I9693 0 9693 1.28631e-05
R11633 9693 9694 1.648 0.8 13.184 37
I9694 0 9694 1.23684e-05
R11634 9694 9695 1.632 0.8 13.056 37
I9695 0 9695 1.29868e-05
R11635 9695 9696 1.648 0.8 13.184 37
I9696 0 9696 1.28631e-05
R11636 9696 9697 1.664 0.8 13.312 37
I9697 0 9697 1.31105e-05
R11637 9697 9698 1.632 0.8 13.056 37
I9698 0 9698 1.23684e-05
R11638 9698 9699 1.6 0.8 12.8 37
I9699 0 9699 1.27395e-05
R11639 9699 9700 1.6 0.8 12.8 37
I9700 0 9700 1.23684e-05
R11640 9700 0 0.1 49.28 49.28 37
*seg: 971
R11641 0 9701 0.1 49.28 49.28 37
R11642 9705 9715 6.16 0.8 49.28 37
I9701 0 9701 1.31105e-05
R11643 9701 9702 1.632 0.8 13.056 37
I9702 0 9702 1.29868e-05
R11644 9702 9703 1.744 0.8 13.952 37
I9703 0 9703 1.23684e-05
R11645 9703 9704 1.6 0.8 12.8 37
I9704 0 9704 1.33579e-05
R11646 9704 9705 1.6 0.8 12.8 37
I9705 0 9705 1.24921e-05
R11647 9705 9706 1.728 0.8 13.824 37
I9706 0 9706 1.34816e-05
R11648 9706 9707 1.744 0.8 13.952 37
I9707 0 9707 1.29868e-05
R11649 9707 9708 1.68 0.8 13.44 37
I9708 0 9708 1.27395e-05
R11650 9708 9709 1.696 0.8 13.568 37
I9709 0 9709 1.28631e-05
R11651 9709 9710 1.648 0.8 13.184 37
I9710 0 9710 1.23684e-05
R11652 9710 0 0.1 49.28 49.28 37
*seg: 972
R11653 0 9711 0.1 49.28 49.28 37
R11654 9715 9725 6.16 0.8 49.28 37
I9711 0 9711 1.24921e-05
R11655 9711 9712 1.648 0.8 13.184 37
I9712 0 9712 1.33579e-05
R11656 9712 9713 1.728 0.8 13.824 37
I9713 0 9713 1.27395e-05
R11657 9713 9714 1.696 0.8 13.568 37
I9714 0 9714 1.34816e-05
R11658 9714 9715 1.648 0.8 13.184 37
I9715 0 9715 1.23684e-05
R11659 9715 9716 1.68 0.8 13.44 37
I9716 0 9716 1.32342e-05
R11660 9716 9717 1.744 0.8 13.952 37
I9717 0 9717 1.24921e-05
R11661 9717 9718 1.6 0.8 12.8 37
I9718 0 9718 1.24921e-05
R11662 9718 9719 1.728 0.8 13.824 37
I9719 0 9719 1.28631e-05
R11663 9719 9720 1.648 0.8 13.184 37
I9720 0 9720 1.23684e-05
R11664 9720 0 0.1 49.28 49.28 37
*seg: 973
R11665 0 9721 0.1 49.28 49.28 37
R11666 9725 9735 6.16 0.8 49.28 37
I9721 0 9721 1.28631e-05
R11667 9721 9722 1.632 0.8 13.056 37
I9722 0 9722 1.31105e-05
R11668 9722 9723 1.696 0.8 13.568 37
I9723 0 9723 1.34816e-05
R11669 9723 9724 1.728 0.8 13.824 37
I9724 0 9724 1.24921e-05
R11670 9724 9725 1.632 0.8 13.056 37
I9725 0 9725 1.32342e-05
R11671 9725 9726 1.632 0.8 13.056 37
I9726 0 9726 1.27395e-05
R11672 9726 9727 1.744 0.8 13.952 37
I9727 0 9727 1.31105e-05
R11673 9727 9728 1.68 0.8 13.44 37
I9728 0 9728 1.29868e-05
R11674 9728 9729 1.696 0.8 13.568 37
I9729 0 9729 1.26158e-05
R11675 9729 9730 1.68 0.8 13.44 37
I9730 0 9730 1.23684e-05
R11676 9730 0 0.1 49.28 49.28 37
*seg: 974
R11677 0 9731 0.1 49.28 49.28 37
R11678 9735 9745 6.16 0.8 49.28 37
I9731 0 9731 1.23684e-05
R11679 9731 9732 1.616 0.8 12.928 37
I9732 0 9732 1.29868e-05
R11680 9732 9733 1.616 0.8 12.928 37
I9733 0 9733 1.28631e-05
R11681 9733 9734 1.728 0.8 13.824 37
I9734 0 9734 1.23684e-05
R11682 9734 9735 1.6 0.8 12.8 37
I9735 0 9735 1.34816e-05
R11683 9735 9736 1.728 0.8 13.824 37
I9736 0 9736 1.32342e-05
R11684 9736 9737 1.664 0.8 13.312 37
I9737 0 9737 1.26158e-05
R11685 9737 9738 1.744 0.8 13.952 37
I9738 0 9738 1.23684e-05
R11686 9738 9739 1.68 0.8 13.44 37
I9739 0 9739 1.27395e-05
R11687 9739 9740 1.6 0.8 12.8 37
I9740 0 9740 1.23684e-05
R11688 9740 0 0.1 49.28 49.28 37
*seg: 975
R11689 0 9741 0.1 49.28 49.28 37
R11690 9745 9755 6.16 0.8 49.28 37
I9741 0 9741 1.27395e-05
R11691 9741 9742 1.68 0.8 13.44 37
I9742 0 9742 1.28631e-05
R11692 9742 9743 1.616 0.8 12.928 37
I9743 0 9743 1.34816e-05
R11693 9743 9744 1.616 0.8 12.928 37
I9744 0 9744 1.31105e-05
R11694 9744 9745 1.648 0.8 13.184 37
I9745 0 9745 1.31105e-05
R11695 9745 9746 1.696 0.8 13.568 37
I9746 0 9746 1.28631e-05
R11696 9746 9747 1.696 0.8 13.568 37
I9747 0 9747 1.23684e-05
R11697 9747 9748 1.696 0.8 13.568 37
I9748 0 9748 1.24921e-05
R11698 9748 9749 1.6 0.8 12.8 37
I9749 0 9749 1.23684e-05
R11699 9749 9750 1.712 0.8 13.696 37
I9750 0 9750 1.23684e-05
R11700 9750 0 0.1 49.28 49.28 37
*seg: 976
R11701 0 9751 0.1 49.28 49.28 37
R11702 9755 9765 6.16 0.8 49.28 37
I9751 0 9751 1.28631e-05
R11703 9751 9752 1.744 0.8 13.952 37
I9752 0 9752 1.31105e-05
R11704 9752 9753 1.696 0.8 13.568 37
I9753 0 9753 1.26158e-05
R11705 9753 9754 1.68 0.8 13.44 37
I9754 0 9754 1.28631e-05
R11706 9754 9755 1.616 0.8 12.928 37
I9755 0 9755 1.34816e-05
R11707 9755 9756 1.632 0.8 13.056 37
I9756 0 9756 1.33579e-05
R11708 9756 9757 1.6 0.8 12.8 37
I9757 0 9757 1.26158e-05
R11709 9757 9758 1.6 0.8 12.8 37
I9758 0 9758 1.26158e-05
R11710 9758 9759 1.6 0.8 12.8 37
I9759 0 9759 1.32342e-05
R11711 9759 9760 1.6 0.8 12.8 37
I9760 0 9760 1.23684e-05
R11712 9760 0 0.1 49.28 49.28 37
*seg: 977
R11713 0 9761 0.1 49.28 49.28 37
R11714 9765 9775 6.16 0.8 49.28 37
I9761 0 9761 1.31105e-05
R11715 9761 9762 1.744 0.8 13.952 37
I9762 0 9762 1.28631e-05
R11716 9762 9763 1.744 0.8 13.952 37
I9763 0 9763 1.31105e-05
R11717 9763 9764 1.648 0.8 13.184 37
I9764 0 9764 1.24921e-05
R11718 9764 9765 1.696 0.8 13.568 37
I9765 0 9765 1.31105e-05
R11719 9765 9766 1.696 0.8 13.568 37
I9766 0 9766 1.23684e-05
R11720 9766 9767 1.616 0.8 12.928 37
I9767 0 9767 1.26158e-05
R11721 9767 9768 1.648 0.8 13.184 37
I9768 0 9768 1.28631e-05
R11722 9768 9769 1.648 0.8 13.184 37
I9769 0 9769 1.31105e-05
R11723 9769 9770 1.616 0.8 12.928 37
I9770 0 9770 1.23684e-05
R11724 9770 0 0.1 49.28 49.28 37
*seg: 978
R11725 0 9771 0.1 49.28 49.28 37
R11726 9775 9785 6.16 0.8 49.28 37
I9771 0 9771 1.32342e-05
R11727 9771 9772 1.648 0.8 13.184 37
I9772 0 9772 1.28631e-05
R11728 9772 9773 1.68 0.8 13.44 37
I9773 0 9773 1.32342e-05
R11729 9773 9774 1.648 0.8 13.184 37
I9774 0 9774 1.31105e-05
R11730 9774 9775 1.696 0.8 13.568 37
I9775 0 9775 1.31105e-05
R11731 9775 9776 1.696 0.8 13.568 37
I9776 0 9776 1.27395e-05
R11732 9776 9777 1.712 0.8 13.696 37
I9777 0 9777 1.29868e-05
R11733 9777 9778 1.664 0.8 13.312 37
I9778 0 9778 1.23684e-05
R11734 9778 9779 1.712 0.8 13.696 37
I9779 0 9779 1.23684e-05
R11735 9779 9780 1.664 0.8 13.312 37
I9780 0 9780 1.23684e-05
R11736 9780 0 0.1 49.28 49.28 37
*seg: 979
R11737 0 9781 0.1 49.28 49.28 37
R11738 9785 9795 6.16 0.8 49.28 37
I9781 0 9781 1.32342e-05
R11739 9781 9782 1.744 0.8 13.952 37
I9782 0 9782 1.34816e-05
R11740 9782 9783 1.664 0.8 13.312 37
I9783 0 9783 1.32342e-05
R11741 9783 9784 1.728 0.8 13.824 37
I9784 0 9784 1.31105e-05
R11742 9784 9785 1.696 0.8 13.568 37
I9785 0 9785 1.28631e-05
R11743 9785 9786 1.744 0.8 13.952 37
I9786 0 9786 1.23684e-05
R11744 9786 9787 1.728 0.8 13.824 37
I9787 0 9787 1.24921e-05
R11745 9787 9788 1.632 0.8 13.056 37
I9788 0 9788 1.32342e-05
R11746 9788 9789 1.696 0.8 13.568 37
I9789 0 9789 1.26158e-05
R11747 9789 9790 1.616 0.8 12.928 37
I9790 0 9790 1.23684e-05
R11748 9790 0 0.1 49.28 49.28 37
*seg: 980
R11749 0 9791 0.1 49.28 49.28 37
R11750 9795 9805 6.16 0.8 49.28 37
I9791 0 9791 1.32342e-05
R11751 9791 9792 1.696 0.8 13.568 37
I9792 0 9792 1.27395e-05
R11752 9792 9793 1.664 0.8 13.312 37
I9793 0 9793 1.34816e-05
R11753 9793 9794 1.712 0.8 13.696 37
I9794 0 9794 1.29868e-05
R11754 9794 9795 1.632 0.8 13.056 37
I9795 0 9795 1.26158e-05
R11755 9795 9796 1.616 0.8 12.928 37
I9796 0 9796 1.34816e-05
R11756 9796 9797 1.728 0.8 13.824 37
I9797 0 9797 1.32342e-05
R11757 9797 9798 1.696 0.8 13.568 37
I9798 0 9798 1.29868e-05
R11758 9798 9799 1.744 0.8 13.952 37
I9799 0 9799 1.26158e-05
R11759 9799 9800 1.68 0.8 13.44 37
I9800 0 9800 1.23684e-05
R11760 9800 0 0.1 49.28 49.28 37
*seg: 981
R11761 0 9801 0.1 49.28 49.28 37
R11762 9805 9815 6.16 0.8 49.28 37
I9801 0 9801 1.33579e-05
R11763 9801 9802 1.632 0.8 13.056 37
I9802 0 9802 1.24921e-05
R11764 9802 9803 1.664 0.8 13.312 37
I9803 0 9803 1.24921e-05
R11765 9803 9804 1.632 0.8 13.056 37
I9804 0 9804 1.26158e-05
R11766 9804 9805 1.632 0.8 13.056 37
I9805 0 9805 1.24921e-05
R11767 9805 9806 1.728 0.8 13.824 37
I9806 0 9806 1.23684e-05
R11768 9806 9807 1.664 0.8 13.312 37
I9807 0 9807 1.34816e-05
R11769 9807 9808 1.6 0.8 12.8 37
I9808 0 9808 1.26158e-05
R11770 9808 9809 1.632 0.8 13.056 37
I9809 0 9809 1.33579e-05
R11771 9809 9810 1.616 0.8 12.928 37
I9810 0 9810 1.23684e-05
R11772 9810 0 0.1 49.28 49.28 37
*seg: 982
R11773 0 9811 0.1 49.28 49.28 37
R11774 9815 9825 6.16 0.8 49.28 37
I9811 0 9811 1.27395e-05
R11775 9811 9812 1.744 0.8 13.952 37
I9812 0 9812 1.32342e-05
R11776 9812 9813 1.6 0.8 12.8 37
I9813 0 9813 1.34816e-05
R11777 9813 9814 1.648 0.8 13.184 37
I9814 0 9814 1.26158e-05
R11778 9814 9815 1.744 0.8 13.952 37
I9815 0 9815 1.33579e-05
R11779 9815 9816 1.648 0.8 13.184 37
I9816 0 9816 1.31105e-05
R11780 9816 9817 1.616 0.8 12.928 37
I9817 0 9817 1.29868e-05
R11781 9817 9818 1.68 0.8 13.44 37
I9818 0 9818 1.32342e-05
R11782 9818 9819 1.712 0.8 13.696 37
I9819 0 9819 1.23684e-05
R11783 9819 9820 1.712 0.8 13.696 37
I9820 0 9820 1.23684e-05
R11784 9820 0 0.1 49.28 49.28 37
*seg: 983
R11785 0 9821 0.1 49.28 49.28 37
R11786 9825 9835 6.16 0.8 49.28 37
I9821 0 9821 1.28631e-05
R11787 9821 9822 1.712 0.8 13.696 37
I9822 0 9822 1.26158e-05
R11788 9822 9823 1.696 0.8 13.568 37
I9823 0 9823 1.33579e-05
R11789 9823 9824 1.68 0.8 13.44 37
I9824 0 9824 1.33579e-05
R11790 9824 9825 1.648 0.8 13.184 37
I9825 0 9825 1.34816e-05
R11791 9825 9826 1.68 0.8 13.44 37
I9826 0 9826 1.26158e-05
R11792 9826 9827 1.616 0.8 12.928 37
I9827 0 9827 1.29868e-05
R11793 9827 9828 1.632 0.8 13.056 37
I9828 0 9828 1.33579e-05
R11794 9828 9829 1.648 0.8 13.184 37
I9829 0 9829 1.23684e-05
R11795 9829 9830 1.648 0.8 13.184 37
I9830 0 9830 1.23684e-05
R11796 9830 0 0.1 49.28 49.28 37
*seg: 984
R11797 0 9831 0.1 49.28 49.28 37
R11798 9835 9845 6.16 0.8 49.28 37
I9831 0 9831 1.24921e-05
R11799 9831 9832 1.648 0.8 13.184 37
I9832 0 9832 1.23684e-05
R11800 9832 9833 1.728 0.8 13.824 37
I9833 0 9833 1.27395e-05
R11801 9833 9834 1.648 0.8 13.184 37
I9834 0 9834 1.34816e-05
R11802 9834 9835 1.616 0.8 12.928 37
I9835 0 9835 1.29868e-05
R11803 9835 9836 1.744 0.8 13.952 37
I9836 0 9836 1.23684e-05
R11804 9836 9837 1.648 0.8 13.184 37
I9837 0 9837 1.33579e-05
R11805 9837 9838 1.632 0.8 13.056 37
I9838 0 9838 1.34816e-05
R11806 9838 9839 1.664 0.8 13.312 37
I9839 0 9839 1.33579e-05
R11807 9839 9840 1.728 0.8 13.824 37
I9840 0 9840 1.23684e-05
R11808 9840 0 0.1 49.28 49.28 37
*seg: 985
R11809 0 9841 0.1 49.28 49.28 37
R11810 9845 9855 6.16 0.8 49.28 37
I9841 0 9841 1.31105e-05
R11811 9841 9842 1.744 0.8 13.952 37
I9842 0 9842 1.32342e-05
R11812 9842 9843 1.648 0.8 13.184 37
I9843 0 9843 1.31105e-05
R11813 9843 9844 1.616 0.8 12.928 37
I9844 0 9844 1.33579e-05
R11814 9844 9845 1.616 0.8 12.928 37
I9845 0 9845 1.23684e-05
R11815 9845 9846 1.696 0.8 13.568 37
I9846 0 9846 1.33579e-05
R11816 9846 9847 1.632 0.8 13.056 37
I9847 0 9847 1.27395e-05
R11817 9847 9848 1.696 0.8 13.568 37
I9848 0 9848 1.31105e-05
R11818 9848 9849 1.648 0.8 13.184 37
I9849 0 9849 1.29868e-05
R11819 9849 9850 1.696 0.8 13.568 37
I9850 0 9850 1.23684e-05
R11820 9850 0 0.1 49.28 49.28 37
*seg: 986
R11821 0 9851 0.1 49.28 49.28 37
R11822 9855 9865 6.16 0.8 49.28 37
I9851 0 9851 1.31105e-05
R11823 9851 9852 1.6 0.8 12.8 37
I9852 0 9852 1.28631e-05
R11824 9852 9853 1.696 0.8 13.568 37
I9853 0 9853 1.23684e-05
R11825 9853 9854 1.648 0.8 13.184 37
I9854 0 9854 1.29868e-05
R11826 9854 9855 1.648 0.8 13.184 37
I9855 0 9855 1.34816e-05
R11827 9855 9856 1.6 0.8 12.8 37
I9856 0 9856 1.26158e-05
R11828 9856 9857 1.744 0.8 13.952 37
I9857 0 9857 1.28631e-05
R11829 9857 9858 1.664 0.8 13.312 37
I9858 0 9858 1.27395e-05
R11830 9858 9859 1.632 0.8 13.056 37
I9859 0 9859 1.24921e-05
R11831 9859 9860 1.696 0.8 13.568 37
I9860 0 9860 1.23684e-05
R11832 9860 0 0.1 49.28 49.28 37
*seg: 987
R11833 0 9861 0.1 49.28 49.28 37
R11834 9865 9875 6.16 0.8 49.28 37
I9861 0 9861 1.31105e-05
R11835 9861 9862 1.712 0.8 13.696 37
I9862 0 9862 1.24921e-05
R11836 9862 9863 1.728 0.8 13.824 37
I9863 0 9863 1.34816e-05
R11837 9863 9864 1.728 0.8 13.824 37
I9864 0 9864 1.27395e-05
R11838 9864 9865 1.6 0.8 12.8 37
I9865 0 9865 1.32342e-05
R11839 9865 9866 1.696 0.8 13.568 37
I9866 0 9866 1.34816e-05
R11840 9866 9867 1.712 0.8 13.696 37
I9867 0 9867 1.27395e-05
R11841 9867 9868 1.68 0.8 13.44 37
I9868 0 9868 1.33579e-05
R11842 9868 9869 1.744 0.8 13.952 37
I9869 0 9869 1.32342e-05
R11843 9869 9870 1.632 0.8 13.056 37
I9870 0 9870 1.23684e-05
R11844 9870 0 0.1 49.28 49.28 37
*seg: 988
R11845 0 9871 0.1 49.28 49.28 37
R11846 9875 9885 6.16 0.8 49.28 37
I9871 0 9871 1.34816e-05
R11847 9871 9872 1.744 0.8 13.952 37
I9872 0 9872 1.26158e-05
R11848 9872 9873 1.648 0.8 13.184 37
I9873 0 9873 1.31105e-05
R11849 9873 9874 1.712 0.8 13.696 37
I9874 0 9874 1.29868e-05
R11850 9874 9875 1.712 0.8 13.696 37
I9875 0 9875 1.32342e-05
R11851 9875 9876 1.632 0.8 13.056 37
I9876 0 9876 1.27395e-05
R11852 9876 9877 1.696 0.8 13.568 37
I9877 0 9877 1.28631e-05
R11853 9877 9878 1.648 0.8 13.184 37
I9878 0 9878 1.27395e-05
R11854 9878 9879 1.696 0.8 13.568 37
I9879 0 9879 1.24921e-05
R11855 9879 9880 1.632 0.8 13.056 37
I9880 0 9880 1.23684e-05
R11856 9880 0 0.1 49.28 49.28 37
*seg: 989
R11857 0 9881 0.1 49.28 49.28 37
R11858 9885 9895 6.16 0.8 49.28 37
I9881 0 9881 1.27395e-05
R11859 9881 9882 1.696 0.8 13.568 37
I9882 0 9882 1.28631e-05
R11860 9882 9883 1.68 0.8 13.44 37
I9883 0 9883 1.31105e-05
R11861 9883 9884 1.728 0.8 13.824 37
I9884 0 9884 1.34816e-05
R11862 9884 9885 1.68 0.8 13.44 37
I9885 0 9885 1.24921e-05
R11863 9885 9886 1.712 0.8 13.696 37
I9886 0 9886 1.31105e-05
R11864 9886 9887 1.6 0.8 12.8 37
I9887 0 9887 1.24921e-05
R11865 9887 9888 1.6 0.8 12.8 37
I9888 0 9888 1.29868e-05
R11866 9888 9889 1.632 0.8 13.056 37
I9889 0 9889 1.31105e-05
R11867 9889 9890 1.712 0.8 13.696 37
I9890 0 9890 1.23684e-05
R11868 9890 0 0.1 49.28 49.28 37
*seg: 990
R11869 0 9891 0.1 49.28 49.28 37
R11870 9895 9905 6.16 0.8 49.28 37
I9891 0 9891 1.29868e-05
R11871 9891 9892 1.712 0.8 13.696 37
I9892 0 9892 1.31105e-05
R11872 9892 9893 1.728 0.8 13.824 37
I9893 0 9893 1.28631e-05
R11873 9893 9894 1.728 0.8 13.824 37
I9894 0 9894 1.31105e-05
R11874 9894 9895 1.632 0.8 13.056 37
I9895 0 9895 1.29868e-05
R11875 9895 9896 1.696 0.8 13.568 37
I9896 0 9896 1.28631e-05
R11876 9896 9897 1.712 0.8 13.696 37
I9897 0 9897 1.32342e-05
R11877 9897 9898 1.712 0.8 13.696 37
I9898 0 9898 1.34816e-05
R11878 9898 9899 1.712 0.8 13.696 37
I9899 0 9899 1.26158e-05
R11879 9899 9900 1.616 0.8 12.928 37
I9900 0 9900 1.23684e-05
R11880 9900 0 0.1 49.28 49.28 37
*seg: 991
R11881 0 9901 0.1 49.28 49.28 37
R11882 9905 9915 6.16 0.8 49.28 37
I9901 0 9901 1.28631e-05
R11883 9901 9902 1.616 0.8 12.928 37
I9902 0 9902 1.23684e-05
R11884 9902 9903 1.728 0.8 13.824 37
I9903 0 9903 1.34816e-05
R11885 9903 9904 1.712 0.8 13.696 37
I9904 0 9904 1.29868e-05
R11886 9904 9905 1.728 0.8 13.824 37
I9905 0 9905 1.32342e-05
R11887 9905 9906 1.68 0.8 13.44 37
I9906 0 9906 1.31105e-05
R11888 9906 9907 1.648 0.8 13.184 37
I9907 0 9907 1.26158e-05
R11889 9907 9908 1.68 0.8 13.44 37
I9908 0 9908 1.29868e-05
R11890 9908 9909 1.744 0.8 13.952 37
I9909 0 9909 1.33579e-05
R11891 9909 9910 1.744 0.8 13.952 37
I9910 0 9910 1.23684e-05
R11892 9910 0 0.1 49.28 49.28 37
*seg: 992
R11893 0 9911 0.1 49.28 49.28 37
R11894 9915 9925 6.16 0.8 49.28 37
I9911 0 9911 1.23684e-05
R11895 9911 9912 1.68 0.8 13.44 37
I9912 0 9912 1.32342e-05
R11896 9912 9913 1.728 0.8 13.824 37
I9913 0 9913 1.27395e-05
R11897 9913 9914 1.744 0.8 13.952 37
I9914 0 9914 1.31105e-05
R11898 9914 9915 1.744 0.8 13.952 37
I9915 0 9915 1.23684e-05
R11899 9915 9916 1.712 0.8 13.696 37
I9916 0 9916 1.32342e-05
R11900 9916 9917 1.632 0.8 13.056 37
I9917 0 9917 1.33579e-05
R11901 9917 9918 1.696 0.8 13.568 37
I9918 0 9918 1.24921e-05
R11902 9918 9919 1.712 0.8 13.696 37
I9919 0 9919 1.23684e-05
R11903 9919 9920 1.728 0.8 13.824 37
I9920 0 9920 1.23684e-05
R11904 9920 0 0.1 49.28 49.28 37
*seg: 993
R11905 0 9921 0.1 49.28 49.28 37
R11906 9925 9935 6.16 0.8 49.28 37
I9921 0 9921 1.34816e-05
R11907 9921 9922 1.664 0.8 13.312 37
I9922 0 9922 1.29868e-05
R11908 9922 9923 1.648 0.8 13.184 37
I9923 0 9923 1.27395e-05
R11909 9923 9924 1.664 0.8 13.312 37
I9924 0 9924 1.24921e-05
R11910 9924 9925 1.664 0.8 13.312 37
I9925 0 9925 1.31105e-05
R11911 9925 9926 1.6 0.8 12.8 37
I9926 0 9926 1.27395e-05
R11912 9926 9927 1.664 0.8 13.312 37
I9927 0 9927 1.28631e-05
R11913 9927 9928 1.68 0.8 13.44 37
I9928 0 9928 1.24921e-05
R11914 9928 9929 1.744 0.8 13.952 37
I9929 0 9929 1.32342e-05
R11915 9929 9930 1.616 0.8 12.928 37
I9930 0 9930 1.23684e-05
R11916 9930 0 0.1 49.28 49.28 37
*seg: 994
R11917 0 9931 0.1 49.28 49.28 37
R11918 9935 9945 6.16 0.8 49.28 37
I9931 0 9931 1.32342e-05
R11919 9931 9932 1.696 0.8 13.568 37
I9932 0 9932 1.27395e-05
R11920 9932 9933 1.664 0.8 13.312 37
I9933 0 9933 1.23684e-05
R11921 9933 9934 1.712 0.8 13.696 37
I9934 0 9934 1.34816e-05
R11922 9934 9935 1.664 0.8 13.312 37
I9935 0 9935 1.28631e-05
R11923 9935 9936 1.744 0.8 13.952 37
I9936 0 9936 1.23684e-05
R11924 9936 9937 1.712 0.8 13.696 37
I9937 0 9937 1.23684e-05
R11925 9937 9938 1.744 0.8 13.952 37
I9938 0 9938 1.29868e-05
R11926 9938 9939 1.696 0.8 13.568 37
I9939 0 9939 1.31105e-05
R11927 9939 9940 1.696 0.8 13.568 37
I9940 0 9940 1.23684e-05
R11928 9940 0 0.1 49.28 49.28 37
*seg: 995
R11929 0 9941 0.1 49.28 49.28 37
R11930 9945 9955 6.16 0.8 49.28 37
I9941 0 9941 1.34816e-05
R11931 9941 9942 1.664 0.8 13.312 37
I9942 0 9942 1.34816e-05
R11932 9942 9943 1.728 0.8 13.824 37
I9943 0 9943 1.33579e-05
R11933 9943 9944 1.696 0.8 13.568 37
I9944 0 9944 1.33579e-05
R11934 9944 9945 1.664 0.8 13.312 37
I9945 0 9945 1.29868e-05
R11935 9945 9946 1.744 0.8 13.952 37
I9946 0 9946 1.27395e-05
R11936 9946 9947 1.68 0.8 13.44 37
I9947 0 9947 1.23684e-05
R11937 9947 9948 1.712 0.8 13.696 37
I9948 0 9948 1.24921e-05
R11938 9948 9949 1.68 0.8 13.44 37
I9949 0 9949 1.29868e-05
R11939 9949 9950 1.616 0.8 12.928 37
I9950 0 9950 1.23684e-05
R11940 9950 0 0.1 49.28 49.28 37
*seg: 996
R11941 0 9951 0.1 49.28 49.28 37
R11942 9955 9965 6.16 0.8 49.28 37
I9951 0 9951 1.26158e-05
R11943 9951 9952 1.68 0.8 13.44 37
I9952 0 9952 1.29868e-05
R11944 9952 9953 1.6 0.8 12.8 37
I9953 0 9953 1.29868e-05
R11945 9953 9954 1.616 0.8 12.928 37
I9954 0 9954 1.33579e-05
R11946 9954 9955 1.744 0.8 13.952 37
I9955 0 9955 1.24921e-05
R11947 9955 9956 1.632 0.8 13.056 37
I9956 0 9956 1.26158e-05
R11948 9956 9957 1.648 0.8 13.184 37
I9957 0 9957 1.28631e-05
R11949 9957 9958 1.68 0.8 13.44 37
I9958 0 9958 1.28631e-05
R11950 9958 9959 1.712 0.8 13.696 37
I9959 0 9959 1.26158e-05
R11951 9959 9960 1.616 0.8 12.928 37
I9960 0 9960 1.23684e-05
R11952 9960 0 0.1 49.28 49.28 37
*seg: 997
R11953 0 9961 0.1 49.28 49.28 37
R11954 9965 9975 6.16 0.8 49.28 37
I9961 0 9961 1.23684e-05
R11955 9961 9962 1.632 0.8 13.056 37
I9962 0 9962 1.28631e-05
R11956 9962 9963 1.664 0.8 13.312 37
I9963 0 9963 1.26158e-05
R11957 9963 9964 1.696 0.8 13.568 37
I9964 0 9964 1.24921e-05
R11958 9964 9965 1.616 0.8 12.928 37
I9965 0 9965 1.33579e-05
R11959 9965 9966 1.6 0.8 12.8 37
I9966 0 9966 1.31105e-05
R11960 9966 9967 1.728 0.8 13.824 37
I9967 0 9967 1.24921e-05
R11961 9967 9968 1.712 0.8 13.696 37
I9968 0 9968 1.33579e-05
R11962 9968 9969 1.6 0.8 12.8 37
I9969 0 9969 1.28631e-05
R11963 9969 9970 1.648 0.8 13.184 37
I9970 0 9970 1.23684e-05
R11964 9970 0 0.1 49.28 49.28 37
*seg: 998
R11965 0 9971 0.1 49.28 49.28 37
R11966 9975 9985 6.16 0.8 49.28 37
I9971 0 9971 1.29868e-05
R11967 9971 9972 1.728 0.8 13.824 37
I9972 0 9972 1.27395e-05
R11968 9972 9973 1.696 0.8 13.568 37
I9973 0 9973 1.23684e-05
R11969 9973 9974 1.712 0.8 13.696 37
I9974 0 9974 1.27395e-05
R11970 9974 9975 1.696 0.8 13.568 37
I9975 0 9975 1.27395e-05
R11971 9975 9976 1.68 0.8 13.44 37
I9976 0 9976 1.23684e-05
R11972 9976 9977 1.696 0.8 13.568 37
I9977 0 9977 1.28631e-05
R11973 9977 9978 1.68 0.8 13.44 37
I9978 0 9978 1.32342e-05
R11974 9978 9979 1.68 0.8 13.44 37
I9979 0 9979 1.24921e-05
R11975 9979 9980 1.664 0.8 13.312 37
I9980 0 9980 1.23684e-05
R11976 9980 0 0.1 49.28 49.28 37
*seg: 999
R11977 0 9981 0.1 49.28 49.28 37
R11978 9985 9995 6.16 0.8 49.28 37
I9981 0 9981 1.27395e-05
R11979 9981 9982 1.744 0.8 13.952 37
I9982 0 9982 1.33579e-05
R11980 9982 9983 1.664 0.8 13.312 37
I9983 0 9983 1.26158e-05
R11981 9983 9984 1.616 0.8 12.928 37
I9984 0 9984 1.28631e-05
R11982 9984 9985 1.68 0.8 13.44 37
I9985 0 9985 1.27395e-05
R11983 9985 9986 1.616 0.8 12.928 37
I9986 0 9986 1.29868e-05
R11984 9986 9987 1.68 0.8 13.44 37
I9987 0 9987 1.23684e-05
R11985 9987 9988 1.696 0.8 13.568 37
I9988 0 9988 1.34816e-05
R11986 9988 9989 1.68 0.8 13.44 37
I9989 0 9989 1.27395e-05
R11987 9989 9990 1.696 0.8 13.568 37
I9990 0 9990 1.23684e-05
R11988 9990 0 0.1 49.28 49.28 37
*seg: 1000
R11989 0 9991 0.1 49.28 49.28 37
I9991 0 9991 1.24921e-05
R11990 9991 9992 1.664 0.8 13.312 37
I9992 0 9992 1.26158e-05
R11991 9992 9993 1.648 0.8 13.184 37
I9993 0 9993 1.24921e-05
R11992 9993 9994 1.696 0.8 13.568 37
I9994 0 9994 1.34816e-05
R11993 9994 9995 1.648 0.8 13.184 37
I9995 0 9995 1.31105e-05
R11994 9995 9996 1.6 0.8 12.8 37
I9996 0 9996 1.31105e-05
R11995 9996 9997 1.712 0.8 13.696 37
I9997 0 9997 1.27395e-05
R11996 9997 9998 1.664 0.8 13.312 37
I9998 0 9998 1.28631e-05
R11997 9998 9999 1.712 0.8 13.696 37
I9999 0 9999 1.34816e-05
R11998 9999 10000 1.696 0.8 13.568 37
I10000 0 10000 1.23684e-05
R11999 10000 0 0.1 49.28 49.28 37

.op
.end
