num_node 3042
matrix_size 3042

* resistor network

* Rxxx n1 n2 value width length layer
R3400 3042 3039 6.16 0.8 49.28 37
R3399 3041 1753 0.56 0.8 4.48 37
R3398 3040 3041 30 0.64 3.84 36
R3397 3039 3040 1.106 2 22.12 35
R3396 3039 3036 1.36 0.8 10.88 37
R3395 3038 1749 0.56 0.8 4.48 37
R3394 3037 3038 30 0.64 3.84 36
R3393 3036 3037 1.106 2 22.12 35
R3392 3036 3033 6.16 0.8 49.28 37
R3391 3035 1745 0.56 0.8 4.48 37
R3390 3034 3035 30 0.64 3.84 36
R3389 3033 3034 1.106 2 22.12 35
R3388 3033 3030 1.36 0.8 10.88 37
R3387 3032 1741 0.56 0.8 4.48 37
R3386 3031 3032 30 0.64 3.84 36
R3385 3030 3031 1.106 2 22.12 35
R3384 3030 3027 6.16 0.8 49.28 37
R3383 3029 1737 0.56 0.8 4.48 37
R3382 3028 3029 30 0.64 3.84 36
R3381 3027 3028 1.106 2 22.12 35
R3380 3027 3024 1.36 0.8 10.88 37
R3379 3026 1733 0.56 0.8 4.48 37
R3378 3025 3026 30 0.64 3.84 36
R3377 3024 3025 1.106 2 22.12 35
R3376 3024 3021 6.16 0.8 49.28 37
R3375 3023 1729 0.56 0.8 4.48 37
R3374 3022 3023 30 0.64 3.84 36
R3373 3021 3022 1.106 2 22.12 35
R3372 3021 3018 1.36 0.8 10.88 37
R3371 3020 1725 0.56 0.8 4.48 37
R3370 3019 3020 30 0.64 3.84 36
R3369 3018 3019 1.106 2 22.12 35
R3368 3018 3015 6.16 0.8 49.28 37
R3367 3017 1721 0.56 0.8 4.48 37
R3366 3016 3017 30 0.64 3.84 36
R3365 3015 3016 1.106 2 22.12 35
R3364 3015 3012 1.36 0.8 10.88 37
R3363 3014 1718 0.56 0.8 4.48 37
R3362 3013 3014 30 0.64 3.84 36
R3361 3012 3013 1.106 2 22.12 35
R3360 3012 3009 6.16 0.8 49.28 37
R3359 3011 1714 0.56 0.8 4.48 37
R3358 3010 3011 30 0.64 3.84 36
R3357 3009 3010 1.106 2 22.12 35
R3356 3009 3006 1.36 0.8 10.88 37
R3355 3008 1710 0.56 0.8 4.48 37
R3354 3007 3008 30 0.64 3.84 36
R3353 3006 3007 1.106 2 22.12 35
R3352 3006 3003 6.16 0.8 49.28 37
R3351 3005 1706 0.56 0.8 4.48 37
R3350 3004 3005 30 0.64 3.84 36
R3349 3003 3004 1.106 2 22.12 35
R3348 3003 3000 1.36 0.8 10.88 37
R3347 3002 1702 0.56 0.8 4.48 37
R3346 3001 3002 30 0.64 3.84 36
R3345 3000 3001 1.106 2 22.12 35
R3344 3000 2997 6.16 0.8 49.28 37
R3343 2999 1698 0.56 0.8 4.48 37
R3342 2998 2999 30 0.64 3.84 36
R3341 2997 2998 1.106 2 22.12 35
R3340 2997 2994 1.36 0.8 10.88 37
R3339 2996 1694 0.56 0.8 4.48 37
R3338 2995 2996 30 0.64 3.84 36
R3337 2994 2995 1.106 2 22.12 35
R3336 2994 2991 6.16 0.8 49.28 37
R3335 2993 1690 0.56 0.8 4.48 37
R3334 2992 2993 30 0.64 3.84 36
R3333 2991 2992 1.106 2 22.12 35
R3332 2991 2988 1.36 0.8 10.88 37
R3331 2990 1686 0.56 0.8 4.48 37
R3330 2989 2990 30 0.64 3.84 36
R3329 2988 2989 1.106 2 22.12 35
R3328 2988 2985 6.16 0.8 49.28 37
R3327 2987 1682 0.56 0.8 4.48 37
R3326 2986 2987 30 0.64 3.84 36
R3325 2985 2986 1.106 2 22.12 35
R3324 2985 2982 1.36 0.8 10.88 37
R3323 2984 1678 0.56 0.8 4.48 37
R3322 2983 2984 30 0.64 3.84 36
R3321 2982 2983 1.106 2 22.12 35
R3320 2982 2979 6.16 0.8 49.28 37
R3319 2981 1674 0.56 0.8 4.48 37
R3318 2980 2981 30 0.64 3.84 36
R3317 2979 2980 1.106 2 22.12 35
R3316 2979 2976 1.36 0.8 10.88 37
R3315 2978 1670 0.56 0.8 4.48 37
R3314 2977 2978 30 0.64 3.84 36
R3313 2976 2977 1.106 2 22.12 35
R3312 2976 2973 6.16 0.8 49.28 37
R3311 2975 1666 0.56 0.8 4.48 37
R3310 2974 2975 30 0.64 3.84 36
R3309 2973 2974 1.106 2 22.12 35
R3308 2973 2970 1.36 0.8 10.88 37
R3307 2972 1662 0.56 0.8 4.48 37
R3306 2971 2972 30 0.64 3.84 36
R3305 2970 2971 1.106 2 22.12 35
R3304 2970 2967 6.16 0.8 49.28 37
R3303 2969 1658 0.56 0.8 4.48 37
R3302 2968 2969 30 0.64 3.84 36
R3301 2967 2968 1.106 2 22.12 35
R3300 2967 2964 1.36 0.8 10.88 37
R3299 2966 1654 0.56 0.8 4.48 37
R3298 2965 2966 30 0.64 3.84 36
R3297 2964 2965 1.106 2 22.12 35
R3296 2964 2961 6.16 0.8 49.28 37
R3295 2963 1650 0.56 0.8 4.48 37
R3294 2962 2963 30 0.64 3.84 36
R3293 2961 2962 1.106 2 22.12 35
R3292 2961 2958 1.36 0.8 10.88 37
R3291 2960 1646 0.56 0.8 4.48 37
R3290 2959 2960 30 0.64 3.84 36
R3289 2958 2959 1.106 2 22.12 35
R3288 2958 2955 6.16 0.8 49.28 37
R3287 2957 1642 0.56 0.8 4.48 37
R3286 2956 2957 30 0.64 3.84 36
R3285 2955 2956 1.106 2 22.12 35
R3284 2955 2952 1.36 0.8 10.88 37
R3283 2954 1638 0.56 0.8 4.48 37
R3282 2953 2954 30 0.64 3.84 36
R3281 2952 2953 1.106 2 22.12 35
R3280 2952 2949 6.16 0.8 49.28 37
R3279 2951 1634 0.56 0.8 4.48 37
R3278 2950 2951 30 0.64 3.84 36
R3277 2949 2950 1.106 2 22.12 35
R3276 2949 2946 1.36 0.8 10.88 37
R3275 2948 1630 0.56 0.8 4.48 37
R3274 2947 2948 30 0.64 3.84 36
R3273 2946 2947 1.106 2 22.12 35
R3272 2946 2943 6.16 0.8 49.28 37
R3271 2945 1626 0.56 0.8 4.48 37
R3270 2944 2945 30 0.64 3.84 36
R3269 2943 2944 1.106 2 22.12 35
R3268 2943 2940 1.36 0.8 10.88 37
R3267 2942 1622 0.56 0.8 4.48 37
R3266 2941 2942 30 0.64 3.84 36
R3265 2940 2941 1.106 2 22.12 35
R3264 2940 2937 6.16 0.8 49.28 37
R3263 2939 1618 0.56 0.8 4.48 37
R3262 2938 2939 30 0.64 3.84 36
R3261 2937 2938 1.106 2 22.12 35
R3260 2937 2934 1.36 0.8 10.88 37
R3259 2936 1614 0.56 0.8 4.48 37
R3258 2935 2936 30 0.64 3.84 36
R3257 2934 2935 1.106 2 22.12 35
R3256 2934 2931 6.16 0.8 49.28 37
R3255 2933 1610 0.56 0.8 4.48 37
R3254 2932 2933 30 0.64 3.84 36
R3253 2931 2932 1.106 2 22.12 35
R3252 2931 2928 1.36 0.8 10.88 37
R3251 2930 1606 0.56 0.8 4.48 37
R3250 2929 2930 30 0.64 3.84 36
R3249 2928 2929 1.106 2 22.12 35
R3248 2928 2925 6.16 0.8 49.28 37
R3247 2927 1602 0.56 0.8 4.48 37
R3246 2926 2927 30 0.64 3.84 36
R3245 2925 2926 1.106 2 22.12 35
R3244 2925 2922 1.36 0.8 10.88 37
R3243 2924 1598 0.56 0.8 4.48 37
R3242 2923 2924 30 0.64 3.84 36
R3241 2922 2923 1.106 2 22.12 35
R3240 2922 2919 6.16 0.8 49.28 37
R3239 2921 1594 0.56 0.8 4.48 37
R3238 2920 2921 30 0.64 3.84 36
R3237 2919 2920 1.106 2 22.12 35
R3236 2919 2916 1.36 0.8 10.88 37
R3235 2918 1590 0.56 0.8 4.48 37
R3234 2917 2918 30 0.64 3.84 36
R3233 2916 2917 1.106 2 22.12 35
R3232 2916 2913 6.16 0.8 49.28 37
R3231 2915 1587 0.56 0.8 4.48 37
R3230 2914 2915 30 0.64 3.84 36
R3229 2913 2914 1.106 2 22.12 35
R3228 2913 2910 1.36 0.8 10.88 37
R3227 2912 1583 0.56 0.8 4.48 37
R3226 2911 2912 30 0.64 3.84 36
R3225 2910 2911 1.106 2 22.12 35
R3224 2910 2907 6.16 0.8 49.28 37
R3223 2909 1579 0.56 0.8 4.48 37
R3222 2908 2909 30 0.64 3.84 36
R3221 2907 2908 1.106 2 22.12 35
R3220 2907 2904 1.36 0.8 10.88 37
R3219 2906 1576 0.56 0.8 4.48 37
R3218 2905 2906 30 0.64 3.84 36
R3217 2904 2905 1.106 2 22.12 35
R3216 2904 2901 6.16 0.8 49.28 37
R3215 2903 1572 0.56 0.8 4.48 37
R3214 2902 2903 30 0.64 3.84 36
R3213 2901 2902 1.106 2 22.12 35
R3212 2901 2898 1.36 0.8 10.88 37
R3211 2900 1568 0.56 0.8 4.48 37
R3210 2899 2900 30 0.64 3.84 36
R3209 2898 2899 1.106 2 22.12 35
R3208 2898 2895 6.16 0.8 49.28 37
R3207 2897 1564 0.56 0.8 4.48 37
R3206 2896 2897 30 0.64 3.84 36
R3205 2895 2896 1.106 2 22.12 35
R3204 2895 2892 1.36 0.8 10.88 37
R3203 2894 1560 0.56 0.8 4.48 37
R3202 2893 2894 30 0.64 3.84 36
R3201 2892 2893 1.106 2 22.12 35
R3200 2892 2889 6.16 0.8 49.28 37
R3199 2891 1556 0.56 0.8 4.48 37
R3198 2890 2891 30 0.64 3.84 36
R3197 2889 2890 1.106 2 22.12 35
R3196 2889 2886 1.36 0.8 10.88 37
R3195 2888 1552 0.56 0.8 4.48 37
R3194 2887 2888 30 0.64 3.84 36
R3193 2886 2887 1.106 2 22.12 35
R3192 2886 2883 6.16 0.8 49.28 37
R3191 2885 1548 0.56 0.8 4.48 37
R3190 2884 2885 30 0.64 3.84 36
R3189 2883 2884 1.106 2 22.12 35
R3188 2883 2880 1.36 0.8 10.88 37
R3187 2882 1544 0.56 0.8 4.48 37
R3186 2881 2882 30 0.64 3.84 36
R3185 2880 2881 1.106 2 22.12 35
R3184 2880 2877 6.16 0.8 49.28 37
R3183 2879 1540 0.56 0.8 4.48 37
R3182 2878 2879 30 0.64 3.84 36
R3181 2877 2878 1.106 2 22.12 35
R3180 2877 2874 1.36 0.8 10.88 37
R3179 2876 1536 0.56 0.8 4.48 37
R3178 2875 2876 30 0.64 3.84 36
R3177 2874 2875 1.106 2 22.12 35
R3176 2874 2871 6.16 0.8 49.28 37
R3175 2873 1532 0.56 0.8 4.48 37
R3174 2872 2873 30 0.64 3.84 36
R3173 2871 2872 1.106 2 22.12 35
R3172 2871 2868 1.36 0.8 10.88 37
R3171 2870 1528 0.56 0.8 4.48 37
R3170 2869 2870 30 0.64 3.84 36
R3169 2868 2869 1.106 2 22.12 35
R3168 2868 2865 6.16 0.8 49.28 37
R3167 2867 1524 0.56 0.8 4.48 37
R3166 2866 2867 30 0.64 3.84 36
R3165 2865 2866 1.106 2 22.12 35
R3164 2865 2862 1.36 0.8 10.88 37
R3163 2864 1520 0.56 0.8 4.48 37
R3162 2863 2864 30 0.64 3.84 36
R3161 2862 2863 1.106 2 22.12 35
R3160 2862 2859 6.16 0.8 49.28 37
R3159 2861 1516 0.56 0.8 4.48 37
R3158 2860 2861 30 0.64 3.84 36
R3157 2859 2860 1.106 2 22.12 35
R3156 2859 2856 1.36 0.8 10.88 37
R3155 2858 1512 0.56 0.8 4.48 37
R3154 2857 2858 30 0.64 3.84 36
R3153 2856 2857 1.106 2 22.12 35
R3152 2856 2853 6.16 0.8 49.28 37
R3151 2855 1508 0.56 0.8 4.48 37
R3150 2854 2855 30 0.64 3.84 36
R3149 2853 2854 1.106 2 22.12 35
R3148 2853 2850 1.36 0.8 10.88 37
R3147 2852 1504 0.56 0.8 4.48 37
R3146 2851 2852 30 0.64 3.84 36
R3145 2850 2851 1.106 2 22.12 35
R3144 2850 2847 6.16 0.8 49.28 37
R3143 2849 1500 0.56 0.8 4.48 37
R3142 2848 2849 30 0.64 3.84 36
R3141 2847 2848 1.106 2 22.12 35
R3140 2847 2844 1.36 0.8 10.88 37
R3139 2846 1497 0.56 0.8 4.48 37
R3138 2845 2846 30 0.64 3.84 36
R3137 2844 2845 1.106 2 22.12 35
R3136 2844 2841 6.16 0.8 49.28 37
R3135 2843 1493 0.56 0.8 4.48 37
R3134 2842 2843 30 0.64 3.84 36
R3133 2841 2842 1.106 2 22.12 35
R3132 2841 2838 1.36 0.8 10.88 37
R3131 2840 1489 0.56 0.8 4.48 37
R3130 2839 2840 30 0.64 3.84 36
R3129 2838 2839 1.106 2 22.12 35
R3128 2838 2835 6.16 0.8 49.28 37
R3127 2837 1485 0.56 0.8 4.48 37
R3126 2836 2837 30 0.64 3.84 36
R3125 2835 2836 1.106 2 22.12 35
R3124 2835 2832 1.36 0.8 10.88 37
R3123 2834 1481 0.56 0.8 4.48 37
R3122 2833 2834 30 0.64 3.84 36
R3121 2832 2833 1.106 2 22.12 35
R3120 2832 2829 6.16 0.8 49.28 37
R3119 2831 1477 0.56 0.8 4.48 37
R3118 2830 2831 30 0.64 3.84 36
R3117 2829 2830 1.106 2 22.12 35
R3116 2829 2826 1.36 0.8 10.88 37
R3115 2828 1473 0.56 0.8 4.48 37
R3114 2827 2828 30 0.64 3.84 36
R3113 2826 2827 1.106 2 22.12 35
R3112 2826 2823 6.16 0.8 49.28 37
R3111 2825 1469 0.56 0.8 4.48 37
R3110 2824 2825 30 0.64 3.84 36
R3109 2823 2824 1.106 2 22.12 35
R3108 2823 2820 1.36 0.8 10.88 37
R3107 2822 1465 0.56 0.8 4.48 37
R3106 2821 2822 30 0.64 3.84 36
R3105 2820 2821 1.106 2 22.12 35
R3104 2820 2817 6.16 0.8 49.28 37
R3103 2819 1461 0.56 0.8 4.48 37
R3102 2818 2819 30 0.64 3.84 36
R3101 2817 2818 1.106 2 22.12 35
R3100 2817 2814 1.36 0.8 10.88 37
R3099 2816 1457 0.56 0.8 4.48 37
R3098 2815 2816 30 0.64 3.84 36
R3097 2814 2815 1.106 2 22.12 35
R3096 2814 2811 6.16 0.8 49.28 37
R3095 2813 1453 0.56 0.8 4.48 37
R3094 2812 2813 30 0.64 3.84 36
R3093 2811 2812 1.106 2 22.12 35
R3092 2811 2808 1.36 0.8 10.88 37
R3091 2810 1449 0.56 0.8 4.48 37
R3090 2809 2810 30 0.64 3.84 36
R3089 2808 2809 1.106 2 22.12 35
R3088 2808 2805 6.16 0.8 49.28 37
R3087 2807 1445 0.56 0.8 4.48 37
R3086 2806 2807 30 0.64 3.84 36
R3085 2805 2806 1.106 2 22.12 35
R3084 2805 2802 1.36 0.8 10.88 37
R3083 2804 1441 0.56 0.8 4.48 37
R3082 2803 2804 30 0.64 3.84 36
R3081 2802 2803 1.106 2 22.12 35
R3080 2802 2799 6.16 0.8 49.28 37
R3079 2801 1437 0.56 0.8 4.48 37
R3078 2800 2801 30 0.64 3.84 36
R3077 2799 2800 1.106 2 22.12 35
R3076 2799 2796 1.36 0.8 10.88 37
R3075 2798 1433 0.56 0.8 4.48 37
R3074 2797 2798 30 0.64 3.84 36
R3073 2796 2797 1.106 2 22.12 35
R3072 2796 2793 6.16 0.8 49.28 37
R3071 2795 1429 0.56 0.8 4.48 37
R3070 2794 2795 30 0.64 3.84 36
R3069 2793 2794 1.106 2 22.12 35
R3068 2793 2790 1.36 0.8 10.88 37
R3067 2792 1425 0.56 0.8 4.48 37
R3066 2791 2792 30 0.64 3.84 36
R3065 2790 2791 1.106 2 22.12 35
R3064 2790 2787 6.16 0.8 49.28 37
R3063 2789 1421 0.56 0.8 4.48 37
R3062 2788 2789 30 0.64 3.84 36
R3061 2787 2788 1.106 2 22.12 35
R3060 2787 2784 1.36 0.8 10.88 37
R3059 2786 1417 0.56 0.8 4.48 37
R3058 2785 2786 30 0.64 3.84 36
R3057 2784 2785 1.106 2 22.12 35
R3056 2784 2781 6.16 0.8 49.28 37
R3055 2783 1413 0.56 0.8 4.48 37
R3054 2782 2783 30 0.64 3.84 36
R3053 2781 2782 1.106 2 22.12 35
R3052 2781 2778 1.36 0.8 10.88 37
R3051 2780 1409 0.56 0.8 4.48 37
R3050 2779 2780 30 0.64 3.84 36
R3049 2778 2779 1.106 2 22.12 35
R3048 2778 2775 6.16 0.8 49.28 37
R3047 2777 1405 0.56 0.8 4.48 37
R3046 2776 2777 30 0.64 3.84 36
R3045 2775 2776 1.106 2 22.12 35
R3044 2775 2772 1.36 0.8 10.88 37
R3043 2774 1401 0.56 0.8 4.48 37
R3042 2773 2774 30 0.64 3.84 36
R3041 2772 2773 1.106 2 22.12 35
R3040 2772 2769 6.16 0.8 49.28 37
R3039 2771 1397 0.56 0.8 4.48 37
R3038 2770 2771 30 0.64 3.84 36
R3037 2769 2770 1.106 2 22.12 35
R3036 2769 2766 1.36 0.8 10.88 37
R3035 2768 1393 0.56 0.8 4.48 37
R3034 2767 2768 30 0.64 3.84 36
R3033 2766 2767 1.106 2 22.12 35
R3032 2766 2763 6.16 0.8 49.28 37
R3031 2765 1389 0.56 0.8 4.48 37
R3030 2764 2765 30 0.64 3.84 36
R3029 2763 2764 1.106 2 22.12 35
R3028 2763 2760 1.36 0.8 10.88 37
R3027 2762 1385 0.56 0.8 4.48 37
R3026 2761 2762 30 0.64 3.84 36
R3025 2760 2761 1.106 2 22.12 35
R3024 2760 2757 6.16 0.8 49.28 37
R3023 2759 1381 0.56 0.8 4.48 37
R3022 2758 2759 30 0.64 3.84 36
R3021 2757 2758 1.106 2 22.12 35
R3020 2757 2754 1.36 0.8 10.88 37
R3019 2756 1377 0.56 0.8 4.48 37
R3018 2755 2756 30 0.64 3.84 36
R3017 2754 2755 1.106 2 22.12 35
R3016 2754 2751 6.16 0.8 49.28 37
R3015 2753 1373 0.56 0.8 4.48 37
R3014 2752 2753 30 0.64 3.84 36
R3013 2751 2752 1.106 2 22.12 35
R3012 2751 2748 1.36 0.8 10.88 37
R3011 2750 1370 0.56 0.8 4.48 37
R3010 2749 2750 30 0.64 3.84 36
R3009 2748 2749 1.106 2 22.12 35
R3008 2748 2745 6.16 0.8 49.28 37
R3007 2747 1366 0.56 0.8 4.48 37
R3006 2746 2747 30 0.64 3.84 36
R3005 2745 2746 1.106 2 22.12 35
R3004 2745 2742 1.36 0.8 10.88 37
R3003 2744 1362 0.56 0.8 4.48 37
R3002 2743 2744 30 0.64 3.84 36
R3001 2742 2743 1.106 2 22.12 35
R3000 2742 2739 6.16 0.8 49.28 37
R2999 2741 1358 0.56 0.8 4.48 37
R2998 2740 2741 30 0.64 3.84 36
R2997 2739 2740 1.106 2 22.12 35
R2996 2739 2736 1.36 0.8 10.88 37
R2995 2738 1354 0.56 0.8 4.48 37
R2994 2737 2738 30 0.64 3.84 36
R2993 2736 2737 1.106 2 22.12 35
R2992 2736 2733 6.16 0.8 49.28 37
R2991 2735 1350 0.56 0.8 4.48 37
R2990 2734 2735 30 0.64 3.84 36
R2989 2733 2734 1.106 2 22.12 35
R2988 2733 2730 1.36 0.8 10.88 37
R2987 2732 1346 0.56 0.8 4.48 37
R2986 2731 2732 30 0.64 3.84 36
R2985 2730 2731 1.106 2 22.12 35
R2984 2730 2727 6.16 0.8 49.28 37
R2983 2729 1342 0.56 0.8 4.48 37
R2982 2728 2729 30 0.64 3.84 36
R2981 2727 2728 1.106 2 22.12 35
R2980 2727 2724 1.36 0.8 10.88 37
R2979 2726 1338 0.56 0.8 4.48 37
R2978 2725 2726 30 0.64 3.84 36
R2977 2724 2725 1.106 2 22.12 35
R2976 2724 2721 6.16 0.8 49.28 37
R2975 2723 1334 0.56 0.8 4.48 37
R2974 2722 2723 30 0.64 3.84 36
R2973 2721 2722 1.106 2 22.12 35
R2972 2721 2718 1.36 0.8 10.88 37
R2971 2720 1330 0.56 0.8 4.48 37
R2970 2719 2720 30 0.64 3.84 36
R2969 2718 2719 1.106 2 22.12 35
R2968 2718 2715 6.16 0.8 49.28 37
R2967 2717 1326 0.56 0.8 4.48 37
R2966 2716 2717 30 0.64 3.84 36
R2965 2715 2716 1.106 2 22.12 35
R2964 2715 2712 1.36 0.8 10.88 37
R2963 2714 1322 0.56 0.8 4.48 37
R2962 2713 2714 30 0.64 3.84 36
R2961 2712 2713 1.106 2 22.12 35
R2960 2712 2709 6.16 0.8 49.28 37
R2959 2711 1318 0.56 0.8 4.48 37
R2958 2710 2711 30 0.64 3.84 36
R2957 2709 2710 1.106 2 22.12 35
R2956 2709 2706 1.36 0.8 10.88 37
R2955 2708 1314 0.56 0.8 4.48 37
R2954 2707 2708 30 0.64 3.84 36
R2953 2706 2707 1.106 2 22.12 35
R2952 2706 2703 6.16 0.8 49.28 37
R2951 2705 1310 0.56 0.8 4.48 37
R2950 2704 2705 30 0.64 3.84 36
R2949 2703 2704 1.106 2 22.12 35
R2948 2703 2700 1.36 0.8 10.88 37
R2947 2702 1306 0.56 0.8 4.48 37
R2946 2701 2702 30 0.64 3.84 36
R2945 2700 2701 1.106 2 22.12 35
R2944 2700 2697 6.16 0.8 49.28 37
R2943 2699 1302 0.56 0.8 4.48 37
R2942 2698 2699 30 0.64 3.84 36
R2941 2697 2698 1.106 2 22.12 35
R2940 2697 2694 1.36 0.8 10.88 37
R2939 2696 1298 0.56 0.8 4.48 37
R2938 2695 2696 30 0.64 3.84 36
R2937 2694 2695 1.106 2 22.12 35
R2936 2694 2691 6.16 0.8 49.28 37
R2935 2693 1294 0.56 0.8 4.48 37
R2934 2692 2693 30 0.64 3.84 36
R2933 2691 2692 1.106 2 22.12 35
R2932 2691 2688 1.36 0.8 10.88 37
R2931 2690 1290 0.56 0.8 4.48 37
R2930 2689 2690 30 0.64 3.84 36
R2929 2688 2689 1.106 2 22.12 35
R2928 2688 2685 6.16 0.8 49.28 37
R2927 2687 1286 0.56 0.8 4.48 37
R2926 2686 2687 30 0.64 3.84 36
R2925 2685 2686 1.106 2 22.12 35
R2924 2685 2682 1.36 0.8 10.88 37
R2923 2684 1283 0.56 0.8 4.48 37
R2922 2683 2684 30 0.64 3.84 36
R2921 2682 2683 1.106 2 22.12 35
R2920 2682 2679 6.16 0.8 49.28 37
R2919 2681 1279 0.56 0.8 4.48 37
R2918 2680 2681 30 0.64 3.84 36
R2917 2679 2680 1.106 2 22.12 35
R2916 2679 2676 1.36 0.8 10.88 37
R2915 2678 1275 0.56 0.8 4.48 37
R2914 2677 2678 30 0.64 3.84 36
R2913 2676 2677 1.106 2 22.12 35
R2912 2676 2673 6.16 0.8 49.28 37
R2911 2675 1271 0.56 0.8 4.48 37
R2910 2674 2675 30 0.64 3.84 36
R2909 2673 2674 1.106 2 22.12 35
R2908 2673 2670 1.36 0.8 10.88 37
R2907 2672 1267 0.56 0.8 4.48 37
R2906 2671 2672 30 0.64 3.84 36
R2905 2670 2671 1.106 2 22.12 35
R2904 2670 2667 6.16 0.8 49.28 37
R2903 2669 1263 0.56 0.8 4.48 37
R2902 2668 2669 30 0.64 3.84 36
R2901 2667 2668 1.106 2 22.12 35
R2900 2667 2664 1.36 0.8 10.88 37
R2899 2666 1259 0.56 0.8 4.48 37
R2898 2665 2666 30 0.64 3.84 36
R2897 2664 2665 1.106 2 22.12 35
R2896 2664 2661 6.16 0.8 49.28 37
R2895 2663 1255 0.56 0.8 4.48 37
R2894 2662 2663 30 0.64 3.84 36
R2893 2661 2662 1.106 2 22.12 35
R2892 2661 2658 1.36 0.8 10.88 37
R2891 2660 1251 0.56 0.8 4.48 37
R2890 2659 2660 30 0.64 3.84 36
R2889 2658 2659 1.106 2 22.12 35
R2888 2658 2655 6.16 0.8 49.28 37
R2887 2657 1247 0.56 0.8 4.48 37
R2886 2656 2657 30 0.64 3.84 36
R2885 2655 2656 1.106 2 22.12 35
R2884 2655 2652 1.36 0.8 10.88 37
R2883 2654 1243 0.56 0.8 4.48 37
R2882 2653 2654 30 0.64 3.84 36
R2881 2652 2653 1.106 2 22.12 35
R2880 2652 2649 6.16 0.8 49.28 37
R2879 2651 1239 0.56 0.8 4.48 37
R2878 2650 2651 30 0.64 3.84 36
R2877 2649 2650 1.106 2 22.12 35
R2876 2649 2646 1.36 0.8 10.88 37
R2875 2648 1235 0.56 0.8 4.48 37
R2874 2647 2648 30 0.64 3.84 36
R2873 2646 2647 1.106 2 22.12 35
R2872 2646 2643 6.16 0.8 49.28 37
R2871 2645 1231 0.56 0.8 4.48 37
R2870 2644 2645 30 0.64 3.84 36
R2869 2643 2644 1.106 2 22.12 35
R2868 2643 2640 1.36 0.8 10.88 37
R2867 2642 1227 0.56 0.8 4.48 37
R2866 2641 2642 30 0.64 3.84 36
R2865 2640 2641 1.106 2 22.12 35
R2864 2640 2637 6.16 0.8 49.28 37
R2863 2639 1224 0.56 0.8 4.48 37
R2862 2638 2639 30 0.64 3.84 36
R2861 2637 2638 1.106 2 22.12 35
R2860 2637 2634 1.36 0.8 10.88 37
R2859 2636 1220 0.56 0.8 4.48 37
R2858 2635 2636 30 0.64 3.84 36
R2857 2634 2635 1.106 2 22.12 35
R2856 2634 2631 6.16 0.8 49.28 37
R2855 2633 1216 0.56 0.8 4.48 37
R2854 2632 2633 30 0.64 3.84 36
R2853 2631 2632 1.106 2 22.12 35
R2852 2631 2628 1.36 0.8 10.88 37
R2851 2630 1212 0.56 0.8 4.48 37
R2850 2629 2630 30 0.64 3.84 36
R2849 2628 2629 1.106 2 22.12 35
R2848 2628 2625 6.16 0.8 49.28 37
R2847 2627 1208 0.56 0.8 4.48 37
R2846 2626 2627 30 0.64 3.84 36
R2845 2625 2626 1.106 2 22.12 35
R2844 2625 2622 1.36 0.8 10.88 37
R2843 2624 1204 0.56 0.8 4.48 37
R2842 2623 2624 30 0.64 3.84 36
R2841 2622 2623 1.106 2 22.12 35
R2840 2622 2619 6.16 0.8 49.28 37
R2839 2621 1201 0.56 0.8 4.48 37
R2838 2620 2621 30 0.64 3.84 36
R2837 2619 2620 1.106 2 22.12 35
R2836 2619 2616 1.36 0.8 10.88 37
R2835 2618 1198 0.56 0.8 4.48 37
R2834 2617 2618 30 0.64 3.84 36
R2833 2616 2617 1.106 2 22.12 35
R2832 2616 2613 6.16 0.8 49.28 37
R2831 2615 1194 0.56 0.8 4.48 37
R2830 2614 2615 30 0.64 3.84 36
R2829 2613 2614 1.106 2 22.12 35
R2828 2613 2610 1.36 0.8 10.88 37
R2827 2612 1190 0.56 0.8 4.48 37
R2826 2611 2612 30 0.64 3.84 36
R2825 2610 2611 1.106 2 22.12 35
R2824 2610 2607 6.16 0.8 49.28 37
R2823 2609 1186 0.56 0.8 4.48 37
R2822 2608 2609 30 0.64 3.84 36
R2821 2607 2608 1.106 2 22.12 35
R2820 2607 2604 1.36 0.8 10.88 37
R2819 2606 1182 0.56 0.8 4.48 37
R2818 2605 2606 30 0.64 3.84 36
R2817 2604 2605 1.106 2 22.12 35
R2816 2604 2601 6.16 0.8 49.28 37
R2815 2603 1178 0.56 0.8 4.48 37
R2814 2602 2603 30 0.64 3.84 36
R2813 2601 2602 1.106 2 22.12 35
R2812 2601 2598 1.36 0.8 10.88 37
R2811 2600 1174 0.56 0.8 4.48 37
R2810 2599 2600 30 0.64 3.84 36
R2809 2598 2599 1.106 2 22.12 35
R2808 2598 2595 6.16 0.8 49.28 37
R2807 2597 1171 0.56 0.8 4.48 37
R2806 2596 2597 30 0.64 3.84 36
R2805 2595 2596 1.106 2 22.12 35
R2804 2595 2592 1.36 0.8 10.88 37
R2803 2594 1167 0.56 0.8 4.48 37
R2802 2593 2594 30 0.64 3.84 36
R2801 2592 2593 1.106 2 22.12 35
R2800 2592 2589 6.16 0.8 49.28 37
R2799 2591 1163 0.56 0.8 4.48 37
R2798 2590 2591 30 0.64 3.84 36
R2797 2589 2590 1.106 2 22.12 35
R2796 2589 2586 1.36 0.8 10.88 37
R2795 2588 1159 0.56 0.8 4.48 37
R2794 2587 2588 30 0.64 3.84 36
R2793 2586 2587 1.106 2 22.12 35
R2792 2586 2583 6.16 0.8 49.28 37
R2791 2585 1155 0.56 0.8 4.48 37
R2790 2584 2585 30 0.64 3.84 36
R2789 2583 2584 1.106 2 22.12 35
R2788 2583 2580 1.36 0.8 10.88 37
R2787 2582 1151 0.56 0.8 4.48 37
R2786 2581 2582 30 0.64 3.84 36
R2785 2580 2581 1.106 2 22.12 35
R2784 2580 2577 6.16 0.8 49.28 37
R2783 2579 1147 0.56 0.8 4.48 37
R2782 2578 2579 30 0.64 3.84 36
R2781 2577 2578 1.106 2 22.12 35
R2780 2577 2574 1.36 0.8 10.88 37
R2779 2576 1143 0.56 0.8 4.48 37
R2778 2575 2576 30 0.64 3.84 36
R2777 2574 2575 1.106 2 22.12 35
R2776 2574 2571 6.16 0.8 49.28 37
R2775 2573 1139 0.56 0.8 4.48 37
R2774 2572 2573 30 0.64 3.84 36
R2773 2571 2572 1.106 2 22.12 35
R2772 2571 2568 1.36 0.8 10.88 37
R2771 2570 1135 0.56 0.8 4.48 37
R2770 2569 2570 30 0.64 3.84 36
R2769 2568 2569 1.106 2 22.12 35
R2768 2568 2565 6.16 0.8 49.28 37
R2767 2567 1131 0.56 0.8 4.48 37
R2766 2566 2567 30 0.64 3.84 36
R2765 2565 2566 1.106 2 22.12 35
R2764 2565 2562 1.36 0.8 10.88 37
R2763 2564 1127 0.56 0.8 4.48 37
R2762 2563 2564 30 0.64 3.84 36
R2761 2562 2563 1.106 2 22.12 35
R2760 2562 2559 6.16 0.8 49.28 37
R2759 2561 1123 0.56 0.8 4.48 37
R2758 2560 2561 30 0.64 3.84 36
R2757 2559 2560 1.106 2 22.12 35
R2756 2559 2556 1.36 0.8 10.88 37
R2755 2558 1119 0.56 0.8 4.48 37
R2754 2557 2558 30 0.64 3.84 36
R2753 2556 2557 1.106 2 22.12 35
R2752 2556 2553 6.16 0.8 49.28 37
R2751 2555 1115 0.56 0.8 4.48 37
R2750 2554 2555 30 0.64 3.84 36
R2749 2553 2554 1.106 2 22.12 35
R2748 2553 2550 1.36 0.8 10.88 37
R2747 2552 1111 0.56 0.8 4.48 37
R2746 2551 2552 30 0.64 3.84 36
R2745 2550 2551 1.106 2 22.12 35
R2744 2550 2547 6.16 0.8 49.28 37
R2743 2549 1107 0.56 0.8 4.48 37
R2742 2548 2549 30 0.64 3.84 36
R2741 2547 2548 1.106 2 22.12 35
R2740 2547 2544 1.36 0.8 10.88 37
R2739 2546 1103 0.56 0.8 4.48 37
R2738 2545 2546 30 0.64 3.84 36
R2737 2544 2545 1.106 2 22.12 35
R2736 2544 2541 6.16 0.8 49.28 37
R2735 2543 1099 0.56 0.8 4.48 37
R2734 2542 2543 30 0.64 3.84 36
R2733 2541 2542 1.106 2 22.12 35
R2732 2541 2538 1.36 0.8 10.88 37
R2731 2540 1095 0.56 0.8 4.48 37
R2730 2539 2540 30 0.64 3.84 36
R2729 2538 2539 1.106 2 22.12 35
R2728 2538 2535 6.16 0.8 49.28 37
R2727 2537 1091 0.56 0.8 4.48 37
R2726 2536 2537 30 0.64 3.84 36
R2725 2535 2536 1.106 2 22.12 35
R2724 2535 2532 1.36 0.8 10.88 37
R2723 2534 1087 0.56 0.8 4.48 37
R2722 2533 2534 30 0.64 3.84 36
R2721 2532 2533 1.106 2 22.12 35
R2720 2532 2529 6.16 0.8 49.28 37
R2719 2531 1083 0.56 0.8 4.48 37
R2718 2530 2531 30 0.64 3.84 36
R2717 2529 2530 1.106 2 22.12 35
R2716 2529 2526 1.36 0.8 10.88 37
R2715 2528 1080 0.56 0.8 4.48 37
R2714 2527 2528 30 0.64 3.84 36
R2713 2526 2527 1.106 2 22.12 35
R2712 2526 2523 6.16 0.8 49.28 37
R2711 2525 1076 0.56 0.8 4.48 37
R2710 2524 2525 30 0.64 3.84 36
R2709 2523 2524 1.106 2 22.12 35
R2708 2523 2520 1.36 0.8 10.88 37
R2707 2522 1072 0.56 0.8 4.48 37
R2706 2521 2522 30 0.64 3.84 36
R2705 2520 2521 1.106 2 22.12 35
R2704 2520 2517 6.16 0.8 49.28 37
R2703 2519 1068 0.56 0.8 4.48 37
R2702 2518 2519 30 0.64 3.84 36
R2701 2517 2518 1.106 2 22.12 35
R2700 2517 2514 1.36 0.8 10.88 37
R2699 2516 1064 0.56 0.8 4.48 37
R2698 2515 2516 30 0.64 3.84 36
R2697 2514 2515 1.106 2 22.12 35
R2696 2514 2511 6.16 0.8 49.28 37
R2695 2513 1060 0.56 0.8 4.48 37
R2694 2512 2513 30 0.64 3.84 36
R2693 2511 2512 1.106 2 22.12 35
R2692 2511 2508 1.36 0.8 10.88 37
R2691 2510 1056 0.56 0.8 4.48 37
R2690 2509 2510 30 0.64 3.84 36
R2689 2508 2509 1.106 2 22.12 35
R2688 2508 2505 6.16 0.8 49.28 37
R2687 2507 1052 0.56 0.8 4.48 37
R2686 2506 2507 30 0.64 3.84 36
R2685 2505 2506 1.106 2 22.12 35
R2684 2505 2502 1.36 0.8 10.88 37
R2683 2504 1048 0.56 0.8 4.48 37
R2682 2503 2504 30 0.64 3.84 36
R2681 2502 2503 1.106 2 22.12 35
R2680 2502 2499 6.16 0.8 49.28 37
R2679 2501 1044 0.56 0.8 4.48 37
R2678 2500 2501 30 0.64 3.84 36
R2677 2499 2500 1.106 2 22.12 35
R2676 2499 2496 1.36 0.8 10.88 37
R2675 2498 1040 0.56 0.8 4.48 37
R2674 2497 2498 30 0.64 3.84 36
R2673 2496 2497 1.106 2 22.12 35
R2672 2496 2493 6.16 0.8 49.28 37
R2671 2495 1036 0.56 0.8 4.48 37
R2670 2494 2495 30 0.64 3.84 36
R2669 2493 2494 1.106 2 22.12 35
R2668 2493 2490 1.36 0.8 10.88 37
R2667 2492 1032 0.56 0.8 4.48 37
R2666 2491 2492 30 0.64 3.84 36
R2665 2490 2491 1.106 2 22.12 35
R2664 2490 2487 6.16 0.8 49.28 37
R2663 2489 1028 0.56 0.8 4.48 37
R2662 2488 2489 30 0.64 3.84 36
R2661 2487 2488 1.106 2 22.12 35
R2660 2487 2484 1.36 0.8 10.88 37
R2659 2486 1024 0.56 0.8 4.48 37
R2658 2485 2486 30 0.64 3.84 36
R2657 2484 2485 1.106 2 22.12 35
R2656 2484 2481 6.16 0.8 49.28 37
R2655 2483 1020 0.56 0.8 4.48 37
R2654 2482 2483 30 0.64 3.84 36
R2653 2481 2482 1.106 2 22.12 35
R2652 2481 2478 1.36 0.8 10.88 37
R2651 2480 1016 0.56 0.8 4.48 37
R2650 2479 2480 30 0.64 3.84 36
R2649 2478 2479 1.106 2 22.12 35
R2648 2478 2475 6.16 0.8 49.28 37
R2647 2477 1012 0.56 0.8 4.48 37
R2646 2476 2477 30 0.64 3.84 36
R2645 2475 2476 1.106 2 22.12 35
R2644 2475 2472 1.36 0.8 10.88 37
R2643 2474 1008 0.56 0.8 4.48 37
R2642 2473 2474 30 0.64 3.84 36
R2641 2472 2473 1.106 2 22.12 35
R2640 2472 2469 6.16 0.8 49.28 37
R2639 2471 1004 0.56 0.8 4.48 37
R2638 2470 2471 30 0.64 3.84 36
R2637 2469 2470 1.106 2 22.12 35
R2636 2469 2466 1.36 0.8 10.88 37
R2635 2468 1000 0.56 0.8 4.48 37
R2634 2467 2468 30 0.64 3.84 36
R2633 2466 2467 1.106 2 22.12 35
R2632 2466 2463 6.16 0.8 49.28 37
R2631 2465 996 0.56 0.8 4.48 37
R2630 2464 2465 30 0.64 3.84 36
R2629 2463 2464 1.106 2 22.12 35
R2628 2463 2460 1.36 0.8 10.88 37
R2627 2462 992 0.56 0.8 4.48 37
R2626 2461 2462 30 0.64 3.84 36
R2625 2460 2461 1.106 2 22.12 35
R2624 2460 2457 6.16 0.8 49.28 37
R2623 2459 988 0.56 0.8 4.48 37
R2622 2458 2459 30 0.64 3.84 36
R2621 2457 2458 1.106 2 22.12 35
R2620 2457 2454 1.36 0.8 10.88 37
R2619 2456 984 0.56 0.8 4.48 37
R2618 2455 2456 30 0.64 3.84 36
R2617 2454 2455 1.106 2 22.12 35
R2616 2454 2451 6.16 0.8 49.28 37
R2615 2453 980 0.56 0.8 4.48 37
R2614 2452 2453 30 0.64 3.84 36
R2613 2451 2452 1.106 2 22.12 35
R2612 2451 2448 1.36 0.8 10.88 37
R2611 2450 976 0.56 0.8 4.48 37
R2610 2449 2450 30 0.64 3.84 36
R2609 2448 2449 1.106 2 22.12 35
R2608 2448 2445 6.16 0.8 49.28 37
R2607 2447 973 0.56 0.8 4.48 37
R2606 2446 2447 30 0.64 3.84 36
R2605 2445 2446 1.106 2 22.12 35
R2604 2445 2442 1.36 0.8 10.88 37
R2603 2444 969 0.56 0.8 4.48 37
R2602 2443 2444 30 0.64 3.84 36
R2601 2442 2443 1.106 2 22.12 35
R2600 2442 2439 6.16 0.8 49.28 37
R2599 2441 965 0.56 0.8 4.48 37
R2598 2440 2441 30 0.64 3.84 36
R2597 2439 2440 1.106 2 22.12 35
R2596 2439 2436 1.36 0.8 10.88 37
R2595 2438 961 0.56 0.8 4.48 37
R2594 2437 2438 30 0.64 3.84 36
R2593 2436 2437 1.106 2 22.12 35
R2592 2436 2433 6.16 0.8 49.28 37
R2591 2435 957 0.56 0.8 4.48 37
R2590 2434 2435 30 0.64 3.84 36
R2589 2433 2434 1.106 2 22.12 35
R2588 2433 2430 1.36 0.8 10.88 37
R2587 2432 953 0.56 0.8 4.48 37
R2586 2431 2432 30 0.64 3.84 36
R2585 2430 2431 1.106 2 22.12 35
R2584 2430 2427 6.16 0.8 49.28 37
R2583 2429 949 0.56 0.8 4.48 37
R2582 2428 2429 30 0.64 3.84 36
R2581 2427 2428 1.106 2 22.12 35
R2580 2427 2424 1.36 0.8 10.88 37
R2579 2426 945 0.56 0.8 4.48 37
R2578 2425 2426 30 0.64 3.84 36
R2577 2424 2425 1.106 2 22.12 35
R2576 2424 2421 6.16 0.8 49.28 37
R2575 2423 941 0.56 0.8 4.48 37
R2574 2422 2423 30 0.64 3.84 36
R2573 2421 2422 1.106 2 22.12 35
R2572 2421 2418 1.36 0.8 10.88 37
R2571 2420 937 0.56 0.8 4.48 37
R2570 2419 2420 30 0.64 3.84 36
R2569 2418 2419 1.106 2 22.12 35
R2568 2418 2415 6.16 0.8 49.28 37
R2567 2417 933 0.56 0.8 4.48 37
R2566 2416 2417 30 0.64 3.84 36
R2565 2415 2416 1.106 2 22.12 35
R2564 2415 2412 1.36 0.8 10.88 37
R2563 2414 929 0.56 0.8 4.48 37
R2562 2413 2414 30 0.64 3.84 36
R2561 2412 2413 1.106 2 22.12 35
R2560 2412 2409 6.16 0.8 49.28 37
R2559 2411 925 0.56 0.8 4.48 37
R2558 2410 2411 30 0.64 3.84 36
R2557 2409 2410 1.106 2 22.12 35
R2556 2409 2406 1.36 0.8 10.88 37
R2555 2408 921 0.56 0.8 4.48 37
R2554 2407 2408 30 0.64 3.84 36
R2553 2406 2407 1.106 2 22.12 35
R2552 2406 2403 6.16 0.8 49.28 37
R2551 2405 917 0.56 0.8 4.48 37
R2550 2404 2405 30 0.64 3.84 36
R2549 2403 2404 1.106 2 22.12 35
R2548 2403 2400 1.36 0.8 10.88 37
R2547 2402 913 0.56 0.8 4.48 37
R2546 2401 2402 30 0.64 3.84 36
R2545 2400 2401 1.106 2 22.12 35
R2544 2400 2397 6.16 0.8 49.28 37
R2543 2399 909 0.56 0.8 4.48 37
R2542 2398 2399 30 0.64 3.84 36
R2541 2397 2398 1.106 2 22.12 35
R2540 2397 2394 1.36 0.8 10.88 37
R2539 2396 905 0.56 0.8 4.48 37
R2538 2395 2396 30 0.64 3.84 36
R2537 2394 2395 1.106 2 22.12 35
R2536 2394 2391 6.16 0.8 49.28 37
R2535 2393 901 0.56 0.8 4.48 37
R2534 2392 2393 30 0.64 3.84 36
R2533 2391 2392 1.106 2 22.12 35
R2532 2391 2388 1.36 0.8 10.88 37
R2531 2390 897 0.56 0.8 4.48 37
R2530 2389 2390 30 0.64 3.84 36
R2529 2388 2389 1.106 2 22.12 35
R2528 2388 2385 6.16 0.8 49.28 37
R2527 2387 893 0.56 0.8 4.48 37
R2526 2386 2387 30 0.64 3.84 36
R2525 2385 2386 1.106 2 22.12 35
R2524 2385 2382 1.36 0.8 10.88 37
R2523 2384 889 0.56 0.8 4.48 37
R2522 2383 2384 30 0.64 3.84 36
R2521 2382 2383 1.106 2 22.12 35
R2520 2382 2379 6.16 0.8 49.28 37
R2519 2381 885 0.56 0.8 4.48 37
R2518 2380 2381 30 0.64 3.84 36
R2517 2379 2380 1.106 2 22.12 35
R2516 2379 2376 1.36 0.8 10.88 37
R2515 2378 881 0.56 0.8 4.48 37
R2514 2377 2378 30 0.64 3.84 36
R2513 2376 2377 1.106 2 22.12 35
R2512 2376 2373 6.16 0.8 49.28 37
R2511 2375 877 0.56 0.8 4.48 37
R2510 2374 2375 30 0.64 3.84 36
R2509 2373 2374 1.106 2 22.12 35
R2508 2373 2370 1.36 0.8 10.88 37
R2507 2372 873 0.56 0.8 4.48 37
R2506 2371 2372 30 0.64 3.84 36
R2505 2370 2371 1.106 2 22.12 35
R2504 2370 2367 6.16 0.8 49.28 37
R2503 2369 869 0.56 0.8 4.48 37
R2502 2368 2369 30 0.64 3.84 36
R2501 2367 2368 1.106 2 22.12 35
R2500 2367 2364 1.36 0.8 10.88 37
R2499 2366 866 0.56 0.8 4.48 37
R2498 2365 2366 30 0.64 3.84 36
R2497 2364 2365 1.106 2 22.12 35
R2496 2364 2361 6.16 0.8 49.28 37
R2495 2363 862 0.56 0.8 4.48 37
R2494 2362 2363 30 0.64 3.84 36
R2493 2361 2362 1.106 2 22.12 35
R2492 2361 2358 1.36 0.8 10.88 37
R2491 2360 858 0.56 0.8 4.48 37
R2490 2359 2360 30 0.64 3.84 36
R2489 2358 2359 1.106 2 22.12 35
R2488 2358 2355 6.16 0.8 49.28 37
R2487 2357 854 0.56 0.8 4.48 37
R2486 2356 2357 30 0.64 3.84 36
R2485 2355 2356 1.106 2 22.12 35
R2484 2355 2352 1.36 0.8 10.88 37
R2483 2354 850 0.56 0.8 4.48 37
R2482 2353 2354 30 0.64 3.84 36
R2481 2352 2353 1.106 2 22.12 35
R2480 2352 2349 6.16 0.8 49.28 37
R2479 2351 846 0.56 0.8 4.48 37
R2478 2350 2351 30 0.64 3.84 36
R2477 2349 2350 1.106 2 22.12 35
R2476 2349 2346 1.36 0.8 10.88 37
R2475 2348 842 0.56 0.8 4.48 37
R2474 2347 2348 30 0.64 3.84 36
R2473 2346 2347 1.106 2 22.12 35
R2472 2346 2343 6.16 0.8 49.28 37
R2471 2345 838 0.56 0.8 4.48 37
R2470 2344 2345 30 0.64 3.84 36
R2469 2343 2344 1.106 2 22.12 35
R2468 2343 2340 1.36 0.8 10.88 37
R2467 2342 834 0.56 0.8 4.48 37
R2466 2341 2342 30 0.64 3.84 36
R2465 2340 2341 1.106 2 22.12 35
R2464 2340 2337 6.16 0.8 49.28 37
R2463 2339 830 0.56 0.8 4.48 37
R2462 2338 2339 30 0.64 3.84 36
R2461 2337 2338 1.106 2 22.12 35
R2460 2337 2334 1.36 0.8 10.88 37
R2459 2336 826 0.56 0.8 4.48 37
R2458 2335 2336 30 0.64 3.84 36
R2457 2334 2335 1.106 2 22.12 35
R2456 2334 2331 6.16 0.8 49.28 37
R2455 2333 822 0.56 0.8 4.48 37
R2454 2332 2333 30 0.64 3.84 36
R2453 2331 2332 1.106 2 22.12 35
R2452 2331 2328 1.36 0.8 10.88 37
R2451 2330 819 0.56 0.8 4.48 37
R2450 2329 2330 30 0.64 3.84 36
R2449 2328 2329 1.106 2 22.12 35
R2448 2328 2325 6.16 0.8 49.28 37
R2447 2327 815 0.56 0.8 4.48 37
R2446 2326 2327 30 0.64 3.84 36
R2445 2325 2326 1.106 2 22.12 35
R2444 2325 2322 1.36 0.8 10.88 37
R2443 2324 811 0.56 0.8 4.48 37
R2442 2323 2324 30 0.64 3.84 36
R2441 2322 2323 1.106 2 22.12 35
R2440 2322 2319 6.16 0.8 49.28 37
R2439 2321 807 0.56 0.8 4.48 37
R2438 2320 2321 30 0.64 3.84 36
R2437 2319 2320 1.106 2 22.12 35
R2436 2319 2316 1.36 0.8 10.88 37
R2435 2318 803 0.56 0.8 4.48 37
R2434 2317 2318 30 0.64 3.84 36
R2433 2316 2317 1.106 2 22.12 35
R2432 2316 2313 6.16 0.8 49.28 37
R2431 2315 799 0.56 0.8 4.48 37
R2430 2314 2315 30 0.64 3.84 36
R2429 2313 2314 1.106 2 22.12 35
R2428 2313 2310 1.36 0.8 10.88 37
R2427 2312 795 0.56 0.8 4.48 37
R2426 2311 2312 30 0.64 3.84 36
R2425 2310 2311 1.106 2 22.12 35
R2424 2310 2307 6.16 0.8 49.28 37
R2423 2309 791 0.56 0.8 4.48 37
R2422 2308 2309 30 0.64 3.84 36
R2421 2307 2308 1.106 2 22.12 35
R2420 2307 2304 1.36 0.8 10.88 37
R2419 2306 787 0.56 0.8 4.48 37
R2418 2305 2306 30 0.64 3.84 36
R2417 2304 2305 1.106 2 22.12 35
R2416 2304 2301 6.16 0.8 49.28 37
R2415 2303 783 0.56 0.8 4.48 37
R2414 2302 2303 30 0.64 3.84 36
R2413 2301 2302 1.106 2 22.12 35
R2412 2301 2298 1.36 0.8 10.88 37
R2411 2300 779 0.56 0.8 4.48 37
R2410 2299 2300 30 0.64 3.84 36
R2409 2298 2299 1.106 2 22.12 35
R2408 2298 2295 6.16 0.8 49.28 37
R2407 2297 775 0.56 0.8 4.48 37
R2406 2296 2297 30 0.64 3.84 36
R2405 2295 2296 1.106 2 22.12 35
R2404 2295 2292 1.36 0.8 10.88 37
R2403 2294 772 0.56 0.8 4.48 37
R2402 2293 2294 30 0.64 3.84 36
R2401 2292 2293 1.106 2 22.12 35
R2400 2292 2289 6.16 0.8 49.28 37
R2399 2291 768 0.56 0.8 4.48 37
R2398 2290 2291 30 0.64 3.84 36
R2397 2289 2290 1.106 2 22.12 35
R2396 2289 2286 1.36 0.8 10.88 37
R2395 2288 764 0.56 0.8 4.48 37
R2394 2287 2288 30 0.64 3.84 36
R2393 2286 2287 1.106 2 22.12 35
R2392 2286 2283 6.16 0.8 49.28 37
R2391 2285 760 0.56 0.8 4.48 37
R2390 2284 2285 30 0.64 3.84 36
R2389 2283 2284 1.106 2 22.12 35
R2388 2283 2280 1.36 0.8 10.88 37
R2387 2282 756 0.56 0.8 4.48 37
R2386 2281 2282 30 0.64 3.84 36
R2385 2280 2281 1.106 2 22.12 35
R2384 2280 2277 6.16 0.8 49.28 37
R2383 2279 752 0.56 0.8 4.48 37
R2382 2278 2279 30 0.64 3.84 36
R2381 2277 2278 1.106 2 22.12 35
R2380 2277 2274 1.36 0.8 10.88 37
R2379 2276 748 0.56 0.8 4.48 37
R2378 2275 2276 30 0.64 3.84 36
R2377 2274 2275 1.106 2 22.12 35
R2376 2274 2271 6.16 0.8 49.28 37
R2375 2273 744 0.56 0.8 4.48 37
R2374 2272 2273 30 0.64 3.84 36
R2373 2271 2272 1.106 2 22.12 35
R2372 2271 2268 1.36 0.8 10.88 37
R2371 2270 740 0.56 0.8 4.48 37
R2370 2269 2270 30 0.64 3.84 36
R2369 2268 2269 1.106 2 22.12 35
R2368 2268 2265 6.16 0.8 49.28 37
R2367 2267 736 0.56 0.8 4.48 37
R2366 2266 2267 30 0.64 3.84 36
R2365 2265 2266 1.106 2 22.12 35
R2364 2265 2262 1.36 0.8 10.88 37
R2363 2264 732 0.56 0.8 4.48 37
R2362 2263 2264 30 0.64 3.84 36
R2361 2262 2263 1.106 2 22.12 35
R2360 2262 2259 6.16 0.8 49.28 37
R2359 2261 728 0.56 0.8 4.48 37
R2358 2260 2261 30 0.64 3.84 36
R2357 2259 2260 1.106 2 22.12 35
R2356 2259 2256 1.36 0.8 10.88 37
R2355 2258 724 0.56 0.8 4.48 37
R2354 2257 2258 30 0.64 3.84 36
R2353 2256 2257 1.106 2 22.12 35
R2352 2256 2253 6.16 0.8 49.28 37
R2351 2255 720 0.56 0.8 4.48 37
R2350 2254 2255 30 0.64 3.84 36
R2349 2253 2254 1.106 2 22.12 35
R2348 2253 2250 1.36 0.8 10.88 37
R2347 2252 716 0.56 0.8 4.48 37
R2346 2251 2252 30 0.64 3.84 36
R2345 2250 2251 1.106 2 22.12 35
R2344 2250 2247 6.16 0.8 49.28 37
R2343 2249 712 0.56 0.8 4.48 37
R2342 2248 2249 30 0.64 3.84 36
R2341 2247 2248 1.106 2 22.12 35
R2340 2247 2244 1.36 0.8 10.88 37
R2339 2246 708 0.56 0.8 4.48 37
R2338 2245 2246 30 0.64 3.84 36
R2337 2244 2245 1.106 2 22.12 35
R2336 2244 2241 6.16 0.8 49.28 37
R2335 2243 704 0.56 0.8 4.48 37
R2334 2242 2243 30 0.64 3.84 36
R2333 2241 2242 1.106 2 22.12 35
R2332 2241 2238 1.36 0.8 10.88 37
R2331 2240 700 0.56 0.8 4.48 37
R2330 2239 2240 30 0.64 3.84 36
R2329 2238 2239 1.106 2 22.12 35
R2328 2238 2235 6.16 0.8 49.28 37
R2327 2237 696 0.56 0.8 4.48 37
R2326 2236 2237 30 0.64 3.84 36
R2325 2235 2236 1.106 2 22.12 35
R2324 2235 2232 1.36 0.8 10.88 37
R2323 2234 692 0.56 0.8 4.48 37
R2322 2233 2234 30 0.64 3.84 36
R2321 2232 2233 1.106 2 22.12 35
R2320 2232 2229 6.16 0.8 49.28 37
R2319 2231 688 0.56 0.8 4.48 37
R2318 2230 2231 30 0.64 3.84 36
R2317 2229 2230 1.106 2 22.12 35
R2316 2229 2226 1.36 0.8 10.88 37
R2315 2228 684 0.56 0.8 4.48 37
R2314 2227 2228 30 0.64 3.84 36
R2313 2226 2227 1.106 2 22.12 35
R2312 2226 2223 6.16 0.8 49.28 37
R2311 2225 680 0.56 0.8 4.48 37
R2310 2224 2225 30 0.64 3.84 36
R2309 2223 2224 1.106 2 22.12 35
R2308 2223 2220 1.36 0.8 10.88 37
R2307 2222 676 0.56 0.8 4.48 37
R2306 2221 2222 30 0.64 3.84 36
R2305 2220 2221 1.106 2 22.12 35
R2304 2220 2217 6.16 0.8 49.28 37
R2303 2219 672 0.56 0.8 4.48 37
R2302 2218 2219 30 0.64 3.84 36
R2301 2217 2218 1.106 2 22.12 35
R2300 2217 2214 1.36 0.8 10.88 37
R2299 2216 668 0.56 0.8 4.48 37
R2298 2215 2216 30 0.64 3.84 36
R2297 2214 2215 1.106 2 22.12 35
R2296 2214 2211 6.16 0.8 49.28 37
R2295 2213 665 0.56 0.8 4.48 37
R2294 2212 2213 30 0.64 3.84 36
R2293 2211 2212 1.106 2 22.12 35
R2292 2211 2208 1.36 0.8 10.88 37
R2291 2210 661 0.56 0.8 4.48 37
R2290 2209 2210 30 0.64 3.84 36
R2289 2208 2209 1.106 2 22.12 35
R2288 2208 2205 6.16 0.8 49.28 37
R2287 2207 657 0.56 0.8 4.48 37
R2286 2206 2207 30 0.64 3.84 36
R2285 2205 2206 1.106 2 22.12 35
R2284 2205 2202 1.36 0.8 10.88 37
R2283 2204 653 0.56 0.8 4.48 37
R2282 2203 2204 30 0.64 3.84 36
R2281 2202 2203 1.106 2 22.12 35
R2280 2202 2199 6.16 0.8 49.28 37
R2279 2201 649 0.56 0.8 4.48 37
R2278 2200 2201 30 0.64 3.84 36
R2277 2199 2200 1.106 2 22.12 35
R2276 2199 2196 1.36 0.8 10.88 37
R2275 2198 645 0.56 0.8 4.48 37
R2274 2197 2198 30 0.64 3.84 36
R2273 2196 2197 1.106 2 22.12 35
R2272 2196 2193 6.16 0.8 49.28 37
R2271 2195 641 0.56 0.8 4.48 37
R2270 2194 2195 30 0.64 3.84 36
R2269 2193 2194 1.106 2 22.12 35
R2268 2193 2190 1.36 0.8 10.88 37
R2267 2192 637 0.56 0.8 4.48 37
R2266 2191 2192 30 0.64 3.84 36
R2265 2190 2191 1.106 2 22.12 35
R2264 2190 2187 6.16 0.8 49.28 37
R2263 2189 633 0.56 0.8 4.48 37
R2262 2188 2189 30 0.64 3.84 36
R2261 2187 2188 1.106 2 22.12 35
R2260 2187 2184 1.36 0.8 10.88 37
R2259 2186 629 0.56 0.8 4.48 37
R2258 2185 2186 30 0.64 3.84 36
R2257 2184 2185 1.106 2 22.12 35
R2256 2184 2181 6.16 0.8 49.28 37
R2255 2183 625 0.56 0.8 4.48 37
R2254 2182 2183 30 0.64 3.84 36
R2253 2181 2182 1.106 2 22.12 35
R2252 2181 2178 1.36 0.8 10.88 37
R2251 2180 621 0.56 0.8 4.48 37
R2250 2179 2180 30 0.64 3.84 36
R2249 2178 2179 1.106 2 22.12 35
R2248 2178 2175 6.16 0.8 49.28 37
R2247 2177 617 0.56 0.8 4.48 37
R2246 2176 2177 30 0.64 3.84 36
R2245 2175 2176 1.106 2 22.12 35
R2244 2175 2172 1.36 0.8 10.88 37
R2243 2174 613 0.56 0.8 4.48 37
R2242 2173 2174 30 0.64 3.84 36
R2241 2172 2173 1.106 2 22.12 35
R2240 2172 2169 6.16 0.8 49.28 37
R2239 2171 609 0.56 0.8 4.48 37
R2238 2170 2171 30 0.64 3.84 36
R2237 2169 2170 1.106 2 22.12 35
R2236 2169 2166 1.36 0.8 10.88 37
R2235 2168 605 0.56 0.8 4.48 37
R2234 2167 2168 30 0.64 3.84 36
R2233 2166 2167 1.106 2 22.12 35
R2232 2166 2163 6.16 0.8 49.28 37
R2231 2165 601 0.56 0.8 4.48 37
R2230 2164 2165 30 0.64 3.84 36
R2229 2163 2164 1.106 2 22.12 35
R2228 2163 2160 1.36 0.8 10.88 37
R2227 2162 597 0.56 0.8 4.48 37
R2226 2161 2162 30 0.64 3.84 36
R2225 2160 2161 1.106 2 22.12 35
R2224 2160 2157 6.16 0.8 49.28 37
R2223 2159 593 0.56 0.8 4.48 37
R2222 2158 2159 30 0.64 3.84 36
R2221 2157 2158 1.106 2 22.12 35
R2220 2157 2154 1.36 0.8 10.88 37
R2219 2156 589 0.56 0.8 4.48 37
R2218 2155 2156 30 0.64 3.84 36
R2217 2154 2155 1.106 2 22.12 35
R2216 2154 2151 6.16 0.8 49.28 37
R2215 2153 585 0.56 0.8 4.48 37
R2214 2152 2153 30 0.64 3.84 36
R2213 2151 2152 1.106 2 22.12 35
R2212 2151 2148 1.36 0.8 10.88 37
R2211 2150 581 0.56 0.8 4.48 37
R2210 2149 2150 30 0.64 3.84 36
R2209 2148 2149 1.106 2 22.12 35
R2208 2148 2145 6.16 0.8 49.28 37
R2207 2147 577 0.56 0.8 4.48 37
R2206 2146 2147 30 0.64 3.84 36
R2205 2145 2146 1.106 2 22.12 35
R2204 2145 2142 1.36 0.8 10.88 37
R2203 2144 573 0.56 0.8 4.48 37
R2202 2143 2144 30 0.64 3.84 36
R2201 2142 2143 1.106 2 22.12 35
R2200 2142 2139 6.16 0.8 49.28 37
R2199 2141 569 0.56 0.8 4.48 37
R2198 2140 2141 30 0.64 3.84 36
R2197 2139 2140 1.106 2 22.12 35
R2196 2139 2136 1.36 0.8 10.88 37
R2195 2138 565 0.56 0.8 4.48 37
R2194 2137 2138 30 0.64 3.84 36
R2193 2136 2137 1.106 2 22.12 35
R2192 2136 2133 6.16 0.8 49.28 37
R2191 2135 561 0.56 0.8 4.48 37
R2190 2134 2135 30 0.64 3.84 36
R2189 2133 2134 1.106 2 22.12 35
R2188 2133 2130 1.36 0.8 10.88 37
R2187 2132 557 0.56 0.8 4.48 37
R2186 2131 2132 30 0.64 3.84 36
R2185 2130 2131 1.106 2 22.12 35
R2184 2130 2127 6.16 0.8 49.28 37
R2183 2129 553 0.56 0.8 4.48 37
R2182 2128 2129 30 0.64 3.84 36
R2181 2127 2128 1.106 2 22.12 35
R2180 2127 2124 1.36 0.8 10.88 37
R2179 2126 549 0.56 0.8 4.48 37
R2178 2125 2126 30 0.64 3.84 36
R2177 2124 2125 1.106 2 22.12 35
R2176 2124 2121 6.16 0.8 49.28 37
R2175 2123 545 0.56 0.8 4.48 37
R2174 2122 2123 30 0.64 3.84 36
R2173 2121 2122 1.106 2 22.12 35
R2172 2121 2118 1.36 0.8 10.88 37
R2171 2120 541 0.56 0.8 4.48 37
R2170 2119 2120 30 0.64 3.84 36
R2169 2118 2119 1.106 2 22.12 35
R2168 2118 2115 6.16 0.8 49.28 37
R2167 2117 537 0.56 0.8 4.48 37
R2166 2116 2117 30 0.64 3.84 36
R2165 2115 2116 1.106 2 22.12 35
R2164 2115 2112 1.36 0.8 10.88 37
R2163 2114 533 0.56 0.8 4.48 37
R2162 2113 2114 30 0.64 3.84 36
R2161 2112 2113 1.106 2 22.12 35
R2160 2112 2109 6.16 0.8 49.28 37
R2159 2111 529 0.56 0.8 4.48 37
R2158 2110 2111 30 0.64 3.84 36
R2157 2109 2110 1.106 2 22.12 35
R2156 2109 2106 1.36 0.8 10.88 37
R2155 2108 525 0.56 0.8 4.48 37
R2154 2107 2108 30 0.64 3.84 36
R2153 2106 2107 1.106 2 22.12 35
R2152 2106 2103 6.16 0.8 49.28 37
R2151 2105 521 0.56 0.8 4.48 37
R2150 2104 2105 30 0.64 3.84 36
R2149 2103 2104 1.106 2 22.12 35
R2148 2103 2100 1.36 0.8 10.88 37
R2147 2102 517 0.56 0.8 4.48 37
R2146 2101 2102 30 0.64 3.84 36
R2145 2100 2101 1.106 2 22.12 35
R2144 2100 2097 6.16 0.8 49.28 37
R2143 2099 513 0.56 0.8 4.48 37
R2142 2098 2099 30 0.64 3.84 36
R2141 2097 2098 1.106 2 22.12 35
R2140 2097 2094 1.36 0.8 10.88 37
R2139 2096 509 0.56 0.8 4.48 37
R2138 2095 2096 30 0.64 3.84 36
R2137 2094 2095 1.106 2 22.12 35
R2136 2094 2091 6.16 0.8 49.28 37
R2135 2093 505 0.56 0.8 4.48 37
R2134 2092 2093 30 0.64 3.84 36
R2133 2091 2092 1.106 2 22.12 35
R2132 2091 2088 1.36 0.8 10.88 37
R2131 2090 501 0.56 0.8 4.48 37
R2130 2089 2090 30 0.64 3.84 36
R2129 2088 2089 1.106 2 22.12 35
R2128 2088 2085 6.16 0.8 49.28 37
R2127 2087 497 0.56 0.8 4.48 37
R2126 2086 2087 30 0.64 3.84 36
R2125 2085 2086 1.106 2 22.12 35
R2124 2085 2082 1.36 0.8 10.88 37
R2123 2084 493 0.56 0.8 4.48 37
R2122 2083 2084 30 0.64 3.84 36
R2121 2082 2083 1.106 2 22.12 35
R2120 2082 2079 6.16 0.8 49.28 37
R2119 2081 489 0.56 0.8 4.48 37
R2118 2080 2081 30 0.64 3.84 36
R2117 2079 2080 1.106 2 22.12 35
R2116 2079 2076 1.36 0.8 10.88 37
R2115 2078 485 0.56 0.8 4.48 37
R2114 2077 2078 30 0.64 3.84 36
R2113 2076 2077 1.106 2 22.12 35
R2112 2076 2073 6.16 0.8 49.28 37
R2111 2075 481 0.56 0.8 4.48 37
R2110 2074 2075 30 0.64 3.84 36
R2109 2073 2074 1.106 2 22.12 35
R2108 2073 2070 1.36 0.8 10.88 37
R2107 2072 477 0.56 0.8 4.48 37
R2106 2071 2072 30 0.64 3.84 36
R2105 2070 2071 1.106 2 22.12 35
R2104 2070 2067 6.16 0.8 49.28 37
R2103 2069 473 0.56 0.8 4.48 37
R2102 2068 2069 30 0.64 3.84 36
R2101 2067 2068 1.106 2 22.12 35
R2100 2067 2064 1.36 0.8 10.88 37
R2099 2066 469 0.56 0.8 4.48 37
R2098 2065 2066 30 0.64 3.84 36
R2097 2064 2065 1.106 2 22.12 35
R2096 2064 2061 6.16 0.8 49.28 37
R2095 2063 465 0.56 0.8 4.48 37
R2094 2062 2063 30 0.64 3.84 36
R2093 2061 2062 1.106 2 22.12 35
R2092 2061 2058 1.36 0.8 10.88 37
R2091 2060 461 0.56 0.8 4.48 37
R2090 2059 2060 30 0.64 3.84 36
R2089 2058 2059 1.106 2 22.12 35
R2088 2058 2055 6.16 0.8 49.28 37
R2087 2057 457 0.56 0.8 4.48 37
R2086 2056 2057 30 0.64 3.84 36
R2085 2055 2056 1.106 2 22.12 35
R2084 2055 2052 1.36 0.8 10.88 37
R2083 2054 453 0.56 0.8 4.48 37
R2082 2053 2054 30 0.64 3.84 36
R2081 2052 2053 1.106 2 22.12 35
R2080 2052 2049 6.16 0.8 49.28 37
R2079 2051 449 0.56 0.8 4.48 37
R2078 2050 2051 30 0.64 3.84 36
R2077 2049 2050 1.106 2 22.12 35
R2076 2049 2046 1.36 0.8 10.88 37
R2075 2048 445 0.56 0.8 4.48 37
R2074 2047 2048 30 0.64 3.84 36
R2073 2046 2047 1.106 2 22.12 35
R2072 2046 2043 6.16 0.8 49.28 37
R2071 2045 441 0.56 0.8 4.48 37
R2070 2044 2045 30 0.64 3.84 36
R2069 2043 2044 1.106 2 22.12 35
R2068 2043 2040 1.36 0.8 10.88 37
R2067 2042 437 0.56 0.8 4.48 37
R2066 2041 2042 30 0.64 3.84 36
R2065 2040 2041 1.106 2 22.12 35
R2064 2040 2037 6.16 0.8 49.28 37
R2063 2039 434 0.56 0.8 4.48 37
R2062 2038 2039 30 0.64 3.84 36
R2061 2037 2038 1.106 2 22.12 35
R2060 2037 2034 1.36 0.8 10.88 37
R2059 2036 430 0.56 0.8 4.48 37
R2058 2035 2036 30 0.64 3.84 36
R2057 2034 2035 1.106 2 22.12 35
R2056 2034 2031 6.16 0.8 49.28 37
R2055 2033 426 0.56 0.8 4.48 37
R2054 2032 2033 30 0.64 3.84 36
R2053 2031 2032 1.106 2 22.12 35
R2052 2031 2028 1.36 0.8 10.88 37
R2051 2030 422 0.56 0.8 4.48 37
R2050 2029 2030 30 0.64 3.84 36
R2049 2028 2029 1.106 2 22.12 35
R2048 2028 2025 6.16 0.8 49.28 37
R2047 2027 418 0.56 0.8 4.48 37
R2046 2026 2027 30 0.64 3.84 36
R2045 2025 2026 1.106 2 22.12 35
R2044 2025 2022 1.36 0.8 10.88 37
R2043 2024 414 0.56 0.8 4.48 37
R2042 2023 2024 30 0.64 3.84 36
R2041 2022 2023 1.106 2 22.12 35
R2040 2022 2019 6.16 0.8 49.28 37
R2039 2021 410 0.56 0.8 4.48 37
R2038 2020 2021 30 0.64 3.84 36
R2037 2019 2020 1.106 2 22.12 35
R2036 2019 2016 1.36 0.8 10.88 37
R2035 2018 406 0.56 0.8 4.48 37
R2034 2017 2018 30 0.64 3.84 36
R2033 2016 2017 1.106 2 22.12 35
R2032 2016 2013 6.16 0.8 49.28 37
R2031 2015 402 0.56 0.8 4.48 37
R2030 2014 2015 30 0.64 3.84 36
R2029 2013 2014 1.106 2 22.12 35
R2028 2013 2010 1.36 0.8 10.88 37
R2027 2012 398 0.56 0.8 4.48 37
R2026 2011 2012 30 0.64 3.84 36
R2025 2010 2011 1.106 2 22.12 35
R2024 2010 2007 6.16 0.8 49.28 37
R2023 2009 394 0.56 0.8 4.48 37
R2022 2008 2009 30 0.64 3.84 36
R2021 2007 2008 1.106 2 22.12 35
R2020 2007 2004 1.36 0.8 10.88 37
R2019 2006 390 0.56 0.8 4.48 37
R2018 2005 2006 30 0.64 3.84 36
R2017 2004 2005 1.106 2 22.12 35
R2016 2004 2001 6.16 0.8 49.28 37
R2015 2003 386 0.56 0.8 4.48 37
R2014 2002 2003 30 0.64 3.84 36
R2013 2001 2002 1.106 2 22.12 35
R2012 2001 1998 1.36 0.8 10.88 37
R2011 2000 382 0.56 0.8 4.48 37
R2010 1999 2000 30 0.64 3.84 36
R2009 1998 1999 1.106 2 22.12 35
R2008 1998 1995 6.16 0.8 49.28 37
R2007 1997 378 0.56 0.8 4.48 37
R2006 1996 1997 30 0.64 3.84 36
R2005 1995 1996 1.106 2 22.12 35
R2004 1995 1992 1.36 0.8 10.88 37
R2003 1994 374 0.56 0.8 4.48 37
R2002 1993 1994 30 0.64 3.84 36
R2001 1992 1993 1.106 2 22.12 35
R2000 1991 89 0.432 2 8.64 35
R1999 1990 1991 17.5 1.92 6.72 36
R1998 1988 1990 0.174118 6.8 11.84 37
R1997 1988 1989 0.432 2 8.64 35
R1996 1987 296 0.432 2 8.64 35
R1995 1986 1987 17.5 1.92 6.72 36
R1994 1984 1986 0.463529 6.8 31.52 37
R1993 1984 1985 0.432 2 8.64 35
R1992 1983 89 0.432 2 8.64 35
R1991 1982 1983 17.5 1.92 6.72 36
R1990 1980 1982 0.174118 6.8 11.84 37
R1989 1980 1981 0.432 2 8.64 35
R1988 1979 91 0.432 2 8.64 35
R1987 1978 1979 17.5 1.92 6.72 36
R1986 1976 1978 0.174118 6.8 11.84 37
R1985 1976 1977 0.432 2 8.64 35
R1984 1975 91 0.432 2 8.64 35
R1983 1974 1975 17.5 1.92 6.72 36
R1982 1972 1974 0.174118 6.8 11.84 37
R1981 1972 1973 0.432 2 8.64 35
R1980 1971 92 0.432 2 8.64 35
R1979 1970 1971 17.5 1.92 6.72 36
R1978 1968 1970 0.174118 6.8 11.84 37
R1977 1968 1969 0.432 2 8.64 35
R1976 1967 92 0.432 2 8.64 35
R1975 1966 1967 17.5 1.92 6.72 36
R1974 1964 1966 0.174118 6.8 11.84 37
R1973 1964 1965 0.432 2 8.64 35
R1972 1963 93 0.432 2 8.64 35
R1971 1962 1963 17.5 1.92 6.72 36
R1970 1960 1962 0.174118 6.8 11.84 37
R1969 1960 1961 0.432 2 8.64 35
R1968 1959 93 0.432 2 8.64 35
R1967 1958 1959 17.5 1.92 6.72 36
R1966 1956 1958 0.174118 6.8 11.84 37
R1965 1956 1957 0.432 2 8.64 35
R1964 1955 94 0.432 2 8.64 35
R1963 1954 1955 17.5 1.92 6.72 36
R1962 1952 1954 0.174118 6.8 11.84 37
R1961 1952 1953 0.432 2 8.64 35
R1960 1951 94 0.432 2 8.64 35
R1959 1950 1951 17.5 1.92 6.72 36
R1958 1948 1950 0.174118 6.8 11.84 37
R1957 1948 1949 0.432 2 8.64 35
R1956 1947 95 0.432 2 8.64 35
R1955 1946 1947 17.5 1.92 6.72 36
R1954 1944 1946 0.174118 6.8 11.84 37
R1953 1944 1945 0.432 2 8.64 35
R1952 1943 95 0.432 2 8.64 35
R1951 1942 1943 17.5 1.92 6.72 36
R1950 1940 1942 0.174118 6.8 11.84 37
R1949 1940 1941 0.432 2 8.64 35
R1948 1939 96 0.432 2 8.64 35
R1947 1938 1939 17.5 1.92 6.72 36
R1946 1936 1938 0.174118 6.8 11.84 37
R1945 1936 1937 0.432 2 8.64 35
R1944 1935 96 0.432 2 8.64 35
R1943 1934 1935 17.5 1.92 6.72 36
R1942 1932 1934 0.174118 6.8 11.84 37
R1941 1932 1933 0.432 2 8.64 35
R1940 1931 97 0.432 2 8.64 35
R1939 1930 1931 17.5 1.92 6.72 36
R1938 1928 1930 0.174118 6.8 11.84 37
R1937 1928 1929 0.432 2 8.64 35
R1936 1927 97 0.432 2 8.64 35
R1935 1926 1927 17.5 1.92 6.72 36
R1934 1924 1926 0.174118 6.8 11.84 37
R1933 1924 1925 0.432 2 8.64 35
R1932 1923 98 0.432 2 8.64 35
R1931 1922 1923 17.5 1.92 6.72 36
R1930 1920 1922 0.174118 6.8 11.84 37
R1929 1920 1921 0.432 2 8.64 35
R1928 1919 98 0.432 2 8.64 35
R1927 1918 1919 17.5 1.92 6.72 36
R1926 1917 1918 0.174118 6.8 11.84 37
R1925 1917 87 0.526 2 10.52 35
R1924 1916 99 0.432 2 8.64 35
R1923 1915 1916 17.5 1.92 6.72 36
R1922 1913 1915 0.174118 6.8 11.84 37
R1921 1913 1914 0.432 2 8.64 35
R1920 1912 99 0.432 2 8.64 35
R1919 1911 1912 17.5 1.92 6.72 36
R1918 1909 1911 0.174118 6.8 11.84 37
R1917 1909 1910 0.432 2 8.64 35
R1916 1908 100 0.432 2 8.64 35
R1915 1907 1908 17.5 1.92 6.72 36
R1914 1905 1907 0.174118 6.8 11.84 37
R1913 1905 1906 0.432 2 8.64 35
R1912 1904 100 0.432 2 8.64 35
R1911 1903 1904 17.5 1.92 6.72 36
R1910 1901 1903 0.174118 6.8 11.84 37
R1909 1901 1902 0.432 2 8.64 35
R1908 1900 101 0.432 2 8.64 35
R1907 1899 1900 17.5 1.92 6.72 36
R1906 1897 1899 0.174118 6.8 11.84 37
R1905 1897 1898 0.432 2 8.64 35
R1904 1896 101 0.432 2 8.64 35
R1903 1895 1896 17.5 1.92 6.72 36
R1902 1893 1895 0.174118 6.8 11.84 37
R1901 1893 1894 0.432 2 8.64 35
R1900 1892 102 0.432 2 8.64 35
R1899 1891 1892 17.5 1.92 6.72 36
R1898 1889 1891 0.174118 6.8 11.84 37
R1897 1889 1890 0.432 2 8.64 35
R1896 1888 102 0.432 2 8.64 35
R1895 1887 1888 17.5 1.92 6.72 36
R1894 1885 1887 0.174118 6.8 11.84 37
R1893 1885 1886 0.432 2 8.64 35
R1892 1884 103 0.432 2 8.64 35
R1891 1883 1884 17.5 1.92 6.72 36
R1890 1881 1883 0.174118 6.8 11.84 37
R1889 1881 1882 0.432 2 8.64 35
R1888 1880 103 0.432 2 8.64 35
R1887 1879 1880 17.5 1.92 6.72 36
R1886 1877 1879 0.174118 6.8 11.84 37
R1885 1877 1878 0.432 2 8.64 35
R1884 1876 104 0.432 2 8.64 35
R1883 1875 1876 17.5 1.92 6.72 36
R1882 1873 1875 0.174118 6.8 11.84 37
R1881 1873 1874 0.432 2 8.64 35
R1880 1872 104 0.432 2 8.64 35
R1879 1871 1872 17.5 1.92 6.72 36
R1878 1869 1871 0.174118 6.8 11.84 37
R1877 1869 1870 0.432 2 8.64 35
R1876 1868 105 0.432 2 8.64 35
R1875 1867 1868 17.5 1.92 6.72 36
R1874 1865 1867 0.174118 6.8 11.84 37
R1873 1865 1866 0.432 2 8.64 35
R1872 1864 105 0.432 2 8.64 35
R1871 1863 1864 17.5 1.92 6.72 36
R1870 1861 1863 0.174118 6.8 11.84 37
R1869 1861 1862 0.432 2 8.64 35
R1868 1860 106 0.432 2 8.64 35
R1867 1859 1860 17.5 1.92 6.72 36
R1866 1857 1859 0.174118 6.8 11.84 37
R1865 1857 1858 0.432 2 8.64 35
R1864 1856 106 0.432 2 8.64 35
R1863 1855 1856 17.5 1.92 6.72 36
R1862 1853 1855 0.174118 6.8 11.84 37
R1861 1853 1854 0.432 2 8.64 35
R1860 1852 107 0.432 2 8.64 35
R1859 1851 1852 17.5 1.92 6.72 36
R1858 1849 1851 0.174118 6.8 11.84 37
R1857 1849 1850 0.432 2 8.64 35
R1856 1848 107 0.432 2 8.64 35
R1855 1847 1848 17.5 1.92 6.72 36
R1854 1845 1847 0.174118 6.8 11.84 37
R1853 1845 1846 0.432 2 8.64 35
R1852 1844 108 0.432 2 8.64 35
R1851 1843 1844 17.5 1.92 6.72 36
R1850 1841 1843 0.174118 6.8 11.84 37
R1849 1841 1842 0.432 2 8.64 35
R1848 1840 108 0.432 2 8.64 35
R1847 1839 1840 17.5 1.92 6.72 36
R1846 1837 1839 0.174118 6.8 11.84 37
R1845 1837 1838 0.432 2 8.64 35
R1844 1836 109 0.432 2 8.64 35
R1843 1835 1836 17.5 1.92 6.72 36
R1842 1833 1835 0.174118 6.8 11.84 37
R1841 1833 1834 0.432 2 8.64 35
R1840 1832 109 0.432 2 8.64 35
R1839 1831 1832 17.5 1.92 6.72 36
R1838 1829 1831 0.174118 6.8 11.84 37
R1837 1829 1830 0.432 2 8.64 35
R1836 1828 110 0.432 2 8.64 35
R1835 1827 1828 17.5 1.92 6.72 36
R1834 1825 1827 0.174118 6.8 11.84 37
R1833 1825 1826 0.432 2 8.64 35
R1832 1824 110 0.432 2 8.64 35
R1831 1823 1824 17.5 1.92 6.72 36
R1830 1821 1823 0.174118 6.8 11.84 37
R1829 1821 1822 0.432 2 8.64 35
R1828 1820 111 0.432 2 8.64 35
R1827 1819 1820 17.5 1.92 6.72 36
R1826 1817 1819 0.174118 6.8 11.84 37
R1825 1817 1818 0.432 2 8.64 35
R1824 1816 111 0.432 2 8.64 35
R1823 1815 1816 17.5 1.92 6.72 36
R1822 1813 1815 0.174118 6.8 11.84 37
R1821 1813 1814 0.432 2 8.64 35
R1820 1812 112 0.432 2 8.64 35
R1819 1811 1812 17.5 1.92 6.72 36
R1818 1809 1811 0.174118 6.8 11.84 37
R1817 1809 1810 0.432 2 8.64 35
R1816 1808 112 0.432 2 8.64 35
R1815 1807 1808 17.5 1.92 6.72 36
R1814 1805 1807 0.174118 6.8 11.84 37
R1813 1805 1806 0.432 2 8.64 35
R1812 1804 113 0.432 2 8.64 35
R1811 1803 1804 17.5 1.92 6.72 36
R1810 1801 1803 0.174118 6.8 11.84 37
R1809 1801 1802 0.432 2 8.64 35
R1808 1800 113 0.432 2 8.64 35
R1807 1799 1800 17.5 1.92 6.72 36
R1806 1797 1799 0.174118 6.8 11.84 37
R1805 1797 1798 0.432 2 8.64 35
R1804 1796 114 0.432 2 8.64 35
R1803 1795 1796 17.5 1.92 6.72 36
R1802 1793 1795 0.174118 6.8 11.84 37
R1801 1793 1794 0.432 2 8.64 35
R1800 1792 114 0.432 2 8.64 35
R1799 1791 1792 17.5 1.92 6.72 36
R1798 1789 1791 0.174118 6.8 11.84 37
R1797 1789 1790 0.432 2 8.64 35
R1796 1788 115 0.432 2 8.64 35
R1795 1787 1788 17.5 1.92 6.72 36
R1794 1785 1787 0.174118 6.8 11.84 37
R1793 1785 1786 0.432 2 8.64 35
R1792 1784 115 0.432 2 8.64 35
R1791 1783 1784 17.5 1.92 6.72 36
R1790 1781 1783 0.174118 6.8 11.84 37
R1789 1781 1782 0.432 2 8.64 35
R1788 1780 116 0.432 2 8.64 35
R1787 1779 1780 17.5 1.92 6.72 36
R1786 1777 1779 0.174118 6.8 11.84 37
R1785 1777 1778 0.432 2 8.64 35
R1784 1776 116 0.432 2 8.64 35
R1783 1775 1776 17.5 1.92 6.72 36
R1782 1773 1775 0.174118 6.8 11.84 37
R1781 1773 1774 0.432 2 8.64 35
R1780 1772 117 0.432 2 8.64 35
R1779 1771 1772 17.5 1.92 6.72 36
R1778 1769 1771 0.174118 6.8 11.84 37
R1777 1769 1770 0.432 2 8.64 35
R1776 1768 117 0.432 2 8.64 35
R1775 1767 1768 17.5 1.92 6.72 36
R1774 1765 1767 0.174118 6.8 11.84 37
R1773 1765 1766 0.432 2 8.64 35
R1772 1764 118 0.432 2 8.64 35
R1771 1763 1764 17.5 1.92 6.72 36
R1770 1761 1763 0.174118 6.8 11.84 37
R1769 1761 1762 0.432 2 8.64 35
R1768 1760 118 0.432 2 8.64 35
R1767 1759 1760 17.5 1.92 6.72 36
R1766 1757 1759 0.174118 6.8 11.84 37
R1765 1757 1758 0.432 2 8.64 35
R1764 1756 119 0.432 2 8.64 35
R1763 1755 1756 17.5 1.92 6.72 36
R1762 1753 1755 0.174118 6.8 11.84 37
R1761 1753 1754 0.432 2 8.64 35
R1760 1752 119 0.432 2 8.64 35
R1759 1751 1752 17.5 1.92 6.72 36
R1758 1749 1751 0.174118 6.8 11.84 37
R1757 1749 1750 0.432 2 8.64 35
R1756 1748 120 0.432 2 8.64 35
R1755 1747 1748 17.5 1.92 6.72 36
R1754 1745 1747 0.174118 6.8 11.84 37
R1753 1745 1746 0.432 2 8.64 35
R1752 1744 120 0.432 2 8.64 35
R1751 1743 1744 17.5 1.92 6.72 36
R1750 1741 1743 0.174118 6.8 11.84 37
R1749 1741 1742 0.432 2 8.64 35
R1748 1740 121 0.432 2 8.64 35
R1747 1739 1740 17.5 1.92 6.72 36
R1746 1737 1739 0.174118 6.8 11.84 37
R1745 1737 1738 0.432 2 8.64 35
R1744 1736 121 0.432 2 8.64 35
R1743 1735 1736 17.5 1.92 6.72 36
R1742 1733 1735 0.174118 6.8 11.84 37
R1741 1733 1734 0.432 2 8.64 35
R1740 1732 122 0.432 2 8.64 35
R1739 1731 1732 17.5 1.92 6.72 36
R1738 1729 1731 0.174118 6.8 11.84 37
R1737 1729 1730 0.432 2 8.64 35
R1736 1728 122 0.432 2 8.64 35
R1735 1727 1728 17.5 1.92 6.72 36
R1734 1725 1727 0.174118 6.8 11.84 37
R1733 1725 1726 0.432 2 8.64 35
R1732 1724 123 0.432 2 8.64 35
R1731 1723 1724 17.5 1.92 6.72 36
R1730 1721 1723 0.174118 6.8 11.84 37
R1729 1721 1722 0.432 2 8.64 35
R1728 1720 123 0.432 2 8.64 35
R1727 1719 1720 17.5 1.92 6.72 36
R1726 1718 1719 0.174118 6.8 11.84 37
R1725 1718 85 0.526 2 10.52 35
R1724 1717 124 0.432 2 8.64 35
R1723 1716 1717 17.5 1.92 6.72 36
R1722 1714 1716 0.174118 6.8 11.84 37
R1721 1714 1715 0.432 2 8.64 35
R1720 1713 124 0.432 2 8.64 35
R1719 1712 1713 17.5 1.92 6.72 36
R1718 1710 1712 0.174118 6.8 11.84 37
R1717 1710 1711 0.432 2 8.64 35
R1716 1709 125 0.432 2 8.64 35
R1715 1708 1709 17.5 1.92 6.72 36
R1714 1706 1708 0.174118 6.8 11.84 37
R1713 1706 1707 0.432 2 8.64 35
R1712 1705 125 0.432 2 8.64 35
R1711 1704 1705 17.5 1.92 6.72 36
R1710 1702 1704 0.174118 6.8 11.84 37
R1709 1702 1703 0.432 2 8.64 35
R1708 1701 126 0.432 2 8.64 35
R1707 1700 1701 17.5 1.92 6.72 36
R1706 1698 1700 0.174118 6.8 11.84 37
R1705 1698 1699 0.432 2 8.64 35
R1704 1697 126 0.432 2 8.64 35
R1703 1696 1697 17.5 1.92 6.72 36
R1702 1694 1696 0.174118 6.8 11.84 37
R1701 1694 1695 0.432 2 8.64 35
R1700 1693 127 0.432 2 8.64 35
R1699 1692 1693 17.5 1.92 6.72 36
R1698 1690 1692 0.174118 6.8 11.84 37
R1697 1690 1691 0.432 2 8.64 35
R1696 1689 127 0.432 2 8.64 35
R1695 1688 1689 17.5 1.92 6.72 36
R1694 1686 1688 0.174118 6.8 11.84 37
R1693 1686 1687 0.432 2 8.64 35
R1692 1685 128 0.432 2 8.64 35
R1691 1684 1685 17.5 1.92 6.72 36
R1690 1682 1684 0.174118 6.8 11.84 37
R1689 1682 1683 0.432 2 8.64 35
R1688 1681 128 0.432 2 8.64 35
R1687 1680 1681 17.5 1.92 6.72 36
R1686 1678 1680 0.174118 6.8 11.84 37
R1685 1678 1679 0.432 2 8.64 35
R1684 1677 129 0.432 2 8.64 35
R1683 1676 1677 17.5 1.92 6.72 36
R1682 1674 1676 0.174118 6.8 11.84 37
R1681 1674 1675 0.432 2 8.64 35
R1680 1673 129 0.432 2 8.64 35
R1679 1672 1673 17.5 1.92 6.72 36
R1678 1670 1672 0.174118 6.8 11.84 37
R1677 1670 1671 0.432 2 8.64 35
R1676 1669 130 0.432 2 8.64 35
R1675 1668 1669 17.5 1.92 6.72 36
R1674 1666 1668 0.174118 6.8 11.84 37
R1673 1666 1667 0.432 2 8.64 35
R1672 1665 130 0.432 2 8.64 35
R1671 1664 1665 17.5 1.92 6.72 36
R1670 1662 1664 0.174118 6.8 11.84 37
R1669 1662 1663 0.432 2 8.64 35
R1668 1661 131 0.432 2 8.64 35
R1667 1660 1661 17.5 1.92 6.72 36
R1666 1658 1660 0.174118 6.8 11.84 37
R1665 1658 1659 0.432 2 8.64 35
R1664 1657 131 0.432 2 8.64 35
R1663 1656 1657 17.5 1.92 6.72 36
R1662 1654 1656 0.174118 6.8 11.84 37
R1661 1654 1655 0.432 2 8.64 35
R1660 1653 132 0.432 2 8.64 35
R1659 1652 1653 17.5 1.92 6.72 36
R1658 1650 1652 0.174118 6.8 11.84 37
R1657 1650 1651 0.432 2 8.64 35
R1656 1649 132 0.432 2 8.64 35
R1655 1648 1649 17.5 1.92 6.72 36
R1654 1646 1648 0.174118 6.8 11.84 37
R1653 1646 1647 0.432 2 8.64 35
R1652 1645 133 0.432 2 8.64 35
R1651 1644 1645 17.5 1.92 6.72 36
R1650 1642 1644 0.174118 6.8 11.84 37
R1649 1642 1643 0.432 2 8.64 35
R1648 1641 133 0.432 2 8.64 35
R1647 1640 1641 17.5 1.92 6.72 36
R1646 1638 1640 0.174118 6.8 11.84 37
R1645 1638 1639 0.432 2 8.64 35
R1644 1637 134 0.432 2 8.64 35
R1643 1636 1637 17.5 1.92 6.72 36
R1642 1634 1636 0.232941 6.8 15.84 37
R1641 1634 1635 0.432 2 8.64 35
R1640 1633 134 0.432 2 8.64 35
R1639 1632 1633 17.5 1.92 6.72 36
R1638 1630 1632 0.232941 6.8 15.84 37
R1637 1630 1631 0.432 2 8.64 35
R1636 1629 135 0.432 2 8.64 35
R1635 1628 1629 17.5 1.92 6.72 36
R1634 1626 1628 0.174118 6.8 11.84 37
R1633 1626 1627 0.432 2 8.64 35
R1632 1625 135 0.432 2 8.64 35
R1631 1624 1625 17.5 1.92 6.72 36
R1630 1622 1624 0.174118 6.8 11.84 37
R1629 1622 1623 0.432 2 8.64 35
R1628 1621 136 0.432 2 8.64 35
R1627 1620 1621 17.5 1.92 6.72 36
R1626 1618 1620 0.174118 6.8 11.84 37
R1625 1618 1619 0.432 2 8.64 35
R1624 1617 136 0.432 2 8.64 35
R1623 1616 1617 17.5 1.92 6.72 36
R1622 1614 1616 0.174118 6.8 11.84 37
R1621 1614 1615 0.432 2 8.64 35
R1620 1613 137 0.432 2 8.64 35
R1619 1612 1613 17.5 1.92 6.72 36
R1618 1610 1612 0.174118 6.8 11.84 37
R1617 1610 1611 0.432 2 8.64 35
R1616 1609 137 0.432 2 8.64 35
R1615 1608 1609 17.5 1.92 6.72 36
R1614 1606 1608 0.174118 6.8 11.84 37
R1613 1606 1607 0.432 2 8.64 35
R1612 1605 138 0.432 2 8.64 35
R1611 1604 1605 17.5 1.92 6.72 36
R1610 1602 1604 0.174118 6.8 11.84 37
R1609 1602 1603 0.432 2 8.64 35
R1608 1601 138 0.432 2 8.64 35
R1607 1600 1601 17.5 1.92 6.72 36
R1606 1598 1600 0.174118 6.8 11.84 37
R1605 1598 1599 0.432 2 8.64 35
R1604 1597 139 0.432 2 8.64 35
R1603 1596 1597 17.5 1.92 6.72 36
R1602 1594 1596 0.174118 6.8 11.84 37
R1601 1594 1595 0.432 2 8.64 35
R1600 1593 139 0.432 2 8.64 35
R1599 1592 1593 17.5 1.92 6.72 36
R1598 1590 1592 0.174118 6.8 11.84 37
R1597 1590 1591 0.432 2 8.64 35
R1596 1589 140 0.432 2 8.64 35
R1595 1588 1589 17.5 1.92 6.72 36
R1594 1587 1588 0.174118 6.8 11.84 37
R1593 1587 83 0.526 2 10.52 35
R1592 1586 140 0.432 2 8.64 35
R1591 1585 1586 17.5 1.92 6.72 36
R1590 1583 1585 0.174118 6.8 11.84 37
R1589 1583 1584 0.432 2 8.64 35
R1588 1582 141 0.432 2 8.64 35
R1587 1581 1582 17.5 1.92 6.72 36
R1586 1579 1581 0.174118 6.8 11.84 37
R1585 1579 1580 0.432 2 8.64 35
R1584 1578 141 0.432 2 8.64 35
R1583 1577 1578 17.5 1.92 6.72 36
R1582 1576 1577 0.174118 6.8 11.84 37
R1581 1576 63 0.586 2 11.72 35
R1580 1575 142 0.432 2 8.64 35
R1579 1574 1575 17.5 1.92 6.72 36
R1578 1572 1574 0.174118 6.8 11.84 37
R1577 1572 1573 0.432 2 8.64 35
R1576 1571 142 0.432 2 8.64 35
R1575 1570 1571 17.5 1.92 6.72 36
R1574 1568 1570 0.174118 6.8 11.84 37
R1573 1568 1569 0.432 2 8.64 35
R1572 1567 143 0.432 2 8.64 35
R1571 1566 1567 17.5 1.92 6.72 36
R1570 1564 1566 0.174118 6.8 11.84 37
R1569 1564 1565 0.432 2 8.64 35
R1568 1563 143 0.432 2 8.64 35
R1567 1562 1563 17.5 1.92 6.72 36
R1566 1560 1562 0.174118 6.8 11.84 37
R1565 1560 1561 0.432 2 8.64 35
R1564 1559 144 0.432 2 8.64 35
R1563 1558 1559 17.5 1.92 6.72 36
R1562 1556 1558 0.174118 6.8 11.84 37
R1561 1556 1557 0.432 2 8.64 35
R1560 1555 144 0.432 2 8.64 35
R1559 1554 1555 17.5 1.92 6.72 36
R1558 1552 1554 0.174118 6.8 11.84 37
R1557 1552 1553 0.432 2 8.64 35
R1556 1551 145 0.432 2 8.64 35
R1555 1550 1551 17.5 1.92 6.72 36
R1554 1548 1550 0.256471 6.8 17.44 37
R1553 1548 1549 0.432 2 8.64 35
R1552 1547 145 0.432 2 8.64 35
R1551 1546 1547 17.5 1.92 6.72 36
R1550 1544 1546 0.256471 6.8 17.44 37
R1549 1544 1545 0.432 2 8.64 35
R1548 1543 146 0.432 2 8.64 35
R1547 1542 1543 17.5 1.92 6.72 36
R1546 1540 1542 0.174118 6.8 11.84 37
R1545 1540 1541 0.432 2 8.64 35
R1544 1539 146 0.432 2 8.64 35
R1543 1538 1539 17.5 1.92 6.72 36
R1542 1536 1538 0.174118 6.8 11.84 37
R1541 1536 1537 0.432 2 8.64 35
R1540 1535 147 0.432 2 8.64 35
R1539 1534 1535 17.5 1.92 6.72 36
R1538 1532 1534 0.174118 6.8 11.84 37
R1537 1532 1533 0.432 2 8.64 35
R1536 1531 147 0.432 2 8.64 35
R1535 1530 1531 17.5 1.92 6.72 36
R1534 1528 1530 0.174118 6.8 11.84 37
R1533 1528 1529 0.432 2 8.64 35
R1532 1527 148 0.432 2 8.64 35
R1531 1526 1527 17.5 1.92 6.72 36
R1530 1524 1526 0.174118 6.8 11.84 37
R1529 1524 1525 0.432 2 8.64 35
R1528 1523 148 0.432 2 8.64 35
R1527 1522 1523 17.5 1.92 6.72 36
R1526 1520 1522 0.174118 6.8 11.84 37
R1525 1520 1521 0.432 2 8.64 35
R1524 1519 149 0.432 2 8.64 35
R1523 1518 1519 17.5 1.92 6.72 36
R1522 1516 1518 0.174118 6.8 11.84 37
R1521 1516 1517 0.432 2 8.64 35
R1520 1515 149 0.432 2 8.64 35
R1519 1514 1515 17.5 1.92 6.72 36
R1518 1512 1514 0.174118 6.8 11.84 37
R1517 1512 1513 0.432 2 8.64 35
R1516 1511 150 0.432 2 8.64 35
R1515 1510 1511 17.5 1.92 6.72 36
R1514 1508 1510 0.174118 6.8 11.84 37
R1513 1508 1509 0.432 2 8.64 35
R1512 1507 150 0.432 2 8.64 35
R1511 1506 1507 17.5 1.92 6.72 36
R1510 1504 1506 0.174118 6.8 11.84 37
R1509 1504 1505 0.432 2 8.64 35
R1508 1503 151 0.432 2 8.64 35
R1507 1502 1503 17.5 1.92 6.72 36
R1506 1500 1502 0.174118 6.8 11.84 37
R1505 1500 1501 0.432 2 8.64 35
R1504 1499 151 0.432 2 8.64 35
R1503 1498 1499 17.5 1.92 6.72 36
R1502 1497 1498 0.174118 6.8 11.84 37
R1501 1497 81 0.526 2 10.52 35
R1500 1496 152 0.432 2 8.64 35
R1499 1495 1496 17.5 1.92 6.72 36
R1498 1493 1495 0.174118 6.8 11.84 37
R1497 1493 1494 0.432 2 8.64 35
R1496 1492 152 0.432 2 8.64 35
R1495 1491 1492 17.5 1.92 6.72 36
R1494 1489 1491 0.174118 6.8 11.84 37
R1493 1489 1490 0.432 2 8.64 35
R1492 1488 153 0.432 2 8.64 35
R1491 1487 1488 17.5 1.92 6.72 36
R1490 1485 1487 0.174118 6.8 11.84 37
R1489 1485 1486 0.432 2 8.64 35
R1488 1484 153 0.432 2 8.64 35
R1487 1483 1484 17.5 1.92 6.72 36
R1486 1481 1483 0.174118 6.8 11.84 37
R1485 1481 1482 0.432 2 8.64 35
R1484 1480 154 0.432 2 8.64 35
R1483 1479 1480 17.5 1.92 6.72 36
R1482 1477 1479 0.174118 6.8 11.84 37
R1481 1477 1478 0.432 2 8.64 35
R1480 1476 154 0.432 2 8.64 35
R1479 1475 1476 17.5 1.92 6.72 36
R1478 1473 1475 0.174118 6.8 11.84 37
R1477 1473 1474 0.432 2 8.64 35
R1476 1472 155 0.432 2 8.64 35
R1475 1471 1472 17.5 1.92 6.72 36
R1474 1469 1471 0.174118 6.8 11.84 37
R1473 1469 1470 0.432 2 8.64 35
R1472 1468 155 0.432 2 8.64 35
R1471 1467 1468 17.5 1.92 6.72 36
R1470 1465 1467 0.174118 6.8 11.84 37
R1469 1465 1466 0.432 2 8.64 35
R1468 1464 156 0.432 2 8.64 35
R1467 1463 1464 17.5 1.92 6.72 36
R1466 1461 1463 0.174118 6.8 11.84 37
R1465 1461 1462 0.432 2 8.64 35
R1464 1460 156 0.432 2 8.64 35
R1463 1459 1460 17.5 1.92 6.72 36
R1462 1457 1459 0.174118 6.8 11.84 37
R1461 1457 1458 0.432 2 8.64 35
R1460 1456 157 0.432 2 8.64 35
R1459 1455 1456 17.5 1.92 6.72 36
R1458 1453 1455 0.244706 6.8 16.64 37
R1457 1453 1454 0.432 2 8.64 35
R1456 1452 157 0.432 2 8.64 35
R1455 1451 1452 17.5 1.92 6.72 36
R1454 1449 1451 0.244706 6.8 16.64 37
R1453 1449 1450 0.432 2 8.64 35
R1452 1448 158 0.432 2 8.64 35
R1451 1447 1448 17.5 1.92 6.72 36
R1450 1445 1447 0.174118 6.8 11.84 37
R1449 1445 1446 0.432 2 8.64 35
R1448 1444 158 0.432 2 8.64 35
R1447 1443 1444 17.5 1.92 6.72 36
R1446 1441 1443 0.174118 6.8 11.84 37
R1445 1441 1442 0.432 2 8.64 35
R1444 1440 159 0.432 2 8.64 35
R1443 1439 1440 17.5 1.92 6.72 36
R1442 1437 1439 0.174118 6.8 11.84 37
R1441 1437 1438 0.432 2 8.64 35
R1440 1436 159 0.432 2 8.64 35
R1439 1435 1436 17.5 1.92 6.72 36
R1438 1433 1435 0.174118 6.8 11.84 37
R1437 1433 1434 0.432 2 8.64 35
R1436 1432 160 0.432 2 8.64 35
R1435 1431 1432 17.5 1.92 6.72 36
R1434 1429 1431 0.174118 6.8 11.84 37
R1433 1429 1430 0.432 2 8.64 35
R1432 1428 160 0.432 2 8.64 35
R1431 1427 1428 17.5 1.92 6.72 36
R1430 1425 1427 0.174118 6.8 11.84 37
R1429 1425 1426 0.432 2 8.64 35
R1428 1424 161 0.432 2 8.64 35
R1427 1423 1424 17.5 1.92 6.72 36
R1426 1421 1423 0.174118 6.8 11.84 37
R1425 1421 1422 0.432 2 8.64 35
R1424 1420 161 0.432 2 8.64 35
R1423 1419 1420 17.5 1.92 6.72 36
R1422 1417 1419 0.174118 6.8 11.84 37
R1421 1417 1418 0.432 2 8.64 35
R1420 1416 162 0.432 2 8.64 35
R1419 1415 1416 17.5 1.92 6.72 36
R1418 1413 1415 0.174118 6.8 11.84 37
R1417 1413 1414 0.432 2 8.64 35
R1416 1412 162 0.432 2 8.64 35
R1415 1411 1412 17.5 1.92 6.72 36
R1414 1409 1411 0.174118 6.8 11.84 37
R1413 1409 1410 0.432 2 8.64 35
R1412 1408 163 0.432 2 8.64 35
R1411 1407 1408 17.5 1.92 6.72 36
R1410 1405 1407 0.174118 6.8 11.84 37
R1409 1405 1406 0.432 2 8.64 35
R1408 1404 163 0.432 2 8.64 35
R1407 1403 1404 17.5 1.92 6.72 36
R1406 1401 1403 0.174118 6.8 11.84 37
R1405 1401 1402 0.432 2 8.64 35
R1404 1400 164 0.432 2 8.64 35
R1403 1399 1400 17.5 1.92 6.72 36
R1402 1397 1399 0.174118 6.8 11.84 37
R1401 1397 1398 0.432 2 8.64 35
R1400 1396 164 0.432 2 8.64 35
R1399 1395 1396 17.5 1.92 6.72 36
R1398 1393 1395 0.174118 6.8 11.84 37
R1397 1393 1394 0.432 2 8.64 35
R1396 1392 165 0.432 2 8.64 35
R1395 1391 1392 17.5 1.92 6.72 36
R1394 1389 1391 0.174118 6.8 11.84 37
R1393 1389 1390 0.432 2 8.64 35
R1392 1388 165 0.432 2 8.64 35
R1391 1387 1388 17.5 1.92 6.72 36
R1390 1385 1387 0.174118 6.8 11.84 37
R1389 1385 1386 0.432 2 8.64 35
R1388 1384 166 0.432 2 8.64 35
R1387 1383 1384 17.5 1.92 6.72 36
R1386 1381 1383 0.174118 6.8 11.84 37
R1385 1381 1382 0.432 2 8.64 35
R1384 1380 166 0.432 2 8.64 35
R1383 1379 1380 17.5 1.92 6.72 36
R1382 1377 1379 0.174118 6.8 11.84 37
R1381 1377 1378 0.432 2 8.64 35
R1380 1376 167 0.432 2 8.64 35
R1379 1375 1376 17.5 1.92 6.72 36
R1378 1373 1375 0.174118 6.8 11.84 37
R1377 1373 1374 0.432 2 8.64 35
R1376 1372 167 0.432 2 8.64 35
R1375 1371 1372 17.5 1.92 6.72 36
R1374 1370 1371 0.174118 6.8 11.84 37
R1373 1370 79 0.526 2 10.52 35
R1372 1369 168 0.432 2 8.64 35
R1371 1368 1369 17.5 1.92 6.72 36
R1370 1366 1368 0.174118 6.8 11.84 37
R1369 1366 1367 0.432 2 8.64 35
R1368 1365 168 0.432 2 8.64 35
R1367 1364 1365 17.5 1.92 6.72 36
R1366 1362 1364 0.174118 6.8 11.84 37
R1365 1362 1363 0.432 2 8.64 35
R1364 1361 169 0.432 2 8.64 35
R1363 1360 1361 17.5 1.92 6.72 36
R1362 1358 1360 0.174118 6.8 11.84 37
R1361 1358 1359 0.432 2 8.64 35
R1360 1357 169 0.432 2 8.64 35
R1359 1356 1357 17.5 1.92 6.72 36
R1358 1354 1356 0.174118 6.8 11.84 37
R1357 1354 1355 0.432 2 8.64 35
R1356 1353 170 0.432 2 8.64 35
R1355 1352 1353 17.5 1.92 6.72 36
R1354 1350 1352 0.174118 6.8 11.84 37
R1353 1350 1351 0.432 2 8.64 35
R1352 1349 170 0.432 2 8.64 35
R1351 1348 1349 17.5 1.92 6.72 36
R1350 1346 1348 0.174118 6.8 11.84 37
R1349 1346 1347 0.432 2 8.64 35
R1348 1345 171 0.432 2 8.64 35
R1347 1344 1345 17.5 1.92 6.72 36
R1346 1342 1344 0.174118 6.8 11.84 37
R1345 1342 1343 0.432 2 8.64 35
R1344 1341 171 0.432 2 8.64 35
R1343 1340 1341 17.5 1.92 6.72 36
R1342 1338 1340 0.174118 6.8 11.84 37
R1341 1338 1339 0.432 2 8.64 35
R1340 1337 172 0.432 2 8.64 35
R1339 1336 1337 17.5 1.92 6.72 36
R1338 1334 1336 0.174118 6.8 11.84 37
R1337 1334 1335 0.432 2 8.64 35
R1336 1333 172 0.432 2 8.64 35
R1335 1332 1333 17.5 1.92 6.72 36
R1334 1330 1332 0.174118 6.8 11.84 37
R1333 1330 1331 0.432 2 8.64 35
R1332 1329 173 0.432 2 8.64 35
R1331 1328 1329 17.5 1.92 6.72 36
R1330 1326 1328 0.174118 6.8 11.84 37
R1329 1326 1327 0.432 2 8.64 35
R1328 1325 173 0.432 2 8.64 35
R1327 1324 1325 17.5 1.92 6.72 36
R1326 1322 1324 0.174118 6.8 11.84 37
R1325 1322 1323 0.432 2 8.64 35
R1324 1321 174 0.432 2 8.64 35
R1323 1320 1321 17.5 1.92 6.72 36
R1322 1318 1320 0.174118 6.8 11.84 37
R1321 1318 1319 0.432 2 8.64 35
R1320 1317 174 0.432 2 8.64 35
R1319 1316 1317 17.5 1.92 6.72 36
R1318 1314 1316 0.174118 6.8 11.84 37
R1317 1314 1315 0.432 2 8.64 35
R1316 1313 175 0.432 2 8.64 35
R1315 1312 1313 17.5 1.92 6.72 36
R1314 1310 1312 0.174118 6.8 11.84 37
R1313 1310 1311 0.432 2 8.64 35
R1312 1309 175 0.432 2 8.64 35
R1311 1308 1309 17.5 1.92 6.72 36
R1310 1306 1308 0.174118 6.8 11.84 37
R1309 1306 1307 0.432 2 8.64 35
R1308 1305 176 0.432 2 8.64 35
R1307 1304 1305 17.5 1.92 6.72 36
R1306 1302 1304 0.174118 6.8 11.84 37
R1305 1302 1303 0.432 2 8.64 35
R1304 1301 176 0.432 2 8.64 35
R1303 1300 1301 17.5 1.92 6.72 36
R1302 1298 1300 0.174118 6.8 11.84 37
R1301 1298 1299 0.432 2 8.64 35
R1300 1297 177 0.432 2 8.64 35
R1299 1296 1297 17.5 1.92 6.72 36
R1298 1294 1296 0.174118 6.8 11.84 37
R1297 1294 1295 0.432 2 8.64 35
R1296 1293 177 0.432 2 8.64 35
R1295 1292 1293 17.5 1.92 6.72 36
R1294 1290 1292 0.174118 6.8 11.84 37
R1293 1290 1291 0.432 2 8.64 35
R1292 1289 178 0.432 2 8.64 35
R1291 1288 1289 17.5 1.92 6.72 36
R1290 1286 1288 0.174118 6.8 11.84 37
R1289 1286 1287 0.432 2 8.64 35
R1288 1285 178 0.432 2 8.64 35
R1287 1284 1285 17.5 1.92 6.72 36
R1286 1283 1284 0.174118 6.8 11.84 37
R1285 1283 77 0.526 2 10.52 35
R1284 1282 179 0.432 2 8.64 35
R1283 1281 1282 17.5 1.92 6.72 36
R1282 1279 1281 0.174118 6.8 11.84 37
R1281 1279 1280 0.432 2 8.64 35
R1280 1278 179 0.432 2 8.64 35
R1279 1277 1278 17.5 1.92 6.72 36
R1278 1275 1277 0.174118 6.8 11.84 37
R1277 1275 1276 0.432 2 8.64 35
R1276 1274 180 0.432 2 8.64 35
R1275 1273 1274 17.5 1.92 6.72 36
R1274 1271 1273 0.174118 6.8 11.84 37
R1273 1271 1272 0.432 2 8.64 35
R1272 1270 180 0.432 2 8.64 35
R1271 1269 1270 17.5 1.92 6.72 36
R1270 1267 1269 0.174118 6.8 11.84 37
R1269 1267 1268 0.432 2 8.64 35
R1268 1266 181 0.432 2 8.64 35
R1267 1265 1266 17.5 1.92 6.72 36
R1266 1263 1265 0.174118 6.8 11.84 37
R1265 1263 1264 0.432 2 8.64 35
R1264 1262 181 0.432 2 8.64 35
R1263 1261 1262 17.5 1.92 6.72 36
R1262 1259 1261 0.174118 6.8 11.84 37
R1261 1259 1260 0.432 2 8.64 35
R1260 1258 182 0.432 2 8.64 35
R1259 1257 1258 17.5 1.92 6.72 36
R1258 1255 1257 0.174118 6.8 11.84 37
R1257 1255 1256 0.432 2 8.64 35
R1256 1254 182 0.432 2 8.64 35
R1255 1253 1254 17.5 1.92 6.72 36
R1254 1251 1253 0.174118 6.8 11.84 37
R1253 1251 1252 0.432 2 8.64 35
R1252 1250 183 0.432 2 8.64 35
R1251 1249 1250 17.5 1.92 6.72 36
R1250 1247 1249 0.174118 6.8 11.84 37
R1249 1247 1248 0.432 2 8.64 35
R1248 1246 183 0.432 2 8.64 35
R1247 1245 1246 17.5 1.92 6.72 36
R1246 1243 1245 0.174118 6.8 11.84 37
R1245 1243 1244 0.432 2 8.64 35
R1244 1242 184 0.432 2 8.64 35
R1243 1241 1242 17.5 1.92 6.72 36
R1242 1239 1241 0.174118 6.8 11.84 37
R1241 1239 1240 0.432 2 8.64 35
R1240 1238 184 0.432 2 8.64 35
R1239 1237 1238 17.5 1.92 6.72 36
R1238 1235 1237 0.174118 6.8 11.84 37
R1237 1235 1236 0.432 2 8.64 35
R1236 1234 185 0.432 2 8.64 35
R1235 1233 1234 17.5 1.92 6.72 36
R1234 1231 1233 0.174118 6.8 11.84 37
R1233 1231 1232 0.432 2 8.64 35
R1232 1230 185 0.432 2 8.64 35
R1231 1229 1230 17.5 1.92 6.72 36
R1230 1227 1229 0.174118 6.8 11.84 37
R1229 1227 1228 0.432 2 8.64 35
R1228 1226 186 0.432 2 8.64 35
R1227 1225 1226 17.5 1.92 6.72 36
R1226 1224 1225 0.174118 6.8 11.84 37
R1225 1224 46 0.712 2 14.24 35
R1224 1223 186 0.432 2 8.64 35
R1223 1222 1223 17.5 1.92 6.72 36
R1222 1220 1222 0.174118 6.8 11.84 37
R1221 1220 1221 0.432 2 8.64 35
R1220 1219 187 0.432 2 8.64 35
R1219 1218 1219 17.5 1.92 6.72 36
R1218 1216 1218 0.174118 6.8 11.84 37
R1217 1216 1217 0.432 2 8.64 35
R1216 1215 187 0.432 2 8.64 35
R1215 1214 1215 17.5 1.92 6.72 36
R1214 1212 1214 0.174118 6.8 11.84 37
R1213 1212 1213 0.432 2 8.64 35
R1212 1211 188 0.432 2 8.64 35
R1211 1210 1211 17.5 1.92 6.72 36
R1210 1208 1210 0.174118 6.8 11.84 37
R1209 1208 1209 0.432 2 8.64 35
R1208 1207 188 0.432 2 8.64 35
R1207 1206 1207 17.5 1.92 6.72 36
R1206 1204 1206 0.174118 6.8 11.84 37
R1205 1204 1205 0.432 2 8.64 35
R1204 1203 189 0.432 2 8.64 35
R1203 1202 1203 17.5 1.92 6.72 36
R1202 1201 1202 0.174118 6.8 11.84 37
R1201 1201 36 0.926 2 18.52 35
R1200 1200 189 0.432 2 8.64 35
R1199 1199 1200 17.5 1.92 6.72 36
R1198 1198 1199 0.174118 6.8 11.84 37
R1197 1198 38 0.926 2 18.52 35
R1196 1197 190 0.432 2 8.64 35
R1195 1196 1197 17.5 1.92 6.72 36
R1194 1194 1196 0.174118 6.8 11.84 37
R1193 1194 1195 0.432 2 8.64 35
R1192 1193 190 0.432 2 8.64 35
R1191 1192 1193 17.5 1.92 6.72 36
R1190 1190 1192 0.174118 6.8 11.84 37
R1189 1190 1191 0.432 2 8.64 35
R1188 1189 191 0.432 2 8.64 35
R1187 1188 1189 17.5 1.92 6.72 36
R1186 1186 1188 0.221176 6.8 15.04 37
R1185 1186 1187 0.432 2 8.64 35
R1184 1185 191 0.432 2 8.64 35
R1183 1184 1185 17.5 1.92 6.72 36
R1182 1182 1184 0.221176 6.8 15.04 37
R1181 1182 1183 0.432 2 8.64 35
R1180 1181 192 0.432 2 8.64 35
R1179 1180 1181 17.5 1.92 6.72 36
R1178 1178 1180 0.174118 6.8 11.84 37
R1177 1178 1179 0.432 2 8.64 35
R1176 1177 192 0.432 2 8.64 35
R1175 1176 1177 17.5 1.92 6.72 36
R1174 1174 1176 0.174118 6.8 11.84 37
R1173 1174 1175 0.432 2 8.64 35
R1172 1173 193 0.432 2 8.64 35
R1171 1172 1173 17.5 1.92 6.72 36
R1170 1171 1172 0.174118 6.8 11.84 37
R1169 1171 51 0.712 2 14.24 35
R1168 1170 193 0.432 2 8.64 35
R1167 1169 1170 17.5 1.92 6.72 36
R1166 1167 1169 0.174118 6.8 11.84 37
R1165 1167 1168 0.432 2 8.64 35
R1164 1166 194 0.432 2 8.64 35
R1163 1165 1166 17.5 1.92 6.72 36
R1162 1163 1165 0.174118 6.8 11.84 37
R1161 1163 1164 0.432 2 8.64 35
R1160 1162 194 0.432 2 8.64 35
R1159 1161 1162 17.5 1.92 6.72 36
R1158 1159 1161 0.174118 6.8 11.84 37
R1157 1159 1160 0.432 2 8.64 35
R1156 1158 195 0.432 2 8.64 35
R1155 1157 1158 17.5 1.92 6.72 36
R1154 1155 1157 0.174118 6.8 11.84 37
R1153 1155 1156 0.432 2 8.64 35
R1152 1154 195 0.432 2 8.64 35
R1151 1153 1154 17.5 1.92 6.72 36
R1150 1151 1153 0.174118 6.8 11.84 37
R1149 1151 1152 0.432 2 8.64 35
R1148 1150 196 0.432 2 8.64 35
R1147 1149 1150 17.5 1.92 6.72 36
R1146 1147 1149 0.174118 6.8 11.84 37
R1145 1147 1148 0.432 2 8.64 35
R1144 1146 196 0.432 2 8.64 35
R1143 1145 1146 17.5 1.92 6.72 36
R1142 1143 1145 0.174118 6.8 11.84 37
R1141 1143 1144 0.432 2 8.64 35
R1140 1142 197 0.432 2 8.64 35
R1139 1141 1142 17.5 1.92 6.72 36
R1138 1139 1141 0.174118 6.8 11.84 37
R1137 1139 1140 0.432 2 8.64 35
R1136 1138 197 0.432 2 8.64 35
R1135 1137 1138 17.5 1.92 6.72 36
R1134 1135 1137 0.174118 6.8 11.84 37
R1133 1135 1136 0.432 2 8.64 35
R1132 1134 198 0.432 2 8.64 35
R1131 1133 1134 17.5 1.92 6.72 36
R1130 1131 1133 0.174118 6.8 11.84 37
R1129 1131 1132 0.432 2 8.64 35
R1128 1130 198 0.432 2 8.64 35
R1127 1129 1130 17.5 1.92 6.72 36
R1126 1127 1129 0.174118 6.8 11.84 37
R1125 1127 1128 0.432 2 8.64 35
R1124 1126 199 0.432 2 8.64 35
R1123 1125 1126 17.5 1.92 6.72 36
R1122 1123 1125 0.174118 6.8 11.84 37
R1121 1123 1124 0.432 2 8.64 35
R1120 1122 199 0.432 2 8.64 35
R1119 1121 1122 17.5 1.92 6.72 36
R1118 1119 1121 0.174118 6.8 11.84 37
R1117 1119 1120 0.432 2 8.64 35
R1116 1118 200 0.432 2 8.64 35
R1115 1117 1118 17.5 1.92 6.72 36
R1114 1115 1117 0.174118 6.8 11.84 37
R1113 1115 1116 0.432 2 8.64 35
R1112 1114 200 0.432 2 8.64 35
R1111 1113 1114 17.5 1.92 6.72 36
R1110 1111 1113 0.174118 6.8 11.84 37
R1109 1111 1112 0.432 2 8.64 35
R1108 1110 201 0.432 2 8.64 35
R1107 1109 1110 17.5 1.92 6.72 36
R1106 1107 1109 0.174118 6.8 11.84 37
R1105 1107 1108 0.432 2 8.64 35
R1104 1106 201 0.432 2 8.64 35
R1103 1105 1106 17.5 1.92 6.72 36
R1102 1103 1105 0.174118 6.8 11.84 37
R1101 1103 1104 0.432 2 8.64 35
R1100 1102 202 0.432 2 8.64 35
R1099 1101 1102 17.5 1.92 6.72 36
R1098 1099 1101 0.174118 6.8 11.84 37
R1097 1099 1100 0.432 2 8.64 35
R1096 1098 202 0.432 2 8.64 35
R1095 1097 1098 17.5 1.92 6.72 36
R1094 1095 1097 0.174118 6.8 11.84 37
R1093 1095 1096 0.432 2 8.64 35
R1092 1094 203 0.432 2 8.64 35
R1091 1093 1094 17.5 1.92 6.72 36
R1090 1091 1093 0.174118 6.8 11.84 37
R1089 1091 1092 0.432 2 8.64 35
R1088 1090 203 0.432 2 8.64 35
R1087 1089 1090 17.5 1.92 6.72 36
R1086 1087 1089 0.174118 6.8 11.84 37
R1085 1087 1088 0.432 2 8.64 35
R1084 1086 204 0.432 2 8.64 35
R1083 1085 1086 17.5 1.92 6.72 36
R1082 1083 1085 0.174118 6.8 11.84 37
R1081 1083 1084 0.432 2 8.64 35
R1080 1082 204 0.432 2 8.64 35
R1079 1081 1082 17.5 1.92 6.72 36
R1078 1080 1081 0.174118 6.8 11.84 37
R1077 1080 75 0.526 2 10.52 35
R1076 1079 205 0.432 2 8.64 35
R1075 1078 1079 17.5 1.92 6.72 36
R1074 1076 1078 0.174118 6.8 11.84 37
R1073 1076 1077 0.432 2 8.64 35
R1072 1075 205 0.432 2 8.64 35
R1071 1074 1075 17.5 1.92 6.72 36
R1070 1072 1074 0.174118 6.8 11.84 37
R1069 1072 1073 0.432 2 8.64 35
R1068 1071 206 0.432 2 8.64 35
R1067 1070 1071 17.5 1.92 6.72 36
R1066 1068 1070 0.174118 6.8 11.84 37
R1065 1068 1069 0.432 2 8.64 35
R1064 1067 206 0.432 2 8.64 35
R1063 1066 1067 17.5 1.92 6.72 36
R1062 1064 1066 0.174118 6.8 11.84 37
R1061 1064 1065 0.432 2 8.64 35
R1060 1063 207 0.432 2 8.64 35
R1059 1062 1063 17.5 1.92 6.72 36
R1058 1060 1062 0.174118 6.8 11.84 37
R1057 1060 1061 0.432 2 8.64 35
R1056 1059 207 0.432 2 8.64 35
R1055 1058 1059 17.5 1.92 6.72 36
R1054 1056 1058 0.174118 6.8 11.84 37
R1053 1056 1057 0.432 2 8.64 35
R1052 1055 208 0.432 2 8.64 35
R1051 1054 1055 17.5 1.92 6.72 36
R1050 1052 1054 0.174118 6.8 11.84 37
R1049 1052 1053 0.432 2 8.64 35
R1048 1051 208 0.432 2 8.64 35
R1047 1050 1051 17.5 1.92 6.72 36
R1046 1048 1050 0.174118 6.8 11.84 37
R1045 1048 1049 0.432 2 8.64 35
R1044 1047 210 0.432 2 8.64 35
R1043 1046 1047 17.5 1.92 6.72 36
R1042 1044 1046 0.174118 6.8 11.84 37
R1041 1044 1045 0.432 2 8.64 35
R1040 1043 210 0.432 2 8.64 35
R1039 1042 1043 17.5 1.92 6.72 36
R1038 1040 1042 0.174118 6.8 11.84 37
R1037 1040 1041 0.432 2 8.64 35
R1036 1039 211 0.432 2 8.64 35
R1035 1038 1039 17.5 1.92 6.72 36
R1034 1036 1038 0.174118 6.8 11.84 37
R1033 1036 1037 0.432 2 8.64 35
R1032 1035 211 0.432 2 8.64 35
R1031 1034 1035 17.5 1.92 6.72 36
R1030 1032 1034 0.174118 6.8 11.84 37
R1029 1032 1033 0.432 2 8.64 35
R1028 1031 212 0.432 2 8.64 35
R1027 1030 1031 17.5 1.92 6.72 36
R1026 1028 1030 0.174118 6.8 11.84 37
R1025 1028 1029 0.432 2 8.64 35
R1024 1027 212 0.432 2 8.64 35
R1023 1026 1027 17.5 1.92 6.72 36
R1022 1024 1026 0.174118 6.8 11.84 37
R1021 1024 1025 0.432 2 8.64 35
R1020 1023 213 0.432 2 8.64 35
R1019 1022 1023 17.5 1.92 6.72 36
R1018 1020 1022 0.174118 6.8 11.84 37
R1017 1020 1021 0.432 2 8.64 35
R1016 1019 213 0.432 2 8.64 35
R1015 1018 1019 17.5 1.92 6.72 36
R1014 1016 1018 0.174118 6.8 11.84 37
R1013 1016 1017 0.432 2 8.64 35
R1012 1015 214 0.432 2 8.64 35
R1011 1014 1015 17.5 1.92 6.72 36
R1010 1012 1014 0.174118 6.8 11.84 37
R1009 1012 1013 0.432 2 8.64 35
R1008 1011 214 0.432 2 8.64 35
R1007 1010 1011 17.5 1.92 6.72 36
R1006 1008 1010 0.174118 6.8 11.84 37
R1005 1008 1009 0.432 2 8.64 35
R1004 1007 215 0.432 2 8.64 35
R1003 1006 1007 17.5 1.92 6.72 36
R1002 1004 1006 0.174118 6.8 11.84 37
R1001 1004 1005 0.432 2 8.64 35
R1000 1003 215 0.432 2 8.64 35
R999 1002 1003 17.5 1.92 6.72 36
R998 1000 1002 0.174118 6.8 11.84 37
R997 1000 1001 0.432 2 8.64 35
R996 999 216 0.432 2 8.64 35
R995 998 999 17.5 1.92 6.72 36
R994 996 998 0.174118 6.8 11.84 37
R993 996 997 0.432 2 8.64 35
R992 995 216 0.432 2 8.64 35
R991 994 995 17.5 1.92 6.72 36
R990 992 994 0.174118 6.8 11.84 37
R989 992 993 0.432 2 8.64 35
R988 991 217 0.432 2 8.64 35
R987 990 991 17.5 1.92 6.72 36
R986 988 990 0.174118 6.8 11.84 37
R985 988 989 0.432 2 8.64 35
R984 987 217 0.432 2 8.64 35
R983 986 987 17.5 1.92 6.72 36
R982 984 986 0.174118 6.8 11.84 37
R981 984 985 0.432 2 8.64 35
R980 983 218 0.432 2 8.64 35
R979 982 983 17.5 1.92 6.72 36
R978 980 982 0.174118 6.8 11.84 37
R977 980 981 0.432 2 8.64 35
R976 979 218 0.432 2 8.64 35
R975 978 979 17.5 1.92 6.72 36
R974 976 978 0.174118 6.8 11.84 37
R973 976 977 0.432 2 8.64 35
R972 975 219 0.432 2 8.64 35
R971 974 975 17.5 1.92 6.72 36
R970 973 974 0.174118 6.8 11.84 37
R969 973 73 0.526 2 10.52 35
R968 972 219 0.432 2 8.64 35
R967 971 972 17.5 1.92 6.72 36
R966 969 971 0.174118 6.8 11.84 37
R965 969 970 0.432 2 8.64 35
R964 968 220 0.432 2 8.64 35
R963 967 968 17.5 1.92 6.72 36
R962 965 967 0.174118 6.8 11.84 37
R961 965 966 0.432 2 8.64 35
R960 964 220 0.432 2 8.64 35
R959 963 964 17.5 1.92 6.72 36
R958 961 963 0.174118 6.8 11.84 37
R957 961 962 0.432 2 8.64 35
R956 960 221 0.432 2 8.64 35
R955 959 960 17.5 1.92 6.72 36
R954 957 959 0.174118 6.8 11.84 37
R953 957 958 0.432 2 8.64 35
R952 956 221 0.432 2 8.64 35
R951 955 956 17.5 1.92 6.72 36
R950 953 955 0.174118 6.8 11.84 37
R949 953 954 0.432 2 8.64 35
R948 952 222 0.432 2 8.64 35
R947 951 952 17.5 1.92 6.72 36
R946 949 951 0.174118 6.8 11.84 37
R945 949 950 0.432 2 8.64 35
R944 948 222 0.432 2 8.64 35
R943 947 948 17.5 1.92 6.72 36
R942 945 947 0.174118 6.8 11.84 37
R941 945 946 0.432 2 8.64 35
R940 944 223 0.432 2 8.64 35
R939 943 944 17.5 1.92 6.72 36
R938 941 943 0.174118 6.8 11.84 37
R937 941 942 0.432 2 8.64 35
R936 940 223 0.432 2 8.64 35
R935 939 940 17.5 1.92 6.72 36
R934 937 939 0.174118 6.8 11.84 37
R933 937 938 0.432 2 8.64 35
R932 936 224 0.432 2 8.64 35
R931 935 936 17.5 1.92 6.72 36
R930 933 935 0.174118 6.8 11.84 37
R929 933 934 0.432 2 8.64 35
R928 932 224 0.432 2 8.64 35
R927 931 932 17.5 1.92 6.72 36
R926 929 931 0.174118 6.8 11.84 37
R925 929 930 0.432 2 8.64 35
R924 928 225 0.432 2 8.64 35
R923 927 928 17.5 1.92 6.72 36
R922 925 927 0.174118 6.8 11.84 37
R921 925 926 0.432 2 8.64 35
R920 924 225 0.432 2 8.64 35
R919 923 924 17.5 1.92 6.72 36
R918 921 923 0.174118 6.8 11.84 37
R917 921 922 0.432 2 8.64 35
R916 920 226 0.432 2 8.64 35
R915 919 920 17.5 1.92 6.72 36
R914 917 919 0.174118 6.8 11.84 37
R913 917 918 0.432 2 8.64 35
R912 916 226 0.432 2 8.64 35
R911 915 916 17.5 1.92 6.72 36
R910 913 915 0.174118 6.8 11.84 37
R909 913 914 0.432 2 8.64 35
R908 912 227 0.432 2 8.64 35
R907 911 912 17.5 1.92 6.72 36
R906 909 911 0.291765 6.8 19.84 37
R905 909 910 0.432 2 8.64 35
R904 908 227 0.432 2 8.64 35
R903 907 908 17.5 1.92 6.72 36
R902 905 907 0.291765 6.8 19.84 37
R901 905 906 0.432 2 8.64 35
R900 904 228 0.432 2 8.64 35
R899 903 904 17.5 1.92 6.72 36
R898 901 903 0.174118 6.8 11.84 37
R897 901 902 0.432 2 8.64 35
R896 900 228 0.432 2 8.64 35
R895 899 900 17.5 1.92 6.72 36
R894 897 899 0.174118 6.8 11.84 37
R893 897 898 0.432 2 8.64 35
R892 896 229 0.432 2 8.64 35
R891 895 896 17.5 1.92 6.72 36
R890 893 895 0.174118 6.8 11.84 37
R889 893 894 0.432 2 8.64 35
R888 892 229 0.432 2 8.64 35
R887 891 892 17.5 1.92 6.72 36
R886 889 891 0.174118 6.8 11.84 37
R885 889 890 0.432 2 8.64 35
R884 888 230 0.432 2 8.64 35
R883 887 888 17.5 1.92 6.72 36
R882 885 887 0.174118 6.8 11.84 37
R881 885 886 0.432 2 8.64 35
R880 884 230 0.432 2 8.64 35
R879 883 884 17.5 1.92 6.72 36
R878 881 883 0.174118 6.8 11.84 37
R877 881 882 0.432 2 8.64 35
R876 880 231 0.432 2 8.64 35
R875 879 880 17.5 1.92 6.72 36
R874 877 879 0.174118 6.8 11.84 37
R873 877 878 0.432 2 8.64 35
R872 876 231 0.432 2 8.64 35
R871 875 876 17.5 1.92 6.72 36
R870 873 875 0.174118 6.8 11.84 37
R869 873 874 0.432 2 8.64 35
R868 872 232 0.432 2 8.64 35
R867 871 872 17.5 1.92 6.72 36
R866 869 871 0.174118 6.8 11.84 37
R865 869 870 0.432 2 8.64 35
R864 868 232 0.432 2 8.64 35
R863 867 868 17.5 1.92 6.72 36
R862 866 867 0.174118 6.8 11.84 37
R861 866 71 0.526 2 10.52 35
R860 865 233 0.432 2 8.64 35
R859 864 865 17.5 1.92 6.72 36
R858 862 864 0.174118 6.8 11.84 37
R857 862 863 0.432 2 8.64 35
R856 861 233 0.432 2 8.64 35
R855 860 861 17.5 1.92 6.72 36
R854 858 860 0.174118 6.8 11.84 37
R853 858 859 0.432 2 8.64 35
R852 857 234 0.432 2 8.64 35
R851 856 857 17.5 1.92 6.72 36
R850 854 856 0.174118 6.8 11.84 37
R849 854 855 0.432 2 8.64 35
R848 853 234 0.432 2 8.64 35
R847 852 853 17.5 1.92 6.72 36
R846 850 852 0.174118 6.8 11.84 37
R845 850 851 0.432 2 8.64 35
R844 849 235 0.432 2 8.64 35
R843 848 849 17.5 1.92 6.72 36
R842 846 848 0.174118 6.8 11.84 37
R841 846 847 0.432 2 8.64 35
R840 845 235 0.432 2 8.64 35
R839 844 845 17.5 1.92 6.72 36
R838 842 844 0.174118 6.8 11.84 37
R837 842 843 0.432 2 8.64 35
R836 841 236 0.432 2 8.64 35
R835 840 841 17.5 1.92 6.72 36
R834 838 840 0.174118 6.8 11.84 37
R833 838 839 0.432 2 8.64 35
R832 837 236 0.432 2 8.64 35
R831 836 837 17.5 1.92 6.72 36
R830 834 836 0.174118 6.8 11.84 37
R829 834 835 0.432 2 8.64 35
R828 833 237 0.432 2 8.64 35
R827 832 833 17.5 1.92 6.72 36
R826 830 832 0.174118 6.8 11.84 37
R825 830 831 0.432 2 8.64 35
R824 829 237 0.432 2 8.64 35
R823 828 829 17.5 1.92 6.72 36
R822 826 828 0.174118 6.8 11.84 37
R821 826 827 0.432 2 8.64 35
R820 825 238 0.432 2 8.64 35
R819 824 825 17.5 1.92 6.72 36
R818 822 824 0.185882 6.8 12.64 37
R817 822 823 0.432 2 8.64 35
R816 821 238 0.432 2 8.64 35
R815 820 821 17.5 1.92 6.72 36
R814 819 820 0.185882 6.8 12.64 37
R813 819 62 0.586 2 11.72 35
R812 818 239 0.432 2 8.64 35
R811 817 818 17.5 1.92 6.72 36
R810 815 817 0.174118 6.8 11.84 37
R809 815 816 0.432 2 8.64 35
R808 814 239 0.432 2 8.64 35
R807 813 814 17.5 1.92 6.72 36
R806 811 813 0.174118 6.8 11.84 37
R805 811 812 0.432 2 8.64 35
R804 810 240 0.432 2 8.64 35
R803 809 810 17.5 1.92 6.72 36
R802 807 809 0.174118 6.8 11.84 37
R801 807 808 0.432 2 8.64 35
R800 806 240 0.432 2 8.64 35
R799 805 806 17.5 1.92 6.72 36
R798 803 805 0.174118 6.8 11.84 37
R797 803 804 0.432 2 8.64 35
R796 802 241 0.432 2 8.64 35
R795 801 802 17.5 1.92 6.72 36
R794 799 801 0.174118 6.8 11.84 37
R793 799 800 0.432 2 8.64 35
R792 798 241 0.432 2 8.64 35
R791 797 798 17.5 1.92 6.72 36
R790 795 797 0.174118 6.8 11.84 37
R789 795 796 0.432 2 8.64 35
R788 794 242 0.432 2 8.64 35
R787 793 794 17.5 1.92 6.72 36
R786 791 793 0.174118 6.8 11.84 37
R785 791 792 0.432 2 8.64 35
R784 790 242 0.432 2 8.64 35
R783 789 790 17.5 1.92 6.72 36
R782 787 789 0.174118 6.8 11.84 37
R781 787 788 0.432 2 8.64 35
R780 786 243 0.432 2 8.64 35
R779 785 786 17.5 1.92 6.72 36
R778 783 785 0.174118 6.8 11.84 37
R777 783 784 0.432 2 8.64 35
R776 782 243 0.432 2 8.64 35
R775 781 782 17.5 1.92 6.72 36
R774 779 781 0.174118 6.8 11.84 37
R773 779 780 0.432 2 8.64 35
R772 778 244 0.432 2 8.64 35
R771 777 778 17.5 1.92 6.72 36
R770 775 777 0.174118 6.8 11.84 37
R769 775 776 0.432 2 8.64 35
R768 774 244 0.432 2 8.64 35
R767 773 774 17.5 1.92 6.72 36
R766 772 773 0.174118 6.8 11.84 37
R765 772 69 0.526 2 10.52 35
R764 771 245 0.432 2 8.64 35
R763 770 771 17.5 1.92 6.72 36
R762 768 770 0.174118 6.8 11.84 37
R761 768 769 0.432 2 8.64 35
R760 767 245 0.432 2 8.64 35
R759 766 767 17.5 1.92 6.72 36
R758 764 766 0.174118 6.8 11.84 37
R757 764 765 0.432 2 8.64 35
R756 763 246 0.432 2 8.64 35
R755 762 763 17.5 1.92 6.72 36
R754 760 762 0.174118 6.8 11.84 37
R753 760 761 0.432 2 8.64 35
R752 759 246 0.432 2 8.64 35
R751 758 759 17.5 1.92 6.72 36
R750 756 758 0.174118 6.8 11.84 37
R749 756 757 0.432 2 8.64 35
R748 755 247 0.432 2 8.64 35
R747 754 755 17.5 1.92 6.72 36
R746 752 754 0.174118 6.8 11.84 37
R745 752 753 0.432 2 8.64 35
R744 751 247 0.432 2 8.64 35
R743 750 751 17.5 1.92 6.72 36
R742 748 750 0.174118 6.8 11.84 37
R741 748 749 0.432 2 8.64 35
R740 747 248 0.432 2 8.64 35
R739 746 747 17.5 1.92 6.72 36
R738 744 746 0.174118 6.8 11.84 37
R737 744 745 0.432 2 8.64 35
R736 743 248 0.432 2 8.64 35
R735 742 743 17.5 1.92 6.72 36
R734 740 742 0.174118 6.8 11.84 37
R733 740 741 0.432 2 8.64 35
R732 739 249 0.432 2 8.64 35
R731 738 739 17.5 1.92 6.72 36
R730 736 738 0.174118 6.8 11.84 37
R729 736 737 0.432 2 8.64 35
R728 735 249 0.432 2 8.64 35
R727 734 735 17.5 1.92 6.72 36
R726 732 734 0.174118 6.8 11.84 37
R725 732 733 0.432 2 8.64 35
R724 731 251 0.432 2 8.64 35
R723 730 731 17.5 1.92 6.72 36
R722 728 730 0.174118 6.8 11.84 37
R721 728 729 0.432 2 8.64 35
R720 727 251 0.432 2 8.64 35
R719 726 727 17.5 1.92 6.72 36
R718 724 726 0.174118 6.8 11.84 37
R717 724 725 0.432 2 8.64 35
R716 723 252 0.432 2 8.64 35
R715 722 723 17.5 1.92 6.72 36
R714 720 722 0.174118 6.8 11.84 37
R713 720 721 0.432 2 8.64 35
R712 719 252 0.432 2 8.64 35
R711 718 719 17.5 1.92 6.72 36
R710 716 718 0.174118 6.8 11.84 37
R709 716 717 0.432 2 8.64 35
R708 715 253 0.432 2 8.64 35
R707 714 715 17.5 1.92 6.72 36
R706 712 714 0.174118 6.8 11.84 37
R705 712 713 0.432 2 8.64 35
R704 711 253 0.432 2 8.64 35
R703 710 711 17.5 1.92 6.72 36
R702 708 710 0.174118 6.8 11.84 37
R701 708 709 0.432 2 8.64 35
R700 707 254 0.432 2 8.64 35
R699 706 707 17.5 1.92 6.72 36
R698 704 706 0.174118 6.8 11.84 37
R697 704 705 0.432 2 8.64 35
R696 703 254 0.432 2 8.64 35
R695 702 703 17.5 1.92 6.72 36
R694 700 702 0.174118 6.8 11.84 37
R693 700 701 0.432 2 8.64 35
R692 699 255 0.432 2 8.64 35
R691 698 699 17.5 1.92 6.72 36
R690 696 698 0.174118 6.8 11.84 37
R689 696 697 0.432 2 8.64 35
R688 695 255 0.432 2 8.64 35
R687 694 695 17.5 1.92 6.72 36
R686 692 694 0.174118 6.8 11.84 37
R685 692 693 0.432 2 8.64 35
R684 691 256 0.432 2 8.64 35
R683 690 691 17.5 1.92 6.72 36
R682 688 690 0.174118 6.8 11.84 37
R681 688 689 0.432 2 8.64 35
R680 687 256 0.432 2 8.64 35
R679 686 687 17.5 1.92 6.72 36
R678 684 686 0.174118 6.8 11.84 37
R677 684 685 0.432 2 8.64 35
R676 683 257 0.432 2 8.64 35
R675 682 683 17.5 1.92 6.72 36
R674 680 682 0.174118 6.8 11.84 37
R673 680 681 0.432 2 8.64 35
R672 679 257 0.432 2 8.64 35
R671 678 679 17.5 1.92 6.72 36
R670 676 678 0.174118 6.8 11.84 37
R669 676 677 0.432 2 8.64 35
R668 675 258 0.432 2 8.64 35
R667 674 675 17.5 1.92 6.72 36
R666 672 674 0.174118 6.8 11.84 37
R665 672 673 0.432 2 8.64 35
R664 671 258 0.432 2 8.64 35
R663 670 671 17.5 1.92 6.72 36
R662 668 670 0.174118 6.8 11.84 37
R661 668 669 0.432 2 8.64 35
R660 667 259 0.432 2 8.64 35
R659 666 667 17.5 1.92 6.72 36
R658 665 666 0.174118 6.8 11.84 37
R657 665 67 0.526 2 10.52 35
R656 664 259 0.432 2 8.64 35
R655 663 664 17.5 1.92 6.72 36
R654 661 663 0.174118 6.8 11.84 37
R653 661 662 0.432 2 8.64 35
R652 660 260 0.432 2 8.64 35
R651 659 660 17.5 1.92 6.72 36
R650 657 659 0.174118 6.8 11.84 37
R649 657 658 0.432 2 8.64 35
R648 656 260 0.432 2 8.64 35
R647 655 656 17.5 1.92 6.72 36
R646 653 655 0.174118 6.8 11.84 37
R645 653 654 0.432 2 8.64 35
R644 652 261 0.432 2 8.64 35
R643 651 652 17.5 1.92 6.72 36
R642 649 651 0.174118 6.8 11.84 37
R641 649 650 0.432 2 8.64 35
R640 648 261 0.432 2 8.64 35
R639 647 648 17.5 1.92 6.72 36
R638 645 647 0.174118 6.8 11.84 37
R637 645 646 0.432 2 8.64 35
R636 644 262 0.432 2 8.64 35
R635 643 644 17.5 1.92 6.72 36
R634 641 643 0.174118 6.8 11.84 37
R633 641 642 0.432 2 8.64 35
R632 640 262 0.432 2 8.64 35
R631 639 640 17.5 1.92 6.72 36
R630 637 639 0.174118 6.8 11.84 37
R629 637 638 0.432 2 8.64 35
R628 636 263 0.432 2 8.64 35
R627 635 636 17.5 1.92 6.72 36
R626 633 635 0.174118 6.8 11.84 37
R625 633 634 0.432 2 8.64 35
R624 632 263 0.432 2 8.64 35
R623 631 632 17.5 1.92 6.72 36
R622 629 631 0.174118 6.8 11.84 37
R621 629 630 0.432 2 8.64 35
R620 628 264 0.432 2 8.64 35
R619 627 628 17.5 1.92 6.72 36
R618 625 627 0.174118 6.8 11.84 37
R617 625 626 0.432 2 8.64 35
R616 624 264 0.432 2 8.64 35
R615 623 624 17.5 1.92 6.72 36
R614 621 623 0.174118 6.8 11.84 37
R613 621 622 0.432 2 8.64 35
R612 620 265 0.432 2 8.64 35
R611 619 620 17.5 1.92 6.72 36
R610 617 619 0.174118 6.8 11.84 37
R609 617 618 0.432 2 8.64 35
R608 616 265 0.432 2 8.64 35
R607 615 616 17.5 1.92 6.72 36
R606 613 615 0.174118 6.8 11.84 37
R605 613 614 0.432 2 8.64 35
R604 612 266 0.432 2 8.64 35
R603 611 612 17.5 1.92 6.72 36
R602 609 611 0.174118 6.8 11.84 37
R601 609 610 0.432 2 8.64 35
R600 608 266 0.432 2 8.64 35
R599 607 608 17.5 1.92 6.72 36
R598 605 607 0.174118 6.8 11.84 37
R597 605 606 0.432 2 8.64 35
R596 604 267 0.432 2 8.64 35
R595 603 604 17.5 1.92 6.72 36
R594 601 603 0.174118 6.8 11.84 37
R593 601 602 0.432 2 8.64 35
R592 600 267 0.432 2 8.64 35
R591 599 600 17.5 1.92 6.72 36
R590 597 599 0.174118 6.8 11.84 37
R589 597 598 0.432 2 8.64 35
R588 596 268 0.432 2 8.64 35
R587 595 596 17.5 1.92 6.72 36
R586 593 595 0.174118 6.8 11.84 37
R585 593 594 0.432 2 8.64 35
R584 592 268 0.432 2 8.64 35
R583 591 592 17.5 1.92 6.72 36
R582 589 591 0.174118 6.8 11.84 37
R581 589 590 0.432 2 8.64 35
R580 588 269 0.432 2 8.64 35
R579 587 588 17.5 1.92 6.72 36
R578 585 587 0.174118 6.8 11.84 37
R577 585 586 0.432 2 8.64 35
R576 584 269 0.432 2 8.64 35
R575 583 584 17.5 1.92 6.72 36
R574 581 583 0.174118 6.8 11.84 37
R573 581 582 0.432 2 8.64 35
R572 580 271 0.432 2 8.64 35
R571 579 580 17.5 1.92 6.72 36
R570 577 579 0.174118 6.8 11.84 37
R569 577 578 0.432 2 8.64 35
R568 576 271 0.432 2 8.64 35
R567 575 576 17.5 1.92 6.72 36
R566 573 575 0.174118 6.8 11.84 37
R565 573 574 0.432 2 8.64 35
R564 572 272 0.432 2 8.64 35
R563 571 572 17.5 1.92 6.72 36
R562 569 571 0.174118 6.8 11.84 37
R561 569 570 0.432 2 8.64 35
R560 568 272 0.432 2 8.64 35
R559 567 568 17.5 1.92 6.72 36
R558 565 567 0.174118 6.8 11.84 37
R557 565 566 0.432 2 8.64 35
R556 564 273 0.432 2 8.64 35
R555 563 564 17.5 1.92 6.72 36
R554 561 563 0.174118 6.8 11.84 37
R553 561 562 0.432 2 8.64 35
R552 560 273 0.432 2 8.64 35
R551 559 560 17.5 1.92 6.72 36
R550 557 559 0.174118 6.8 11.84 37
R549 557 558 0.432 2 8.64 35
R548 556 274 0.432 2 8.64 35
R547 555 556 17.5 1.92 6.72 36
R546 553 555 0.174118 6.8 11.84 37
R545 553 554 0.432 2 8.64 35
R544 552 274 0.432 2 8.64 35
R543 551 552 17.5 1.92 6.72 36
R542 549 551 0.174118 6.8 11.84 37
R541 549 550 0.432 2 8.64 35
R540 548 275 0.432 2 8.64 35
R539 547 548 17.5 1.92 6.72 36
R538 545 547 0.174118 6.8 11.84 37
R537 545 546 0.432 2 8.64 35
R536 544 275 0.432 2 8.64 35
R535 543 544 17.5 1.92 6.72 36
R534 541 543 0.174118 6.8 11.84 37
R533 541 542 0.432 2 8.64 35
R532 540 276 0.432 2 8.64 35
R531 539 540 17.5 1.92 6.72 36
R530 537 539 0.174118 6.8 11.84 37
R529 537 538 0.432 2 8.64 35
R528 536 276 0.432 2 8.64 35
R527 535 536 17.5 1.92 6.72 36
R526 533 535 0.174118 6.8 11.84 37
R525 533 534 0.432 2 8.64 35
R524 532 277 0.432 2 8.64 35
R523 531 532 17.5 1.92 6.72 36
R522 529 531 0.174118 6.8 11.84 37
R521 529 530 0.432 2 8.64 35
R520 528 277 0.432 2 8.64 35
R519 527 528 17.5 1.92 6.72 36
R518 525 527 0.174118 6.8 11.84 37
R517 525 526 0.432 2 8.64 35
R516 524 278 0.432 2 8.64 35
R515 523 524 17.5 1.92 6.72 36
R514 521 523 0.174118 6.8 11.84 37
R513 521 522 0.432 2 8.64 35
R512 520 278 0.432 2 8.64 35
R511 519 520 17.5 1.92 6.72 36
R510 517 519 0.174118 6.8 11.84 37
R509 517 518 0.432 2 8.64 35
R508 516 279 0.432 2 8.64 35
R507 515 516 17.5 1.92 6.72 36
R506 513 515 0.174118 6.8 11.84 37
R505 513 514 0.432 2 8.64 35
R504 512 279 0.432 2 8.64 35
R503 511 512 17.5 1.92 6.72 36
R502 509 511 0.174118 6.8 11.84 37
R501 509 510 0.432 2 8.64 35
R500 508 280 0.432 2 8.64 35
R499 507 508 17.5 1.92 6.72 36
R498 505 507 0.174118 6.8 11.84 37
R497 505 506 0.432 2 8.64 35
R496 504 280 0.432 2 8.64 35
R495 503 504 17.5 1.92 6.72 36
R494 501 503 0.174118 6.8 11.84 37
R493 501 502 0.432 2 8.64 35
R492 500 281 0.432 2 8.64 35
R491 499 500 17.5 1.92 6.72 36
R490 497 499 0.174118 6.8 11.84 37
R489 497 498 0.432 2 8.64 35
R488 496 281 0.432 2 8.64 35
R487 495 496 17.5 1.92 6.72 36
R486 493 495 0.174118 6.8 11.84 37
R485 493 494 0.432 2 8.64 35
R484 492 282 0.432 2 8.64 35
R483 491 492 17.5 1.92 6.72 36
R482 489 491 0.174118 6.8 11.84 37
R481 489 490 0.432 2 8.64 35
R480 488 282 0.432 2 8.64 35
R479 487 488 17.5 1.92 6.72 36
R478 485 487 0.174118 6.8 11.84 37
R477 485 486 0.432 2 8.64 35
R476 484 283 0.432 2 8.64 35
R475 483 484 17.5 1.92 6.72 36
R474 481 483 0.174118 6.8 11.84 37
R473 481 482 0.432 2 8.64 35
R472 480 283 0.432 2 8.64 35
R471 479 480 17.5 1.92 6.72 36
R470 477 479 0.174118 6.8 11.84 37
R469 477 478 0.432 2 8.64 35
R468 476 284 0.432 2 8.64 35
R467 475 476 17.5 1.92 6.72 36
R466 473 475 0.174118 6.8 11.84 37
R465 473 474 0.432 2 8.64 35
R464 472 284 0.432 2 8.64 35
R463 471 472 17.5 1.92 6.72 36
R462 469 471 0.174118 6.8 11.84 37
R461 469 470 0.432 2 8.64 35
R460 468 285 0.432 2 8.64 35
R459 467 468 17.5 1.92 6.72 36
R458 465 467 0.174118 6.8 11.84 37
R457 465 466 0.432 2 8.64 35
R456 464 285 0.432 2 8.64 35
R455 463 464 17.5 1.92 6.72 36
R454 461 463 0.174118 6.8 11.84 37
R453 461 462 0.432 2 8.64 35
R452 460 286 0.432 2 8.64 35
R451 459 460 17.5 1.92 6.72 36
R450 457 459 0.174118 6.8 11.84 37
R449 457 458 0.432 2 8.64 35
R448 456 286 0.432 2 8.64 35
R447 455 456 17.5 1.92 6.72 36
R446 453 455 0.174118 6.8 11.84 37
R445 453 454 0.432 2 8.64 35
R444 452 287 0.432 2 8.64 35
R443 451 452 17.5 1.92 6.72 36
R442 449 451 0.174118 6.8 11.84 37
R441 449 450 0.432 2 8.64 35
R440 448 287 0.432 2 8.64 35
R439 447 448 17.5 1.92 6.72 36
R438 445 447 0.174118 6.8 11.84 37
R437 445 446 0.432 2 8.64 35
R436 444 288 0.432 2 8.64 35
R435 443 444 17.5 1.92 6.72 36
R434 441 443 0.174118 6.8 11.84 37
R433 441 442 0.432 2 8.64 35
R432 440 288 0.432 2 8.64 35
R431 439 440 17.5 1.92 6.72 36
R430 437 439 0.174118 6.8 11.84 37
R429 437 438 0.432 2 8.64 35
R428 436 289 0.432 2 8.64 35
R427 435 436 17.5 1.92 6.72 36
R426 434 435 0.174118 6.8 11.84 37
R425 434 65 0.526 2 10.52 35
R424 433 289 0.432 2 8.64 35
R423 432 433 17.5 1.92 6.72 36
R422 430 432 0.174118 6.8 11.84 37
R421 430 431 0.432 2 8.64 35
R420 429 290 0.432 2 8.64 35
R419 428 429 17.5 1.92 6.72 36
R418 426 428 0.174118 6.8 11.84 37
R417 426 427 0.432 2 8.64 35
R416 425 290 0.432 2 8.64 35
R415 424 425 17.5 1.92 6.72 36
R414 422 424 0.174118 6.8 11.84 37
R413 422 423 0.432 2 8.64 35
R412 421 291 0.432 2 8.64 35
R411 420 421 17.5 1.92 6.72 36
R410 418 420 0.174118 6.8 11.84 37
R409 418 419 0.432 2 8.64 35
R408 417 291 0.432 2 8.64 35
R407 416 417 17.5 1.92 6.72 36
R406 414 416 0.174118 6.8 11.84 37
R405 414 415 0.432 2 8.64 35
R404 413 292 0.432 2 8.64 35
R403 412 413 17.5 1.92 6.72 36
R402 410 412 0.174118 6.8 11.84 37
R401 410 411 0.432 2 8.64 35
R400 409 292 0.432 2 8.64 35
R399 408 409 17.5 1.92 6.72 36
R398 406 408 0.174118 6.8 11.84 37
R397 406 407 0.432 2 8.64 35
R396 405 293 0.432 2 8.64 35
R395 404 405 17.5 1.92 6.72 36
R394 402 404 0.174118 6.8 11.84 37
R393 402 403 0.432 2 8.64 35
R392 401 293 0.432 2 8.64 35
R391 400 401 17.5 1.92 6.72 36
R390 398 400 0.174118 6.8 11.84 37
R389 398 399 0.432 2 8.64 35
R388 397 294 0.432 2 8.64 35
R387 396 397 17.5 1.92 6.72 36
R386 394 396 0.174118 6.8 11.84 37
R385 394 395 0.432 2 8.64 35
R384 393 294 0.432 2 8.64 35
R383 392 393 17.5 1.92 6.72 36
R382 390 392 0.174118 6.8 11.84 37
R381 390 391 0.432 2 8.64 35
R380 389 295 0.432 2 8.64 35
R379 388 389 17.5 1.92 6.72 36
R378 386 388 0.174118 6.8 11.84 37
R377 386 387 0.432 2 8.64 35
R376 385 295 0.432 2 8.64 35
R375 384 385 17.5 1.92 6.72 36
R374 382 384 0.174118 6.8 11.84 37
R373 382 383 0.432 2 8.64 35
R372 381 296 0.432 2 8.64 35
R371 380 381 17.5 1.92 6.72 36
R370 378 380 0.174118 6.8 11.84 37
R369 378 379 0.432 2 8.64 35
R368 377 296 0.432 2 8.64 35
R367 376 377 17.5 1.92 6.72 36
R366 374 376 0.174118 6.8 11.84 37
R365 374 375 0.432 2 8.64 35
R364 373 270 0.361111 8.64 52 43
R363 372 373 17.5 1.92 6.72 42
R362 371 372 0.18 2.4 7.2 41
R361 370 371 17.5 1.92 6.72 40
R360 369 370 0.34 2 6.8 39
R359 368 369 17.5 1.92 6.72 38
R358 367 368 0.127059 6.8 8.64 37
R357 0 367 0.0945231 52 81.92 43
R356 366 250 0.361111 8.64 52 43
R355 365 366 17.5 1.92 6.72 42
R354 364 365 0.18 2.4 7.2 41
R353 363 364 17.5 1.92 6.72 40
R352 362 363 0.34 2 6.8 39
R351 361 362 17.5 1.92 6.72 38
R350 360 361 0.127059 6.8 8.64 37
R349 0 360 0.0945231 52 81.92 43
R348 359 238 0.361111 8.64 52 43
R347 358 359 17.5 1.92 6.72 42
R346 357 358 0.18 2.4 7.2 41
R345 356 357 17.5 1.92 6.72 40
R344 355 356 0.34 2 6.8 39
R343 354 355 17.5 1.92 6.72 38
R342 353 354 0.185882 6.8 12.64 37
R341 353 64 0.327731 9.52 52 43
R340 352 227 0.361111 8.64 52 43
R339 351 352 17.5 1.92 6.72 42
R338 350 351 0.18 2.4 7.2 41
R337 349 350 17.5 1.92 6.72 40
R336 348 349 0.34 2 6.8 39
R335 347 348 17.5 1.92 6.72 38
R334 346 347 0.291765 6.8 19.84 37
R333 0 346 0.0945231 52 81.92 43
R332 345 209 0.361111 8.64 52 43
R331 344 345 17.5 1.92 6.72 42
R330 343 344 0.18 2.4 7.2 41
R329 342 343 17.5 1.92 6.72 40
R328 341 342 0.34 2 6.8 39
R327 340 341 17.5 1.92 6.72 38
R326 339 340 0.127059 6.8 8.64 37
R325 0 339 0.0945231 52 81.92 43
R324 338 191 0.361111 8.64 52 43
R323 337 338 17.5 1.92 6.72 42
R322 336 337 0.18 2.4 7.2 41
R321 335 336 17.5 1.92 6.72 40
R320 334 335 0.34 2 6.8 39
R319 333 334 17.5 1.92 6.72 38
R318 332 333 0.221176 6.8 15.04 37
R317 0 332 0.0945231 52 81.92 43
R316 331 174 0.361111 8.64 52 43
R315 330 331 17.5 1.92 6.72 42
R314 329 330 0.18 2.4 7.2 41
R313 328 329 17.5 1.92 6.72 40
R312 327 328 0.34 2 6.8 39
R311 326 327 17.5 1.92 6.72 38
R310 325 326 0.174118 6.8 11.84 37
R309 0 325 0.0945231 52 81.92 43
R308 324 157 0.361111 8.64 52 43
R307 323 324 17.5 1.92 6.72 42
R306 322 323 0.18 2.4 7.2 41
R305 321 322 17.5 1.92 6.72 40
R304 320 321 0.34 2 6.8 39
R303 319 320 17.5 1.92 6.72 38
R302 318 319 0.244706 6.8 16.64 37
R301 0 318 0.0945231 52 81.92 43
R300 317 145 0.361111 8.64 52 43
R299 316 317 17.5 1.92 6.72 42
R298 315 316 0.18 2.4 7.2 41
R297 314 315 17.5 1.92 6.72 40
R296 313 314 0.34 2 6.8 39
R295 312 313 17.5 1.92 6.72 38
R294 311 312 0.256471 6.8 17.44 37
R293 0 311 0.0945231 52 81.92 43
R292 310 134 0.361111 8.64 52 43
R291 309 310 17.5 1.92 6.72 42
R290 308 309 0.18 2.4 7.2 41
R289 307 308 17.5 1.92 6.72 40
R288 306 307 0.34 2 6.8 39
R287 305 306 17.5 1.92 6.72 38
R286 304 305 0.232941 6.8 15.84 37
R285 0 304 0.0945231 52 81.92 43
R284 303 105 0.361111 8.64 52 43
R283 302 303 17.5 1.92 6.72 42
R282 301 302 0.18 2.4 7.2 41
R281 300 301 17.5 1.92 6.72 40
R280 299 300 0.34 2 6.8 39
R279 298 299 17.5 1.92 6.72 38
R278 297 298 0.174118 6.8 11.84 37
R277 0 297 0.0945231 52 81.92 43
R276 296 295 0.550588 6.8 37.44 37
R275 295 294 0.550588 6.8 37.44 37
R274 294 293 0.550588 6.8 37.44 37
R273 293 292 0.550588 6.8 37.44 37
R272 292 291 0.550588 6.8 37.44 37
R271 291 290 0.550588 6.8 37.44 37
R270 290 289 0.550588 6.8 37.44 37
R269 289 288 0.550588 6.8 37.44 37
R268 288 287 0.550588 6.8 37.44 37
R267 287 286 0.550588 6.8 37.44 37
R266 286 285 0.550588 6.8 37.44 37
R265 285 284 0.550588 6.8 37.44 37
R264 284 283 0.550588 6.8 37.44 37
R263 283 282 0.550588 6.8 37.44 37
R262 282 281 0.550588 6.8 37.44 37
R261 281 280 0.550588 6.8 37.44 37
R260 280 279 0.550588 6.8 37.44 37
R259 279 278 0.550588 6.8 37.44 37
R258 278 277 0.550588 6.8 37.44 37
R257 277 276 0.550588 6.8 37.44 37
R256 276 275 0.550588 6.8 37.44 37
R255 275 274 0.550588 6.8 37.44 37
R254 274 273 0.550588 6.8 37.44 37
R253 273 272 0.550588 6.8 37.44 37
R252 272 271 0.550588 6.8 37.44 37
R251 271 270 0.315294 6.8 21.44 37
R250 270 269 0.362353 6.8 24.64 37
R249 269 268 0.550588 6.8 37.44 37
R248 268 267 0.550588 6.8 37.44 37
R247 267 266 0.550588 6.8 37.44 37
R246 266 265 0.550588 6.8 37.44 37
R245 265 264 0.550588 6.8 37.44 37
R244 264 263 0.550588 6.8 37.44 37
R243 263 262 0.550588 6.8 37.44 37
R242 262 261 0.550588 6.8 37.44 37
R241 261 260 0.550588 6.8 37.44 37
R240 260 259 0.550588 6.8 37.44 37
R239 259 258 0.550588 6.8 37.44 37
R238 258 257 0.550588 6.8 37.44 37
R237 257 256 0.550588 6.8 37.44 37
R236 256 255 0.550588 6.8 37.44 37
R235 255 254 0.550588 6.8 37.44 37
R234 254 253 0.550588 6.8 37.44 37
R233 253 252 0.550588 6.8 37.44 37
R232 252 251 0.550588 6.8 37.44 37
R231 251 250 0.303529 6.8 20.64 37
R230 250 249 0.374118 6.8 25.44 37
R229 249 248 0.550588 6.8 37.44 37
R228 248 247 0.550588 6.8 37.44 37
R227 247 246 0.550588 6.8 37.44 37
R226 246 245 0.550588 6.8 37.44 37
R225 245 244 0.550588 6.8 37.44 37
R224 244 243 0.550588 6.8 37.44 37
R223 243 242 0.550588 6.8 37.44 37
R222 242 241 0.550588 6.8 37.44 37
R221 241 240 0.550588 6.8 37.44 37
R220 240 239 0.550588 6.8 37.44 37
R219 239 238 0.550588 6.8 37.44 37
R218 238 237 0.562353 6.8 38.24 37
R217 237 236 0.550588 6.8 37.44 37
R216 236 235 0.550588 6.8 37.44 37
R215 235 234 0.550588 6.8 37.44 37
R214 234 233 0.550588 6.8 37.44 37
R213 233 232 0.550588 6.8 37.44 37
R212 232 231 0.550588 6.8 37.44 37
R211 231 230 0.550588 6.8 37.44 37
R210 230 229 0.550588 6.8 37.44 37
R209 229 228 0.550588 6.8 37.44 37
R208 228 227 0.668235 6.8 45.44 37
R207 227 226 0.550588 6.8 37.44 37
R206 226 225 0.550588 6.8 37.44 37
R205 225 224 0.550588 6.8 37.44 37
R204 224 223 0.550588 6.8 37.44 37
R203 223 222 0.550588 6.8 37.44 37
R202 222 221 0.550588 6.8 37.44 37
R201 221 220 0.550588 6.8 37.44 37
R200 220 219 0.550588 6.8 37.44 37
R199 219 218 0.550588 6.8 37.44 37
R198 218 217 0.550588 6.8 37.44 37
R197 217 216 0.550588 6.8 37.44 37
R196 216 215 0.550588 6.8 37.44 37
R195 215 214 0.550588 6.8 37.44 37
R194 214 213 0.550588 6.8 37.44 37
R193 213 212 0.550588 6.8 37.44 37
R192 212 211 0.550588 6.8 37.44 37
R191 211 210 0.550588 6.8 37.44 37
R190 210 209 0.374118 6.8 25.44 37
R189 209 208 0.303529 6.8 20.64 37
R188 208 207 0.550588 6.8 37.44 37
R187 207 206 0.550588 6.8 37.44 37
R186 206 205 0.550588 6.8 37.44 37
R185 205 204 0.550588 6.8 37.44 37
R184 204 203 0.550588 6.8 37.44 37
R183 203 202 0.550588 6.8 37.44 37
R182 202 201 0.550588 6.8 37.44 37
R181 201 200 0.550588 6.8 37.44 37
R180 200 199 0.550588 6.8 37.44 37
R179 199 198 0.550588 6.8 37.44 37
R178 198 197 0.550588 6.8 37.44 37
R177 197 196 0.550588 6.8 37.44 37
R176 196 195 0.550588 6.8 37.44 37
R175 195 194 0.550588 6.8 37.44 37
R174 194 193 0.550588 6.8 37.44 37
R173 193 192 0.550588 6.8 37.44 37
R172 192 191 0.550588 6.8 37.44 37
R171 191 190 0.597647 6.8 40.64 37
R170 190 189 0.550588 6.8 37.44 37
R169 189 188 0.550588 6.8 37.44 37
R168 188 187 0.550588 6.8 37.44 37
R167 187 186 0.550588 6.8 37.44 37
R166 186 185 0.550588 6.8 37.44 37
R165 185 184 0.550588 6.8 37.44 37
R164 184 183 0.550588 6.8 37.44 37
R163 183 182 0.550588 6.8 37.44 37
R162 182 181 0.550588 6.8 37.44 37
R161 181 180 0.550588 6.8 37.44 37
R160 180 179 0.550588 6.8 37.44 37
R159 179 178 0.550588 6.8 37.44 37
R158 178 177 0.550588 6.8 37.44 37
R157 177 176 0.550588 6.8 37.44 37
R156 176 175 0.550588 6.8 37.44 37
R155 175 174 0.550588 6.8 37.44 37
R154 174 173 0.550588 6.8 37.44 37
R153 173 172 0.550588 6.8 37.44 37
R152 172 171 0.550588 6.8 37.44 37
R151 171 170 0.550588 6.8 37.44 37
R150 170 169 0.550588 6.8 37.44 37
R149 169 168 0.550588 6.8 37.44 37
R148 168 167 0.550588 6.8 37.44 37
R147 167 166 0.550588 6.8 37.44 37
R146 166 165 0.550588 6.8 37.44 37
R145 165 164 0.550588 6.8 37.44 37
R144 164 163 0.550588 6.8 37.44 37
R143 163 162 0.550588 6.8 37.44 37
R142 162 161 0.550588 6.8 37.44 37
R141 161 160 0.550588 6.8 37.44 37
R140 160 159 0.550588 6.8 37.44 37
R139 159 158 0.550588 6.8 37.44 37
R138 158 157 0.621176 6.8 42.24 37
R137 157 156 0.550588 6.8 37.44 37
R136 156 155 0.550588 6.8 37.44 37
R135 155 154 0.550588 6.8 37.44 37
R134 154 153 0.550588 6.8 37.44 37
R133 153 152 0.550588 6.8 37.44 37
R132 152 151 0.550588 6.8 37.44 37
R131 151 150 0.550588 6.8 37.44 37
R130 150 149 0.550588 6.8 37.44 37
R129 149 148 0.550588 6.8 37.44 37
R128 148 147 0.550588 6.8 37.44 37
R127 147 146 0.550588 6.8 37.44 37
R126 146 145 0.550588 6.8 37.44 37
R125 145 144 0.632941 6.8 43.04 37
R124 144 143 0.550588 6.8 37.44 37
R123 143 142 0.550588 6.8 37.44 37
R122 142 141 0.550588 6.8 37.44 37
R121 141 140 0.550588 6.8 37.44 37
R120 140 139 0.550588 6.8 37.44 37
R119 139 138 0.550588 6.8 37.44 37
R118 138 137 0.550588 6.8 37.44 37
R117 137 136 0.550588 6.8 37.44 37
R116 136 135 0.550588 6.8 37.44 37
R115 135 134 0.609412 6.8 41.44 37
R114 134 133 0.550588 6.8 37.44 37
R113 133 132 0.550588 6.8 37.44 37
R112 132 131 0.550588 6.8 37.44 37
R111 131 130 0.550588 6.8 37.44 37
R110 130 129 0.550588 6.8 37.44 37
R109 129 128 0.550588 6.8 37.44 37
R108 128 127 0.550588 6.8 37.44 37
R107 127 126 0.550588 6.8 37.44 37
R106 126 125 0.550588 6.8 37.44 37
R105 125 124 0.550588 6.8 37.44 37
R104 124 123 0.550588 6.8 37.44 37
R103 123 122 0.550588 6.8 37.44 37
R102 122 121 0.550588 6.8 37.44 37
R101 121 120 0.550588 6.8 37.44 37
R100 120 119 0.550588 6.8 37.44 37
R99 119 118 0.550588 6.8 37.44 37
R98 118 117 0.550588 6.8 37.44 37
R97 117 116 0.550588 6.8 37.44 37
R96 116 115 0.550588 6.8 37.44 37
R95 115 114 0.550588 6.8 37.44 37
R94 114 113 0.550588 6.8 37.44 37
R93 113 112 0.550588 6.8 37.44 37
R92 112 111 0.550588 6.8 37.44 37
R91 111 110 0.550588 6.8 37.44 37
R90 110 109 0.550588 6.8 37.44 37
R89 109 108 0.550588 6.8 37.44 37
R88 108 107 0.550588 6.8 37.44 37
R87 107 106 0.550588 6.8 37.44 37
R86 106 105 0.550588 6.8 37.44 37
R85 105 104 0.550588 6.8 37.44 37
R84 104 103 0.550588 6.8 37.44 37
R83 103 102 0.550588 6.8 37.44 37
R82 102 101 0.550588 6.8 37.44 37
R81 101 100 0.550588 6.8 37.44 37
R80 100 99 0.550588 6.8 37.44 37
R79 99 98 0.550588 6.8 37.44 37
R78 98 97 0.550588 6.8 37.44 37
R77 97 96 0.550588 6.8 37.44 37
R76 96 95 0.550588 6.8 37.44 37
R75 95 94 0.550588 6.8 37.44 37
R74 94 93 0.550588 6.8 37.44 37
R73 93 92 0.550588 6.8 37.44 37
R72 92 91 0.550588 6.8 37.44 37
R71 91 89 0.550588 6.8 37.44 37
R70 89 90 0.174118 6.8 11.84 37
R69 87 88 0.5 0.8 4 35
R68 85 86 0.5 0.8 4 35
R67 83 84 0.5 0.8 4 35
R66 81 82 0.5 0.8 4 35
R65 79 80 0.5 0.8 4 35
R64 77 78 0.5 0.8 4 35
R63 75 76 0.5 0.8 4 35
R62 73 74 0.5 0.8 4 35
R61 71 72 0.5 0.8 4 35
R60 69 70 0.5 0.8 4 35
R59 67 68 0.5 0.8 4 35
R58 65 66 0.5 0.8 4 35
R57 0 22 0.0850154 52 73.68 43
R56 0 20 0.0850154 52 73.68 43
R55 0 16 0.0850154 52 73.68 43
R54 0 14 0.0850154 52 73.68 43
R53 0 12 0.0850154 52 73.68 43
R52 0 10 0.0850154 52 73.68 43
R51 0 8 0.0850154 52 73.68 43
R50 0 6 0.0850154 52 73.68 43
R49 0 4 0.0850154 52 73.68 43
R48 0 2 0.0850154 52 73.68 43
R47 0 64 0.084 52 72.8 43
R46 63 40 0.146 2 2.92 35
R45 62 56 0.146 2 2.92 35
R44 0 18 0.084 52 72.8 43
R43 61 58 0.3125 0.64 2 35
R42 60 61 5 0.64 0.64 36
R41 59 60 1.3 0.8 10.4 37
R40 56 59 5 0.64 0.64 36
R39 56 57 0.3125 0.64 2 35
R38 55 52 0.3125 0.64 2 35
R37 54 55 5 0.64 0.64 36
R36 53 54 1.3 0.8 10.4 37
R35 51 53 5 0.64 0.64 36
R34 51 30 0.352 2 7.04 35
R33 50 47 0.3125 0.64 2 35
R32 49 50 5 0.64 0.64 36
R31 48 49 1.3 0.8 10.4 37
R30 46 48 5 0.64 0.64 36
R29 46 24 0.432 2 8.64 35
R28 45 42 0.3125 0.64 2 35
R27 44 45 5 0.64 0.64 36
R26 43 44 1.3 0.8 10.4 37
R25 40 43 5 0.64 0.64 36
R24 40 41 0.3125 0.64 2 35
R23 38 39 0.5 0.8 4 35
R22 36 37 0.5 0.8 4 35
R21 35 32 0.3125 0.64 2 35
R20 34 35 5 0.64 0.64 36
R19 33 34 1.3 0.8 10.4 37
R18 30 33 5 0.64 0.64 36
R17 30 31 0.3125 0.64 2 35
R16 29 26 0.3125 0.64 2 35
R15 28 29 5 0.64 0.64 36
R14 27 28 1.3 0.8 10.4 37
R13 24 27 5 0.64 0.64 36
R12 24 25 0.3125 0.64 2 35
R11 22 23 3.9 1.6 104 43
R10 20 21 3.9 1.6 104 43
R9 18 19 3.9 1.6 104 43
R8 16 17 3.9 1.6 104 43
R7 14 15 3.9 1.6 104 43
R6 12 13 3.9 1.6 104 43
R5 10 11 3.9 1.6 104 43
R4 8 9 3.9 1.6 104 43
R3 6 7 3.9 1.6 104 43
R2 4 5 3.9 1.6 104 43
R1 2 3 3.9 1.6 104 43

* indenpendent current source
I27 0 87 1.23684e-05
I26 0 85 1.2728e-05
I25 0 83 1.23389e-05
I24 0 81 1.25452e-05
I23 0 79 1.22264e-05
I22 0 77 1.26033e-05
I21 0 75 1.18694e-05
I20 0 73 1.24886e-05
I19 0 71 1.165e-05
I18 0 69 1.1302e-05
I17 0 67 1.16918e-05
I16 0 65 1.47401e-05
I15 0 64 3.20715e-05
I14 0 63 3.27998e-05
I13 0 62 3.20715e-05
I12 0 36 3.97044e-05
I11 0 22 5.76162e-06
I10 0 20 5.76162e-06
I9 0 18 5.76162e-06
I8 0 16 5.76162e-06
I7 0 14 5.76162e-06
I6 0 12 5.76162e-06
I5 0 10 5.76162e-06
I4 0 8 5.76162e-06
I3 0 6 5.76162e-06
I2 0 4 5.76162e-06
I1 0 2 5.76162e-06

.op
.end
