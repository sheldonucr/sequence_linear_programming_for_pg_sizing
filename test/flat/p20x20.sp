num_node 401
matrix_size 402

* 20 x 20 ground network
*seg: 1
R1 401 1 0.4 20 80 37
R2 10 30 6.16 0.8 49.28 37
I1 1 0 1.33579e-05
R3 1 2 1.728 0.8 13.824 37
I2 2 0 1.27395e-05
R4 2 3 1.68 0.8 13.44 37
I3 3 0 1.24921e-05
R5 3 4 1.712 0.8 13.696 37
I4 4 0 1.23684e-05
R6 4 5 1.744 0.8 13.952 37
I5 5 0 1.26158e-05
R7 5 6 1.696 0.8 13.568 37
I6 6 0 1.34816e-05
R8 6 7 1.712 0.8 13.696 37
I7 7 0 1.28631e-05
R9 7 8 1.6 0.8 12.8 37
I8 8 0 1.29868e-05
R10 8 9 1.648 0.8 13.184 37
I9 9 0 1.34816e-05
R11 9 10 1.648 0.8 13.184 37
I10 10 0 1.32342e-05
R12 10 11 1.696 0.8 13.568 37
I11 11 0 1.31105e-05
R13 11 12 1.728 0.8 13.824 37
I12 12 0 1.29868e-05
R14 12 13 1.616 0.8 12.928 37
I13 13 0 1.32342e-05
R15 13 14 1.664 0.8 13.312 37
I14 14 0 1.24921e-05
R16 14 15 1.68 0.8 13.44 37
I15 15 0 1.26158e-05
R17 15 16 1.696 0.8 13.568 37
I16 16 0 1.28631e-05
R18 16 17 1.68 0.8 13.44 37
I17 17 0 1.28631e-05
R19 17 18 1.632 0.8 13.056 37
I18 18 0 1.24921e-05
R20 18 19 1.712 0.8 13.696 37
I19 19 0 1.28631e-05
R21 19 20 1.648 0.8 13.184 37
I20 20 0 1.23684e-05
R22 20 401 0.5 10 50 37
*seg: 2
R23 401 21 0.4 20 80 37
R24 30 50 6.16 0.8 49.28 37
I21 21 0 1.24921e-05
R25 21 22 1.696 0.8 13.568 37
I22 22 0 1.33579e-05
R26 22 23 1.728 0.8 13.824 37
I23 23 0 1.29868e-05
R27 23 24 1.648 0.8 13.184 37
I24 24 0 1.32342e-05
R28 24 25 1.696 0.8 13.568 37
I25 25 0 1.29868e-05
R29 25 26 1.648 0.8 13.184 37
I26 26 0 1.26158e-05
R30 26 27 1.664 0.8 13.312 37
I27 27 0 1.27395e-05
R31 27 28 1.6 0.8 12.8 37
I28 28 0 1.28631e-05
R32 28 29 1.648 0.8 13.184 37
I29 29 0 1.26158e-05
R33 29 30 1.728 0.8 13.824 37
I30 30 0 1.26158e-05
R34 30 31 1.712 0.8 13.696 37
I31 31 0 1.32342e-05
R35 31 32 1.68 0.8 13.44 37
I32 32 0 1.34816e-05
R36 32 33 1.648 0.8 13.184 37
I33 33 0 1.24921e-05
R37 33 34 1.664 0.8 13.312 37
I34 34 0 1.23684e-05
R38 34 35 1.744 0.8 13.952 37
I35 35 0 1.33579e-05
R39 35 36 1.712 0.8 13.696 37
I36 36 0 1.34816e-05
R40 36 37 1.696 0.8 13.568 37
I37 37 0 1.31105e-05
R41 37 38 1.6 0.8 12.8 37
I38 38 0 1.33579e-05
R42 38 39 1.696 0.8 13.568 37
I39 39 0 1.28631e-05
R43 39 40 1.632 0.8 13.056 37
I40 40 0 1.23684e-05
R44 40 401 0.5 10 50 37
*seg: 3
R45 401 41 0.4 20 80 37
R46 50 70 6.16 0.8 49.28 37
I41 41 0 1.31105e-05
R47 41 42 1.68 0.8 13.44 37
I42 42 0 1.24921e-05
R48 42 43 1.664 0.8 13.312 37
I43 43 0 1.27395e-05
R49 43 44 1.632 0.8 13.056 37
I44 44 0 1.27395e-05
R50 44 45 1.696 0.8 13.568 37
I45 45 0 1.23684e-05
R51 45 46 1.744 0.8 13.952 37
I46 46 0 1.24921e-05
R52 46 47 1.616 0.8 12.928 37
I47 47 0 1.31105e-05
R53 47 48 1.616 0.8 12.928 37
I48 48 0 1.23684e-05
R54 48 49 1.68 0.8 13.44 37
I49 49 0 1.34816e-05
R55 49 50 1.664 0.8 13.312 37
I50 50 0 1.29868e-05
R56 50 51 1.648 0.8 13.184 37
I51 51 0 1.28631e-05
R57 51 52 1.744 0.8 13.952 37
I52 52 0 1.33579e-05
R58 52 53 1.616 0.8 12.928 37
I53 53 0 1.26158e-05
R59 53 54 1.616 0.8 12.928 37
I54 54 0 1.28631e-05
R60 54 55 1.712 0.8 13.696 37
I55 55 0 1.26158e-05
R61 55 56 1.68 0.8 13.44 37
I56 56 0 1.31105e-05
R62 56 57 1.648 0.8 13.184 37
I57 57 0 1.31105e-05
R63 57 58 1.664 0.8 13.312 37
I58 58 0 1.24921e-05
R64 58 59 1.728 0.8 13.824 37
I59 59 0 1.27395e-05
R65 59 60 1.664 0.8 13.312 37
I60 60 0 1.23684e-05
R66 60 401 0.5 10 50 37
*seg: 4
R67 401 61 0.4 20 80 37
R68 70 90 6.16 0.8 49.28 37
I61 61 0 1.27395e-05
R69 61 62 1.6 0.8 12.8 37
I62 62 0 1.33579e-05
R70 62 63 1.6 0.8 12.8 37
I63 63 0 1.23684e-05
R71 63 64 1.744 0.8 13.952 37
I64 64 0 1.31105e-05
R72 64 65 1.632 0.8 13.056 37
I65 65 0 1.31105e-05
R73 65 66 1.712 0.8 13.696 37
I66 66 0 1.27395e-05
R74 66 67 1.6 0.8 12.8 37
I67 67 0 1.24921e-05
R75 67 68 1.744 0.8 13.952 37
I68 68 0 1.31105e-05
R76 68 69 1.68 0.8 13.44 37
I69 69 0 1.29868e-05
R77 69 70 1.632 0.8 13.056 37
I70 70 0 1.23684e-05
R78 70 71 1.6 0.8 12.8 37
I71 71 0 1.26158e-05
R79 71 72 1.68 0.8 13.44 37
I72 72 0 1.23684e-05
R80 72 73 1.6 0.8 12.8 37
I73 73 0 1.34816e-05
R81 73 74 1.664 0.8 13.312 37
I74 74 0 1.29868e-05
R82 74 75 1.68 0.8 13.44 37
I75 75 0 1.29868e-05
R83 75 76 1.68 0.8 13.44 37
I76 76 0 1.28631e-05
R84 76 77 1.616 0.8 12.928 37
I77 77 0 1.31105e-05
R85 77 78 1.712 0.8 13.696 37
I78 78 0 1.27395e-05
R86 78 79 1.712 0.8 13.696 37
I79 79 0 1.34816e-05
R87 79 80 1.712 0.8 13.696 37
I80 80 0 1.23684e-05
R88 80 401 0.5 10 50 37
*seg: 5
R89 401 81 0.4 20 80 37
R90 90 110 6.16 0.8 49.28 37
I81 81 0 1.27395e-05
R91 81 82 1.744 0.8 13.952 37
I82 82 0 1.29868e-05
R92 82 83 1.696 0.8 13.568 37
I83 83 0 1.27395e-05
R93 83 84 1.616 0.8 12.928 37
I84 84 0 1.27395e-05
R94 84 85 1.712 0.8 13.696 37
I85 85 0 1.34816e-05
R95 85 86 1.712 0.8 13.696 37
I86 86 0 1.27395e-05
R96 86 87 1.728 0.8 13.824 37
I87 87 0 1.31105e-05
R97 87 88 1.616 0.8 12.928 37
I88 88 0 1.31105e-05
R98 88 89 1.696 0.8 13.568 37
I89 89 0 1.31105e-05
R99 89 90 1.728 0.8 13.824 37
I90 90 0 1.33579e-05
R100 90 91 1.696 0.8 13.568 37
I91 91 0 1.27395e-05
R101 91 92 1.712 0.8 13.696 37
I92 92 0 1.24921e-05
R102 92 93 1.712 0.8 13.696 37
I93 93 0 1.26158e-05
R103 93 94 1.728 0.8 13.824 37
I94 94 0 1.24921e-05
R104 94 95 1.648 0.8 13.184 37
I95 95 0 1.26158e-05
R105 95 96 1.664 0.8 13.312 37
I96 96 0 1.33579e-05
R106 96 97 1.68 0.8 13.44 37
I97 97 0 1.27395e-05
R107 97 98 1.744 0.8 13.952 37
I98 98 0 1.24921e-05
R108 98 99 1.696 0.8 13.568 37
I99 99 0 1.29868e-05
R109 99 100 1.728 0.8 13.824 37
I100 100 0 1.23684e-05
R110 100 401 0.5 10 50 37
*seg: 6
R111 401 101 0.4 20 80 37
R112 110 130 6.16 0.8 49.28 37
I101 101 0 1.27395e-05
R113 101 102 1.68 0.8 13.44 37
I102 102 0 1.28631e-05
R114 102 103 1.744 0.8 13.952 37
I103 103 0 1.27395e-05
R115 103 104 1.616 0.8 12.928 37
I104 104 0 1.24921e-05
R116 104 105 1.696 0.8 13.568 37
I105 105 0 1.29868e-05
R117 105 106 1.696 0.8 13.568 37
I106 106 0 1.27395e-05
R118 106 107 1.6 0.8 12.8 37
I107 107 0 1.23684e-05
R119 107 108 1.744 0.8 13.952 37
I108 108 0 1.34816e-05
R120 108 109 1.6 0.8 12.8 37
I109 109 0 1.32342e-05
R121 109 110 1.728 0.8 13.824 37
I110 110 0 1.29868e-05
R122 110 111 1.712 0.8 13.696 37
I111 111 0 1.26158e-05
R123 111 112 1.664 0.8 13.312 37
I112 112 0 1.24921e-05
R124 112 113 1.632 0.8 13.056 37
I113 113 0 1.26158e-05
R125 113 114 1.664 0.8 13.312 37
I114 114 0 1.28631e-05
R126 114 115 1.68 0.8 13.44 37
I115 115 0 1.32342e-05
R127 115 116 1.696 0.8 13.568 37
I116 116 0 1.33579e-05
R128 116 117 1.68 0.8 13.44 37
I117 117 0 1.31105e-05
R129 117 118 1.696 0.8 13.568 37
I118 118 0 1.26158e-05
R130 118 119 1.616 0.8 12.928 37
I119 119 0 1.33579e-05
R131 119 120 1.648 0.8 13.184 37
I120 120 0 1.23684e-05
R132 120 401 0.5 10 50 37
*seg: 7
R133 401 121 0.4 20 80 37
R134 130 150 6.16 0.8 49.28 37
I121 121 0 1.24921e-05
R135 121 122 1.648 0.8 13.184 37
I122 122 0 1.26158e-05
R136 122 123 1.696 0.8 13.568 37
I123 123 0 1.24921e-05
R137 123 124 1.664 0.8 13.312 37
I124 124 0 1.33579e-05
R138 124 125 1.664 0.8 13.312 37
I125 125 0 1.34816e-05
R139 125 126 1.664 0.8 13.312 37
I126 126 0 1.24921e-05
R140 126 127 1.744 0.8 13.952 37
I127 127 0 1.29868e-05
R141 127 128 1.68 0.8 13.44 37
I128 128 0 1.28631e-05
R142 128 129 1.6 0.8 12.8 37
I129 129 0 1.26158e-05
R143 129 130 1.68 0.8 13.44 37
I130 130 0 1.34816e-05
R144 130 131 1.632 0.8 13.056 37
I131 131 0 1.23684e-05
R145 131 132 1.6 0.8 12.8 37
I132 132 0 1.29868e-05
R146 132 133 1.728 0.8 13.824 37
I133 133 0 1.24921e-05
R147 133 134 1.744 0.8 13.952 37
I134 134 0 1.24921e-05
R148 134 135 1.632 0.8 13.056 37
I135 135 0 1.23684e-05
R149 135 136 1.696 0.8 13.568 37
I136 136 0 1.24921e-05
R150 136 137 1.6 0.8 12.8 37
I137 137 0 1.24921e-05
R151 137 138 1.712 0.8 13.696 37
I138 138 0 1.34816e-05
R152 138 139 1.6 0.8 12.8 37
I139 139 0 1.31105e-05
R153 139 140 1.648 0.8 13.184 37
I140 140 0 1.23684e-05
R154 140 401 0.5 10 50 37
*seg: 8
R155 401 141 0.4 20 80 37
R156 150 170 6.16 0.8 49.28 37
I141 141 0 1.33579e-05
R157 141 142 1.648 0.8 13.184 37
I142 142 0 1.24921e-05
R158 142 143 1.616 0.8 12.928 37
I143 143 0 1.34816e-05
R159 143 144 1.696 0.8 13.568 37
I144 144 0 1.28631e-05
R160 144 145 1.744 0.8 13.952 37
I145 145 0 1.26158e-05
R161 145 146 1.712 0.8 13.696 37
I146 146 0 1.33579e-05
R162 146 147 1.632 0.8 13.056 37
I147 147 0 1.29868e-05
R163 147 148 1.6 0.8 12.8 37
I148 148 0 1.34816e-05
R164 148 149 1.68 0.8 13.44 37
I149 149 0 1.34816e-05
R165 149 150 1.616 0.8 12.928 37
I150 150 0 1.33579e-05
R166 150 151 1.632 0.8 13.056 37
I151 151 0 1.27395e-05
R167 151 152 1.68 0.8 13.44 37
I152 152 0 1.34816e-05
R168 152 153 1.632 0.8 13.056 37
I153 153 0 1.28631e-05
R169 153 154 1.632 0.8 13.056 37
I154 154 0 1.34816e-05
R170 154 155 1.648 0.8 13.184 37
I155 155 0 1.32342e-05
R171 155 156 1.632 0.8 13.056 37
I156 156 0 1.24921e-05
R172 156 157 1.68 0.8 13.44 37
I157 157 0 1.28631e-05
R173 157 158 1.744 0.8 13.952 37
I158 158 0 1.23684e-05
R174 158 159 1.744 0.8 13.952 37
I159 159 0 1.34816e-05
R175 159 160 1.664 0.8 13.312 37
I160 160 0 1.23684e-05
R176 160 401 0.5 10 50 37
*seg: 9
R177 401 161 0.4 20 80 37
R178 170 190 6.16 0.8 49.28 37
I161 161 0 1.26158e-05
R179 161 162 1.664 0.8 13.312 37
I162 162 0 1.23684e-05
R180 162 163 1.744 0.8 13.952 37
I163 163 0 1.29868e-05
R181 163 164 1.632 0.8 13.056 37
I164 164 0 1.29868e-05
R182 164 165 1.696 0.8 13.568 37
I165 165 0 1.27395e-05
R183 165 166 1.744 0.8 13.952 37
I166 166 0 1.33579e-05
R184 166 167 1.712 0.8 13.696 37
I167 167 0 1.34816e-05
R185 167 168 1.712 0.8 13.696 37
I168 168 0 1.28631e-05
R186 168 169 1.712 0.8 13.696 37
I169 169 0 1.23684e-05
R187 169 170 1.632 0.8 13.056 37
I170 170 0 1.34816e-05
R188 170 171 1.744 0.8 13.952 37
I171 171 0 1.34816e-05
R189 171 172 1.648 0.8 13.184 37
I172 172 0 1.31105e-05
R190 172 173 1.632 0.8 13.056 37
I173 173 0 1.34816e-05
R191 173 174 1.648 0.8 13.184 37
I174 174 0 1.34816e-05
R192 174 175 1.696 0.8 13.568 37
I175 175 0 1.32342e-05
R193 175 176 1.616 0.8 12.928 37
I176 176 0 1.24921e-05
R194 176 177 1.6 0.8 12.8 37
I177 177 0 1.27395e-05
R195 177 178 1.68 0.8 13.44 37
I178 178 0 1.34816e-05
R196 178 179 1.6 0.8 12.8 37
I179 179 0 1.32342e-05
R197 179 180 1.664 0.8 13.312 37
I180 180 0 1.23684e-05
R198 180 401 0.5 10 50 37
*seg: 10
R199 401 181 0.4 20 80 37
R200 190 210 6.16 0.8 49.28 37
I181 181 0 1.28631e-05
R201 181 182 1.648 0.8 13.184 37
I182 182 0 1.26158e-05
R202 182 183 1.744 0.8 13.952 37
I183 183 0 1.31105e-05
R203 183 184 1.648 0.8 13.184 37
I184 184 0 1.32342e-05
R204 184 185 1.68 0.8 13.44 37
I185 185 0 1.27395e-05
R205 185 186 1.664 0.8 13.312 37
I186 186 0 1.26158e-05
R206 186 187 1.632 0.8 13.056 37
I187 187 0 1.29868e-05
R207 187 188 1.632 0.8 13.056 37
I188 188 0 1.28631e-05
R208 188 189 1.6 0.8 12.8 37
I189 189 0 1.29868e-05
R209 189 190 1.696 0.8 13.568 37
I190 190 0 1.33579e-05
R210 190 191 1.68 0.8 13.44 37
I191 191 0 1.33579e-05
R211 191 192 1.6 0.8 12.8 37
I192 192 0 1.31105e-05
R212 192 193 1.68 0.8 13.44 37
I193 193 0 1.31105e-05
R213 193 194 1.648 0.8 13.184 37
I194 194 0 1.24921e-05
R214 194 195 1.616 0.8 12.928 37
I195 195 0 1.33579e-05
R215 195 196 1.744 0.8 13.952 37
I196 196 0 1.32342e-05
R216 196 197 1.616 0.8 12.928 37
I197 197 0 1.23684e-05
R217 197 198 1.664 0.8 13.312 37
I198 198 0 1.23684e-05
R218 198 199 1.648 0.8 13.184 37
I199 199 0 1.33579e-05
R219 199 200 1.728 0.8 13.824 37
I200 200 0 1.23684e-05
R220 200 401 0.5 10 50 37
*seg: 11
R221 401 201 0.4 20 80 37
R222 210 230 6.16 0.8 49.28 37
I201 201 0 1.28631e-05
R223 201 202 1.68 0.8 13.44 37
I202 202 0 1.29868e-05
R224 202 203 1.632 0.8 13.056 37
I203 203 0 1.33579e-05
R225 203 204 1.744 0.8 13.952 37
I204 204 0 1.29868e-05
R226 204 205 1.632 0.8 13.056 37
I205 205 0 1.33579e-05
R227 205 206 1.664 0.8 13.312 37
I206 206 0 1.33579e-05
R228 206 207 1.632 0.8 13.056 37
I207 207 0 1.28631e-05
R229 207 208 1.616 0.8 12.928 37
I208 208 0 1.28631e-05
R230 208 209 1.744 0.8 13.952 37
I209 209 0 1.24921e-05
R231 209 210 1.632 0.8 13.056 37
I210 210 0 1.27395e-05
R232 210 211 1.728 0.8 13.824 37
I211 211 0 1.33579e-05
R233 211 212 1.648 0.8 13.184 37
I212 212 0 1.32342e-05
R234 212 213 1.632 0.8 13.056 37
I213 213 0 1.29868e-05
R235 213 214 1.744 0.8 13.952 37
I214 214 0 1.29868e-05
R236 214 215 1.68 0.8 13.44 37
I215 215 0 1.29868e-05
R237 215 216 1.728 0.8 13.824 37
I216 216 0 1.27395e-05
R238 216 217 1.712 0.8 13.696 37
I217 217 0 1.33579e-05
R239 217 218 1.632 0.8 13.056 37
I218 218 0 1.33579e-05
R240 218 219 1.68 0.8 13.44 37
I219 219 0 1.28631e-05
R241 219 220 1.6 0.8 12.8 37
I220 220 0 1.23684e-05
R242 220 401 0.5 10 50 37
*seg: 12
R243 401 221 0.4 20 80 37
R244 230 250 6.16 0.8 49.28 37
I221 221 0 1.24921e-05
R245 221 222 1.68 0.8 13.44 37
I222 222 0 1.24921e-05
R246 222 223 1.616 0.8 12.928 37
I223 223 0 1.33579e-05
R247 223 224 1.664 0.8 13.312 37
I224 224 0 1.32342e-05
R248 224 225 1.68 0.8 13.44 37
I225 225 0 1.34816e-05
R249 225 226 1.68 0.8 13.44 37
I226 226 0 1.23684e-05
R250 226 227 1.712 0.8 13.696 37
I227 227 0 1.34816e-05
R251 227 228 1.712 0.8 13.696 37
I228 228 0 1.34816e-05
R252 228 229 1.744 0.8 13.952 37
I229 229 0 1.24921e-05
R253 229 230 1.712 0.8 13.696 37
I230 230 0 1.32342e-05
R254 230 231 1.744 0.8 13.952 37
I231 231 0 1.31105e-05
R255 231 232 1.712 0.8 13.696 37
I232 232 0 1.29868e-05
R256 232 233 1.616 0.8 12.928 37
I233 233 0 1.32342e-05
R257 233 234 1.744 0.8 13.952 37
I234 234 0 1.29868e-05
R258 234 235 1.68 0.8 13.44 37
I235 235 0 1.31105e-05
R259 235 236 1.648 0.8 13.184 37
I236 236 0 1.31105e-05
R260 236 237 1.6 0.8 12.8 37
I237 237 0 1.33579e-05
R261 237 238 1.6 0.8 12.8 37
I238 238 0 1.34816e-05
R262 238 239 1.728 0.8 13.824 37
I239 239 0 1.26158e-05
R263 239 240 1.744 0.8 13.952 37
I240 240 0 1.23684e-05
R264 240 401 0.5 10 50 37
*seg: 13
R265 401 241 0.4 20 80 37
R266 250 270 6.16 0.8 49.28 37
I241 241 0 1.34816e-05
R267 241 242 1.696 0.8 13.568 37
I242 242 0 1.33579e-05
R268 242 243 1.616 0.8 12.928 37
I243 243 0 1.24921e-05
R269 243 244 1.696 0.8 13.568 37
I244 244 0 1.33579e-05
R270 244 245 1.712 0.8 13.696 37
I245 245 0 1.32342e-05
R271 245 246 1.6 0.8 12.8 37
I246 246 0 1.34816e-05
R272 246 247 1.696 0.8 13.568 37
I247 247 0 1.31105e-05
R273 247 248 1.68 0.8 13.44 37
I248 248 0 1.24921e-05
R274 248 249 1.696 0.8 13.568 37
I249 249 0 1.27395e-05
R275 249 250 1.744 0.8 13.952 37
I250 250 0 1.24921e-05
R276 250 251 1.632 0.8 13.056 37
I251 251 0 1.31105e-05
R277 251 252 1.712 0.8 13.696 37
I252 252 0 1.31105e-05
R278 252 253 1.632 0.8 13.056 37
I253 253 0 1.23684e-05
R279 253 254 1.664 0.8 13.312 37
I254 254 0 1.27395e-05
R280 254 255 1.744 0.8 13.952 37
I255 255 0 1.34816e-05
R281 255 256 1.632 0.8 13.056 37
I256 256 0 1.26158e-05
R282 256 257 1.712 0.8 13.696 37
I257 257 0 1.33579e-05
R283 257 258 1.632 0.8 13.056 37
I258 258 0 1.26158e-05
R284 258 259 1.632 0.8 13.056 37
I259 259 0 1.29868e-05
R285 259 260 1.744 0.8 13.952 37
I260 260 0 1.23684e-05
R286 260 401 0.5 10 50 37
*seg: 14
R287 401 261 0.4 20 80 37
R288 270 290 6.16 0.8 49.28 37
I261 261 0 1.31105e-05
R289 261 262 1.664 0.8 13.312 37
I262 262 0 1.23684e-05
R290 262 263 1.68 0.8 13.44 37
I263 263 0 1.34816e-05
R291 263 264 1.68 0.8 13.44 37
I264 264 0 1.27395e-05
R292 264 265 1.616 0.8 12.928 37
I265 265 0 1.28631e-05
R293 265 266 1.744 0.8 13.952 37
I266 266 0 1.23684e-05
R294 266 267 1.616 0.8 12.928 37
I267 267 0 1.28631e-05
R295 267 268 1.68 0.8 13.44 37
I268 268 0 1.28631e-05
R296 268 269 1.6 0.8 12.8 37
I269 269 0 1.34816e-05
R297 269 270 1.616 0.8 12.928 37
I270 270 0 1.27395e-05
R298 270 271 1.616 0.8 12.928 37
I271 271 0 1.34816e-05
R299 271 272 1.6 0.8 12.8 37
I272 272 0 1.28631e-05
R300 272 273 1.712 0.8 13.696 37
I273 273 0 1.27395e-05
R301 273 274 1.712 0.8 13.696 37
I274 274 0 1.33579e-05
R302 274 275 1.6 0.8 12.8 37
I275 275 0 1.29868e-05
R303 275 276 1.6 0.8 12.8 37
I276 276 0 1.34816e-05
R304 276 277 1.696 0.8 13.568 37
I277 277 0 1.31105e-05
R305 277 278 1.712 0.8 13.696 37
I278 278 0 1.26158e-05
R306 278 279 1.648 0.8 13.184 37
I279 279 0 1.32342e-05
R307 279 280 1.632 0.8 13.056 37
I280 280 0 1.23684e-05
R308 280 401 0.5 10 50 37
*seg: 15
R309 401 281 0.4 20 80 37
R310 290 310 6.16 0.8 49.28 37
I281 281 0 1.31105e-05
R311 281 282 1.632 0.8 13.056 37
I282 282 0 1.34816e-05
R312 282 283 1.664 0.8 13.312 37
I283 283 0 1.26158e-05
R313 283 284 1.664 0.8 13.312 37
I284 284 0 1.29868e-05
R314 284 285 1.728 0.8 13.824 37
I285 285 0 1.28631e-05
R315 285 286 1.712 0.8 13.696 37
I286 286 0 1.31105e-05
R316 286 287 1.632 0.8 13.056 37
I287 287 0 1.28631e-05
R317 287 288 1.696 0.8 13.568 37
I288 288 0 1.26158e-05
R318 288 289 1.68 0.8 13.44 37
I289 289 0 1.33579e-05
R319 289 290 1.632 0.8 13.056 37
I290 290 0 1.23684e-05
R320 290 291 1.616 0.8 12.928 37
I291 291 0 1.34816e-05
R321 291 292 1.712 0.8 13.696 37
I292 292 0 1.28631e-05
R322 292 293 1.664 0.8 13.312 37
I293 293 0 1.29868e-05
R323 293 294 1.712 0.8 13.696 37
I294 294 0 1.29868e-05
R324 294 295 1.6 0.8 12.8 37
I295 295 0 1.33579e-05
R325 295 296 1.68 0.8 13.44 37
I296 296 0 1.23684e-05
R326 296 297 1.616 0.8 12.928 37
I297 297 0 1.34816e-05
R327 297 298 1.712 0.8 13.696 37
I298 298 0 1.32342e-05
R328 298 299 1.6 0.8 12.8 37
I299 299 0 1.32342e-05
R329 299 300 1.712 0.8 13.696 37
I300 300 0 1.23684e-05
R330 300 401 0.5 10 50 37
*seg: 16
R331 401 301 0.4 20 80 37
R332 310 330 6.16 0.8 49.28 37
I301 301 0 1.31105e-05
R333 301 302 1.648 0.8 13.184 37
I302 302 0 1.27395e-05
R334 302 303 1.712 0.8 13.696 37
I303 303 0 1.32342e-05
R335 303 304 1.68 0.8 13.44 37
I304 304 0 1.24921e-05
R336 304 305 1.68 0.8 13.44 37
I305 305 0 1.31105e-05
R337 305 306 1.712 0.8 13.696 37
I306 306 0 1.24921e-05
R338 306 307 1.616 0.8 12.928 37
I307 307 0 1.23684e-05
R339 307 308 1.696 0.8 13.568 37
I308 308 0 1.34816e-05
R340 308 309 1.68 0.8 13.44 37
I309 309 0 1.32342e-05
R341 309 310 1.728 0.8 13.824 37
I310 310 0 1.27395e-05
R342 310 311 1.616 0.8 12.928 37
I311 311 0 1.31105e-05
R343 311 312 1.664 0.8 13.312 37
I312 312 0 1.33579e-05
R344 312 313 1.632 0.8 13.056 37
I313 313 0 1.32342e-05
R345 313 314 1.664 0.8 13.312 37
I314 314 0 1.31105e-05
R346 314 315 1.68 0.8 13.44 37
I315 315 0 1.29868e-05
R347 315 316 1.632 0.8 13.056 37
I316 316 0 1.31105e-05
R348 316 317 1.68 0.8 13.44 37
I317 317 0 1.29868e-05
R349 317 318 1.632 0.8 13.056 37
I318 318 0 1.33579e-05
R350 318 319 1.68 0.8 13.44 37
I319 319 0 1.32342e-05
R351 319 320 1.632 0.8 13.056 37
I320 320 0 1.23684e-05
R352 320 401 0.5 10 50 37
*seg: 17
R353 401 321 0.4 20 80 37
R354 330 350 6.16 0.8 49.28 37
I321 321 0 1.23684e-05
R355 321 322 1.712 0.8 13.696 37
I322 322 0 1.26158e-05
R356 322 323 1.632 0.8 13.056 37
I323 323 0 1.27395e-05
R357 323 324 1.728 0.8 13.824 37
I324 324 0 1.29868e-05
R358 324 325 1.6 0.8 12.8 37
I325 325 0 1.33579e-05
R359 325 326 1.696 0.8 13.568 37
I326 326 0 1.26158e-05
R360 326 327 1.632 0.8 13.056 37
I327 327 0 1.28631e-05
R361 327 328 1.712 0.8 13.696 37
I328 328 0 1.29868e-05
R362 328 329 1.744 0.8 13.952 37
I329 329 0 1.28631e-05
R363 329 330 1.648 0.8 13.184 37
I330 330 0 1.34816e-05
R364 330 331 1.68 0.8 13.44 37
I331 331 0 1.29868e-05
R365 331 332 1.712 0.8 13.696 37
I332 332 0 1.24921e-05
R366 332 333 1.648 0.8 13.184 37
I333 333 0 1.32342e-05
R367 333 334 1.616 0.8 12.928 37
I334 334 0 1.32342e-05
R368 334 335 1.712 0.8 13.696 37
I335 335 0 1.26158e-05
R369 335 336 1.664 0.8 13.312 37
I336 336 0 1.24921e-05
R370 336 337 1.712 0.8 13.696 37
I337 337 0 1.27395e-05
R371 337 338 1.712 0.8 13.696 37
I338 338 0 1.32342e-05
R372 338 339 1.648 0.8 13.184 37
I339 339 0 1.24921e-05
R373 339 340 1.728 0.8 13.824 37
I340 340 0 1.23684e-05
R374 340 401 0.5 10 50 37
*seg: 18
R375 401 341 0.4 20 80 37
R376 350 370 6.16 0.8 49.28 37
I341 341 0 1.34816e-05
R377 341 342 1.728 0.8 13.824 37
I342 342 0 1.31105e-05
R378 342 343 1.632 0.8 13.056 37
I343 343 0 1.23684e-05
R379 343 344 1.632 0.8 13.056 37
I344 344 0 1.33579e-05
R380 344 345 1.68 0.8 13.44 37
I345 345 0 1.26158e-05
R381 345 346 1.696 0.8 13.568 37
I346 346 0 1.34816e-05
R382 346 347 1.664 0.8 13.312 37
I347 347 0 1.31105e-05
R383 347 348 1.744 0.8 13.952 37
I348 348 0 1.27395e-05
R384 348 349 1.712 0.8 13.696 37
I349 349 0 1.23684e-05
R385 349 350 1.728 0.8 13.824 37
I350 350 0 1.33579e-05
R386 350 351 1.712 0.8 13.696 37
I351 351 0 1.29868e-05
R387 351 352 1.632 0.8 13.056 37
I352 352 0 1.23684e-05
R388 352 353 1.648 0.8 13.184 37
I353 353 0 1.27395e-05
R389 353 354 1.616 0.8 12.928 37
I354 354 0 1.24921e-05
R390 354 355 1.632 0.8 13.056 37
I355 355 0 1.28631e-05
R391 355 356 1.68 0.8 13.44 37
I356 356 0 1.31105e-05
R392 356 357 1.728 0.8 13.824 37
I357 357 0 1.24921e-05
R393 357 358 1.632 0.8 13.056 37
I358 358 0 1.24921e-05
R394 358 359 1.744 0.8 13.952 37
I359 359 0 1.34816e-05
R395 359 360 1.632 0.8 13.056 37
I360 360 0 1.23684e-05
R396 360 401 0.5 10 50 37
*seg: 19
R397 401 361 0.4 20 80 37
R398 370 390 6.16 0.8 49.28 37
I361 361 0 1.34816e-05
R399 361 362 1.728 0.8 13.824 37
I362 362 0 1.27395e-05
R400 362 363 1.712 0.8 13.696 37
I363 363 0 1.24921e-05
R401 363 364 1.664 0.8 13.312 37
I364 364 0 1.24921e-05
R402 364 365 1.664 0.8 13.312 37
I365 365 0 1.32342e-05
R403 365 366 1.68 0.8 13.44 37
I366 366 0 1.27395e-05
R404 366 367 1.616 0.8 12.928 37
I367 367 0 1.24921e-05
R405 367 368 1.664 0.8 13.312 37
I368 368 0 1.28631e-05
R406 368 369 1.648 0.8 13.184 37
I369 369 0 1.29868e-05
R407 369 370 1.744 0.8 13.952 37
I370 370 0 1.26158e-05
R408 370 371 1.616 0.8 12.928 37
I371 371 0 1.34816e-05
R409 371 372 1.616 0.8 12.928 37
I372 372 0 1.27395e-05
R410 372 373 1.664 0.8 13.312 37
I373 373 0 1.33579e-05
R411 373 374 1.616 0.8 12.928 37
I374 374 0 1.31105e-05
R412 374 375 1.648 0.8 13.184 37
I375 375 0 1.28631e-05
R413 375 376 1.6 0.8 12.8 37
I376 376 0 1.29868e-05
R414 376 377 1.696 0.8 13.568 37
I377 377 0 1.33579e-05
R415 377 378 1.6 0.8 12.8 37
I378 378 0 1.26158e-05
R416 378 379 1.648 0.8 13.184 37
I379 379 0 1.28631e-05
R417 379 380 1.712 0.8 13.696 37
I380 380 0 1.23684e-05
R418 380 401 0.5 10 50 37
*seg: 20
R419 401 381 0.4 20 80 37
I381 381 0 1.27395e-05
R420 381 382 1.648 0.8 13.184 37
I382 382 0 1.27395e-05
R421 382 383 1.696 0.8 13.568 37
I383 383 0 1.28631e-05
R422 383 384 1.616 0.8 12.928 37
I384 384 0 1.24921e-05
R423 384 385 1.648 0.8 13.184 37
I385 385 0 1.28631e-05
R424 385 386 1.728 0.8 13.824 37
I386 386 0 1.32342e-05
R425 386 387 1.728 0.8 13.824 37
I387 387 0 1.33579e-05
R426 387 388 1.616 0.8 12.928 37
I388 388 0 1.24921e-05
R427 388 389 1.744 0.8 13.952 37
I389 389 0 1.34816e-05
R428 389 390 1.728 0.8 13.824 37
I390 390 0 1.29868e-05
R429 390 391 1.632 0.8 13.056 37
I391 391 0 1.28631e-05
R430 391 392 1.744 0.8 13.952 37
I392 392 0 1.23684e-05
R431 392 393 1.664 0.8 13.312 37
I393 393 0 1.28631e-05
R432 393 394 1.744 0.8 13.952 37
I394 394 0 1.23684e-05
R433 394 395 1.744 0.8 13.952 37
I395 395 0 1.34816e-05
R434 395 396 1.6 0.8 12.8 37
I396 396 0 1.24921e-05
R435 396 397 1.664 0.8 13.312 37
I397 397 0 1.26158e-05
R436 397 398 1.712 0.8 13.696 37
I398 398 0 1.24921e-05
R437 398 399 1.728 0.8 13.824 37
I399 399 0 1.26158e-05
R438 399 400 1.728 0.8 13.824 37
I400 400 0 1.23684e-05
R439 400 401 0.5 10 50 37
V1 401 0 5

.op
.end
