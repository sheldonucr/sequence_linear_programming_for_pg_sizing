* Wire sized spice-like netlist file generated by PGOPT.
* Copyright 1999-2002, X.D. Sheldon Tan.

* num_node: 17
* matrix_size: 18
* --- Format ---
* Rxxx, n1, n2, value, width, length, lay_index
* Ixxx(Vxxx), n1, n2, value

V1 17 0 5
R23 16 17 12.5 0.4 50 37
I16 16 0 1.23684e-05
R22 15 16 3.232 0.4 12.928 37
I15 15 0 1.29868e-05
R21 14 15 3.456 0.4 13.824 37
I14 14 0 1.31105e-05
R20 13 14 2.8323 0.479046 13.568 37
I13 13 0 1.32342e-05
R19 17 13 11.7919 0.678429 80 37
R18 12 17 12.2461 0.408293 50 37
I12 12 0 1.23684e-05
R17 11 12 3.296 0.4 13.184 37
I11 11 0 1.34816e-05
R16 10 11 3.296 0.4 13.184 37
I10 10 0 1.29868e-05
R15 9 10 2.67203 0.479037 12.8 37
I9 9 0 1.28631e-05
R14 10 14 12.32 0.4 49.28 37
R13 17 9 11.7145 0.682916 80 37
R12 8 17 12.5 0.4 50 37
I8 8 0 1.23684e-05
R11 7 8 3.424 0.4 13.696 37
I7 7 0 1.34816e-05
R10 6 7 3.392 0.4 13.568 37
I6 6 0 1.26158e-05
R9 5 6 2.91238 0.479059 13.952 37
I5 5 0 1.23684e-05
R8 6 10 12.32 0.4 49.28 37
R7 17 5 12.1851 0.656539 80 37
R6 4 17 12.5 0.4 50 37
I4 4 0 1.23684e-05
R5 3 4 3.424 0.4 13.696 37
I3 3 0 1.24921e-05
R4 2 3 3.36 0.4 13.44 37
I2 2 0 1.27395e-05
R3 1 2 2.88574 0.479045 13.824 37
I1 1 0 1.33579e-05
R2 2 6 12.32 0.4 49.28 37
R1 17 1 11.8384 0.675769 80 37
