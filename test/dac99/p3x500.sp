num_node 1501
matrix_size 1502

* 3 x 500 ground network
*seg: 1
R1 1501 1 0.4 20 80 37
R2 250 750 6.16 0.8 49.28 37
I1 1 0 1.33579e-05
R3 1 2 1.728 0.8 13.824 37
I2 2 0 1.27395e-05
R4 2 3 1.68 0.8 13.44 37
I3 3 0 1.24921e-05
R5 3 4 1.712 0.8 13.696 37
I4 4 0 1.23684e-05
R6 4 5 1.744 0.8 13.952 37
I5 5 0 1.26158e-05
R7 5 6 1.696 0.8 13.568 37
I6 6 0 1.34816e-05
R8 6 7 1.712 0.8 13.696 37
I7 7 0 1.28631e-05
R9 7 8 1.6 0.8 12.8 37
I8 8 0 1.29868e-05
R10 8 9 1.648 0.8 13.184 37
I9 9 0 1.34816e-05
R11 9 10 1.648 0.8 13.184 37
I10 10 0 1.32342e-05
R12 10 11 1.696 0.8 13.568 37
I11 11 0 1.31105e-05
R13 11 12 1.728 0.8 13.824 37
I12 12 0 1.29868e-05
R14 12 13 1.616 0.8 12.928 37
I13 13 0 1.32342e-05
R15 13 14 1.664 0.8 13.312 37
I14 14 0 1.24921e-05
R16 14 15 1.68 0.8 13.44 37
I15 15 0 1.26158e-05
R17 15 16 1.696 0.8 13.568 37
I16 16 0 1.28631e-05
R18 16 17 1.68 0.8 13.44 37
I17 17 0 1.28631e-05
R19 17 18 1.632 0.8 13.056 37
I18 18 0 1.24921e-05
R20 18 19 1.712 0.8 13.696 37
I19 19 0 1.28631e-05
R21 19 20 1.648 0.8 13.184 37
I20 20 0 1.24921e-05
R22 20 21 1.696 0.8 13.568 37
I21 21 0 1.33579e-05
R23 21 22 1.728 0.8 13.824 37
I22 22 0 1.29868e-05
R24 22 23 1.648 0.8 13.184 37
I23 23 0 1.32342e-05
R25 23 24 1.696 0.8 13.568 37
I24 24 0 1.29868e-05
R26 24 25 1.648 0.8 13.184 37
I25 25 0 1.26158e-05
R27 25 26 1.664 0.8 13.312 37
I26 26 0 1.27395e-05
R28 26 27 1.6 0.8 12.8 37
I27 27 0 1.28631e-05
R29 27 28 1.648 0.8 13.184 37
I28 28 0 1.26158e-05
R30 28 29 1.728 0.8 13.824 37
I29 29 0 1.26158e-05
R31 29 30 1.712 0.8 13.696 37
I30 30 0 1.32342e-05
R32 30 31 1.68 0.8 13.44 37
I31 31 0 1.34816e-05
R33 31 32 1.648 0.8 13.184 37
I32 32 0 1.24921e-05
R34 32 33 1.664 0.8 13.312 37
I33 33 0 1.23684e-05
R35 33 34 1.744 0.8 13.952 37
I34 34 0 1.33579e-05
R36 34 35 1.712 0.8 13.696 37
I35 35 0 1.34816e-05
R37 35 36 1.696 0.8 13.568 37
I36 36 0 1.31105e-05
R38 36 37 1.6 0.8 12.8 37
I37 37 0 1.33579e-05
R39 37 38 1.696 0.8 13.568 37
I38 38 0 1.28631e-05
R40 38 39 1.632 0.8 13.056 37
I39 39 0 1.31105e-05
R41 39 40 1.68 0.8 13.44 37
I40 40 0 1.24921e-05
R42 40 41 1.664 0.8 13.312 37
I41 41 0 1.27395e-05
R43 41 42 1.632 0.8 13.056 37
I42 42 0 1.27395e-05
R44 42 43 1.696 0.8 13.568 37
I43 43 0 1.23684e-05
R45 43 44 1.744 0.8 13.952 37
I44 44 0 1.24921e-05
R46 44 45 1.616 0.8 12.928 37
I45 45 0 1.31105e-05
R47 45 46 1.616 0.8 12.928 37
I46 46 0 1.23684e-05
R48 46 47 1.68 0.8 13.44 37
I47 47 0 1.34816e-05
R49 47 48 1.664 0.8 13.312 37
I48 48 0 1.29868e-05
R50 48 49 1.648 0.8 13.184 37
I49 49 0 1.28631e-05
R51 49 50 1.744 0.8 13.952 37
I50 50 0 1.33579e-05
R52 50 51 1.616 0.8 12.928 37
I51 51 0 1.26158e-05
R53 51 52 1.616 0.8 12.928 37
I52 52 0 1.28631e-05
R54 52 53 1.712 0.8 13.696 37
I53 53 0 1.26158e-05
R55 53 54 1.68 0.8 13.44 37
I54 54 0 1.31105e-05
R56 54 55 1.648 0.8 13.184 37
I55 55 0 1.31105e-05
R57 55 56 1.664 0.8 13.312 37
I56 56 0 1.24921e-05
R58 56 57 1.728 0.8 13.824 37
I57 57 0 1.27395e-05
R59 57 58 1.664 0.8 13.312 37
I58 58 0 1.27395e-05
R60 58 59 1.6 0.8 12.8 37
I59 59 0 1.33579e-05
R61 59 60 1.6 0.8 12.8 37
I60 60 0 1.23684e-05
R62 60 61 1.744 0.8 13.952 37
I61 61 0 1.31105e-05
R63 61 62 1.632 0.8 13.056 37
I62 62 0 1.31105e-05
R64 62 63 1.712 0.8 13.696 37
I63 63 0 1.27395e-05
R65 63 64 1.6 0.8 12.8 37
I64 64 0 1.24921e-05
R66 64 65 1.744 0.8 13.952 37
I65 65 0 1.31105e-05
R67 65 66 1.68 0.8 13.44 37
I66 66 0 1.29868e-05
R68 66 67 1.632 0.8 13.056 37
I67 67 0 1.23684e-05
R69 67 68 1.6 0.8 12.8 37
I68 68 0 1.26158e-05
R70 68 69 1.68 0.8 13.44 37
I69 69 0 1.23684e-05
R71 69 70 1.6 0.8 12.8 37
I70 70 0 1.34816e-05
R72 70 71 1.664 0.8 13.312 37
I71 71 0 1.29868e-05
R73 71 72 1.68 0.8 13.44 37
I72 72 0 1.29868e-05
R74 72 73 1.68 0.8 13.44 37
I73 73 0 1.28631e-05
R75 73 74 1.616 0.8 12.928 37
I74 74 0 1.31105e-05
R76 74 75 1.712 0.8 13.696 37
I75 75 0 1.27395e-05
R77 75 76 1.712 0.8 13.696 37
I76 76 0 1.34816e-05
R78 76 77 1.712 0.8 13.696 37
I77 77 0 1.27395e-05
R79 77 78 1.744 0.8 13.952 37
I78 78 0 1.29868e-05
R80 78 79 1.696 0.8 13.568 37
I79 79 0 1.27395e-05
R81 79 80 1.616 0.8 12.928 37
I80 80 0 1.27395e-05
R82 80 81 1.712 0.8 13.696 37
I81 81 0 1.34816e-05
R83 81 82 1.712 0.8 13.696 37
I82 82 0 1.27395e-05
R84 82 83 1.728 0.8 13.824 37
I83 83 0 1.31105e-05
R85 83 84 1.616 0.8 12.928 37
I84 84 0 1.31105e-05
R86 84 85 1.696 0.8 13.568 37
I85 85 0 1.31105e-05
R87 85 86 1.728 0.8 13.824 37
I86 86 0 1.33579e-05
R88 86 87 1.696 0.8 13.568 37
I87 87 0 1.27395e-05
R89 87 88 1.712 0.8 13.696 37
I88 88 0 1.24921e-05
R90 88 89 1.712 0.8 13.696 37
I89 89 0 1.26158e-05
R91 89 90 1.728 0.8 13.824 37
I90 90 0 1.24921e-05
R92 90 91 1.648 0.8 13.184 37
I91 91 0 1.26158e-05
R93 91 92 1.664 0.8 13.312 37
I92 92 0 1.33579e-05
R94 92 93 1.68 0.8 13.44 37
I93 93 0 1.27395e-05
R95 93 94 1.744 0.8 13.952 37
I94 94 0 1.24921e-05
R96 94 95 1.696 0.8 13.568 37
I95 95 0 1.29868e-05
R97 95 96 1.728 0.8 13.824 37
I96 96 0 1.27395e-05
R98 96 97 1.68 0.8 13.44 37
I97 97 0 1.28631e-05
R99 97 98 1.744 0.8 13.952 37
I98 98 0 1.27395e-05
R100 98 99 1.616 0.8 12.928 37
I99 99 0 1.24921e-05
R101 99 100 1.696 0.8 13.568 37
I100 100 0 1.29868e-05
R102 100 101 1.696 0.8 13.568 37
I101 101 0 1.27395e-05
R103 101 102 1.6 0.8 12.8 37
I102 102 0 1.23684e-05
R104 102 103 1.744 0.8 13.952 37
I103 103 0 1.34816e-05
R105 103 104 1.6 0.8 12.8 37
I104 104 0 1.32342e-05
R106 104 105 1.728 0.8 13.824 37
I105 105 0 1.29868e-05
R107 105 106 1.712 0.8 13.696 37
I106 106 0 1.26158e-05
R108 106 107 1.664 0.8 13.312 37
I107 107 0 1.24921e-05
R109 107 108 1.632 0.8 13.056 37
I108 108 0 1.26158e-05
R110 108 109 1.664 0.8 13.312 37
I109 109 0 1.28631e-05
R111 109 110 1.68 0.8 13.44 37
I110 110 0 1.32342e-05
R112 110 111 1.696 0.8 13.568 37
I111 111 0 1.33579e-05
R113 111 112 1.68 0.8 13.44 37
I112 112 0 1.31105e-05
R114 112 113 1.696 0.8 13.568 37
I113 113 0 1.26158e-05
R115 113 114 1.616 0.8 12.928 37
I114 114 0 1.33579e-05
R116 114 115 1.648 0.8 13.184 37
I115 115 0 1.24921e-05
R117 115 116 1.648 0.8 13.184 37
I116 116 0 1.26158e-05
R118 116 117 1.696 0.8 13.568 37
I117 117 0 1.24921e-05
R119 117 118 1.664 0.8 13.312 37
I118 118 0 1.33579e-05
R120 118 119 1.664 0.8 13.312 37
I119 119 0 1.34816e-05
R121 119 120 1.664 0.8 13.312 37
I120 120 0 1.24921e-05
R122 120 121 1.744 0.8 13.952 37
I121 121 0 1.29868e-05
R123 121 122 1.68 0.8 13.44 37
I122 122 0 1.28631e-05
R124 122 123 1.6 0.8 12.8 37
I123 123 0 1.26158e-05
R125 123 124 1.68 0.8 13.44 37
I124 124 0 1.34816e-05
R126 124 125 1.632 0.8 13.056 37
I125 125 0 1.23684e-05
R127 125 126 1.6 0.8 12.8 37
I126 126 0 1.29868e-05
R128 126 127 1.728 0.8 13.824 37
I127 127 0 1.24921e-05
R129 127 128 1.744 0.8 13.952 37
I128 128 0 1.24921e-05
R130 128 129 1.632 0.8 13.056 37
I129 129 0 1.23684e-05
R131 129 130 1.696 0.8 13.568 37
I130 130 0 1.24921e-05
R132 130 131 1.6 0.8 12.8 37
I131 131 0 1.24921e-05
R133 131 132 1.712 0.8 13.696 37
I132 132 0 1.34816e-05
R134 132 133 1.6 0.8 12.8 37
I133 133 0 1.31105e-05
R135 133 134 1.648 0.8 13.184 37
I134 134 0 1.33579e-05
R136 134 135 1.648 0.8 13.184 37
I135 135 0 1.24921e-05
R137 135 136 1.616 0.8 12.928 37
I136 136 0 1.34816e-05
R138 136 137 1.696 0.8 13.568 37
I137 137 0 1.28631e-05
R139 137 138 1.744 0.8 13.952 37
I138 138 0 1.26158e-05
R140 138 139 1.712 0.8 13.696 37
I139 139 0 1.33579e-05
R141 139 140 1.632 0.8 13.056 37
I140 140 0 1.29868e-05
R142 140 141 1.6 0.8 12.8 37
I141 141 0 1.34816e-05
R143 141 142 1.68 0.8 13.44 37
I142 142 0 1.34816e-05
R144 142 143 1.616 0.8 12.928 37
I143 143 0 1.33579e-05
R145 143 144 1.632 0.8 13.056 37
I144 144 0 1.27395e-05
R146 144 145 1.68 0.8 13.44 37
I145 145 0 1.34816e-05
R147 145 146 1.632 0.8 13.056 37
I146 146 0 1.28631e-05
R148 146 147 1.632 0.8 13.056 37
I147 147 0 1.34816e-05
R149 147 148 1.648 0.8 13.184 37
I148 148 0 1.32342e-05
R150 148 149 1.632 0.8 13.056 37
I149 149 0 1.24921e-05
R151 149 150 1.68 0.8 13.44 37
I150 150 0 1.28631e-05
R152 150 151 1.744 0.8 13.952 37
I151 151 0 1.23684e-05
R153 151 152 1.744 0.8 13.952 37
I152 152 0 1.34816e-05
R154 152 153 1.664 0.8 13.312 37
I153 153 0 1.26158e-05
R155 153 154 1.664 0.8 13.312 37
I154 154 0 1.23684e-05
R156 154 155 1.744 0.8 13.952 37
I155 155 0 1.29868e-05
R157 155 156 1.632 0.8 13.056 37
I156 156 0 1.29868e-05
R158 156 157 1.696 0.8 13.568 37
I157 157 0 1.27395e-05
R159 157 158 1.744 0.8 13.952 37
I158 158 0 1.33579e-05
R160 158 159 1.712 0.8 13.696 37
I159 159 0 1.34816e-05
R161 159 160 1.712 0.8 13.696 37
I160 160 0 1.28631e-05
R162 160 161 1.712 0.8 13.696 37
I161 161 0 1.23684e-05
R163 161 162 1.632 0.8 13.056 37
I162 162 0 1.34816e-05
R164 162 163 1.744 0.8 13.952 37
I163 163 0 1.34816e-05
R165 163 164 1.648 0.8 13.184 37
I164 164 0 1.31105e-05
R166 164 165 1.632 0.8 13.056 37
I165 165 0 1.34816e-05
R167 165 166 1.648 0.8 13.184 37
I166 166 0 1.34816e-05
R168 166 167 1.696 0.8 13.568 37
I167 167 0 1.32342e-05
R169 167 168 1.616 0.8 12.928 37
I168 168 0 1.24921e-05
R170 168 169 1.6 0.8 12.8 37
I169 169 0 1.27395e-05
R171 169 170 1.68 0.8 13.44 37
I170 170 0 1.34816e-05
R172 170 171 1.6 0.8 12.8 37
I171 171 0 1.32342e-05
R173 171 172 1.664 0.8 13.312 37
I172 172 0 1.28631e-05
R174 172 173 1.648 0.8 13.184 37
I173 173 0 1.26158e-05
R175 173 174 1.744 0.8 13.952 37
I174 174 0 1.31105e-05
R176 174 175 1.648 0.8 13.184 37
I175 175 0 1.32342e-05
R177 175 176 1.68 0.8 13.44 37
I176 176 0 1.27395e-05
R178 176 177 1.664 0.8 13.312 37
I177 177 0 1.26158e-05
R179 177 178 1.632 0.8 13.056 37
I178 178 0 1.29868e-05
R180 178 179 1.632 0.8 13.056 37
I179 179 0 1.28631e-05
R181 179 180 1.6 0.8 12.8 37
I180 180 0 1.29868e-05
R182 180 181 1.696 0.8 13.568 37
I181 181 0 1.33579e-05
R183 181 182 1.68 0.8 13.44 37
I182 182 0 1.33579e-05
R184 182 183 1.6 0.8 12.8 37
I183 183 0 1.31105e-05
R185 183 184 1.68 0.8 13.44 37
I184 184 0 1.31105e-05
R186 184 185 1.648 0.8 13.184 37
I185 185 0 1.24921e-05
R187 185 186 1.616 0.8 12.928 37
I186 186 0 1.33579e-05
R188 186 187 1.744 0.8 13.952 37
I187 187 0 1.32342e-05
R189 187 188 1.616 0.8 12.928 37
I188 188 0 1.23684e-05
R190 188 189 1.664 0.8 13.312 37
I189 189 0 1.23684e-05
R191 189 190 1.648 0.8 13.184 37
I190 190 0 1.33579e-05
R192 190 191 1.728 0.8 13.824 37
I191 191 0 1.28631e-05
R193 191 192 1.68 0.8 13.44 37
I192 192 0 1.29868e-05
R194 192 193 1.632 0.8 13.056 37
I193 193 0 1.33579e-05
R195 193 194 1.744 0.8 13.952 37
I194 194 0 1.29868e-05
R196 194 195 1.632 0.8 13.056 37
I195 195 0 1.33579e-05
R197 195 196 1.664 0.8 13.312 37
I196 196 0 1.33579e-05
R198 196 197 1.632 0.8 13.056 37
I197 197 0 1.28631e-05
R199 197 198 1.616 0.8 12.928 37
I198 198 0 1.28631e-05
R200 198 199 1.744 0.8 13.952 37
I199 199 0 1.24921e-05
R201 199 200 1.632 0.8 13.056 37
I200 200 0 1.27395e-05
R202 200 201 1.728 0.8 13.824 37
I201 201 0 1.33579e-05
R203 201 202 1.648 0.8 13.184 37
I202 202 0 1.32342e-05
R204 202 203 1.632 0.8 13.056 37
I203 203 0 1.29868e-05
R205 203 204 1.744 0.8 13.952 37
I204 204 0 1.29868e-05
R206 204 205 1.68 0.8 13.44 37
I205 205 0 1.29868e-05
R207 205 206 1.728 0.8 13.824 37
I206 206 0 1.27395e-05
R208 206 207 1.712 0.8 13.696 37
I207 207 0 1.33579e-05
R209 207 208 1.632 0.8 13.056 37
I208 208 0 1.33579e-05
R210 208 209 1.68 0.8 13.44 37
I209 209 0 1.28631e-05
R211 209 210 1.6 0.8 12.8 37
I210 210 0 1.24921e-05
R212 210 211 1.68 0.8 13.44 37
I211 211 0 1.24921e-05
R213 211 212 1.616 0.8 12.928 37
I212 212 0 1.33579e-05
R214 212 213 1.664 0.8 13.312 37
I213 213 0 1.32342e-05
R215 213 214 1.68 0.8 13.44 37
I214 214 0 1.34816e-05
R216 214 215 1.68 0.8 13.44 37
I215 215 0 1.23684e-05
R217 215 216 1.712 0.8 13.696 37
I216 216 0 1.34816e-05
R218 216 217 1.712 0.8 13.696 37
I217 217 0 1.34816e-05
R219 217 218 1.744 0.8 13.952 37
I218 218 0 1.24921e-05
R220 218 219 1.712 0.8 13.696 37
I219 219 0 1.32342e-05
R221 219 220 1.744 0.8 13.952 37
I220 220 0 1.31105e-05
R222 220 221 1.712 0.8 13.696 37
I221 221 0 1.29868e-05
R223 221 222 1.616 0.8 12.928 37
I222 222 0 1.32342e-05
R224 222 223 1.744 0.8 13.952 37
I223 223 0 1.29868e-05
R225 223 224 1.68 0.8 13.44 37
I224 224 0 1.31105e-05
R226 224 225 1.648 0.8 13.184 37
I225 225 0 1.31105e-05
R227 225 226 1.6 0.8 12.8 37
I226 226 0 1.33579e-05
R228 226 227 1.6 0.8 12.8 37
I227 227 0 1.34816e-05
R229 227 228 1.728 0.8 13.824 37
I228 228 0 1.26158e-05
R230 228 229 1.744 0.8 13.952 37
I229 229 0 1.34816e-05
R231 229 230 1.696 0.8 13.568 37
I230 230 0 1.33579e-05
R232 230 231 1.616 0.8 12.928 37
I231 231 0 1.24921e-05
R233 231 232 1.696 0.8 13.568 37
I232 232 0 1.33579e-05
R234 232 233 1.712 0.8 13.696 37
I233 233 0 1.32342e-05
R235 233 234 1.6 0.8 12.8 37
I234 234 0 1.34816e-05
R236 234 235 1.696 0.8 13.568 37
I235 235 0 1.31105e-05
R237 235 236 1.68 0.8 13.44 37
I236 236 0 1.24921e-05
R238 236 237 1.696 0.8 13.568 37
I237 237 0 1.27395e-05
R239 237 238 1.744 0.8 13.952 37
I238 238 0 1.24921e-05
R240 238 239 1.632 0.8 13.056 37
I239 239 0 1.31105e-05
R241 239 240 1.712 0.8 13.696 37
I240 240 0 1.31105e-05
R242 240 241 1.632 0.8 13.056 37
I241 241 0 1.23684e-05
R243 241 242 1.664 0.8 13.312 37
I242 242 0 1.27395e-05
R244 242 243 1.744 0.8 13.952 37
I243 243 0 1.34816e-05
R245 243 244 1.632 0.8 13.056 37
I244 244 0 1.26158e-05
R246 244 245 1.712 0.8 13.696 37
I245 245 0 1.33579e-05
R247 245 246 1.632 0.8 13.056 37
I246 246 0 1.26158e-05
R248 246 247 1.632 0.8 13.056 37
I247 247 0 1.29868e-05
R249 247 248 1.744 0.8 13.952 37
I248 248 0 1.31105e-05
R250 248 249 1.664 0.8 13.312 37
I249 249 0 1.23684e-05
R251 249 250 1.68 0.8 13.44 37
I250 250 0 1.34816e-05
R252 250 251 1.68 0.8 13.44 37
I251 251 0 1.27395e-05
R253 251 252 1.616 0.8 12.928 37
I252 252 0 1.28631e-05
R254 252 253 1.744 0.8 13.952 37
I253 253 0 1.23684e-05
R255 253 254 1.616 0.8 12.928 37
I254 254 0 1.28631e-05
R256 254 255 1.68 0.8 13.44 37
I255 255 0 1.28631e-05
R257 255 256 1.6 0.8 12.8 37
I256 256 0 1.34816e-05
R258 256 257 1.616 0.8 12.928 37
I257 257 0 1.27395e-05
R259 257 258 1.616 0.8 12.928 37
I258 258 0 1.34816e-05
R260 258 259 1.6 0.8 12.8 37
I259 259 0 1.28631e-05
R261 259 260 1.712 0.8 13.696 37
I260 260 0 1.27395e-05
R262 260 261 1.712 0.8 13.696 37
I261 261 0 1.33579e-05
R263 261 262 1.6 0.8 12.8 37
I262 262 0 1.29868e-05
R264 262 263 1.6 0.8 12.8 37
I263 263 0 1.34816e-05
R265 263 264 1.696 0.8 13.568 37
I264 264 0 1.31105e-05
R266 264 265 1.712 0.8 13.696 37
I265 265 0 1.26158e-05
R267 265 266 1.648 0.8 13.184 37
I266 266 0 1.32342e-05
R268 266 267 1.632 0.8 13.056 37
I267 267 0 1.31105e-05
R269 267 268 1.632 0.8 13.056 37
I268 268 0 1.34816e-05
R270 268 269 1.664 0.8 13.312 37
I269 269 0 1.26158e-05
R271 269 270 1.664 0.8 13.312 37
I270 270 0 1.29868e-05
R272 270 271 1.728 0.8 13.824 37
I271 271 0 1.28631e-05
R273 271 272 1.712 0.8 13.696 37
I272 272 0 1.31105e-05
R274 272 273 1.632 0.8 13.056 37
I273 273 0 1.28631e-05
R275 273 274 1.696 0.8 13.568 37
I274 274 0 1.26158e-05
R276 274 275 1.68 0.8 13.44 37
I275 275 0 1.33579e-05
R277 275 276 1.632 0.8 13.056 37
I276 276 0 1.23684e-05
R278 276 277 1.616 0.8 12.928 37
I277 277 0 1.34816e-05
R279 277 278 1.712 0.8 13.696 37
I278 278 0 1.28631e-05
R280 278 279 1.664 0.8 13.312 37
I279 279 0 1.29868e-05
R281 279 280 1.712 0.8 13.696 37
I280 280 0 1.29868e-05
R282 280 281 1.6 0.8 12.8 37
I281 281 0 1.33579e-05
R283 281 282 1.68 0.8 13.44 37
I282 282 0 1.23684e-05
R284 282 283 1.616 0.8 12.928 37
I283 283 0 1.34816e-05
R285 283 284 1.712 0.8 13.696 37
I284 284 0 1.32342e-05
R286 284 285 1.6 0.8 12.8 37
I285 285 0 1.32342e-05
R287 285 286 1.712 0.8 13.696 37
I286 286 0 1.31105e-05
R288 286 287 1.648 0.8 13.184 37
I287 287 0 1.27395e-05
R289 287 288 1.712 0.8 13.696 37
I288 288 0 1.32342e-05
R290 288 289 1.68 0.8 13.44 37
I289 289 0 1.24921e-05
R291 289 290 1.68 0.8 13.44 37
I290 290 0 1.31105e-05
R292 290 291 1.712 0.8 13.696 37
I291 291 0 1.24921e-05
R293 291 292 1.616 0.8 12.928 37
I292 292 0 1.23684e-05
R294 292 293 1.696 0.8 13.568 37
I293 293 0 1.34816e-05
R295 293 294 1.68 0.8 13.44 37
I294 294 0 1.32342e-05
R296 294 295 1.728 0.8 13.824 37
I295 295 0 1.27395e-05
R297 295 296 1.616 0.8 12.928 37
I296 296 0 1.31105e-05
R298 296 297 1.664 0.8 13.312 37
I297 297 0 1.33579e-05
R299 297 298 1.632 0.8 13.056 37
I298 298 0 1.32342e-05
R300 298 299 1.664 0.8 13.312 37
I299 299 0 1.31105e-05
R301 299 300 1.68 0.8 13.44 37
I300 300 0 1.29868e-05
R302 300 301 1.632 0.8 13.056 37
I301 301 0 1.31105e-05
R303 301 302 1.68 0.8 13.44 37
I302 302 0 1.29868e-05
R304 302 303 1.632 0.8 13.056 37
I303 303 0 1.33579e-05
R305 303 304 1.68 0.8 13.44 37
I304 304 0 1.32342e-05
R306 304 305 1.632 0.8 13.056 37
I305 305 0 1.23684e-05
R307 305 306 1.712 0.8 13.696 37
I306 306 0 1.26158e-05
R308 306 307 1.632 0.8 13.056 37
I307 307 0 1.27395e-05
R309 307 308 1.728 0.8 13.824 37
I308 308 0 1.29868e-05
R310 308 309 1.6 0.8 12.8 37
I309 309 0 1.33579e-05
R311 309 310 1.696 0.8 13.568 37
I310 310 0 1.26158e-05
R312 310 311 1.632 0.8 13.056 37
I311 311 0 1.28631e-05
R313 311 312 1.712 0.8 13.696 37
I312 312 0 1.29868e-05
R314 312 313 1.744 0.8 13.952 37
I313 313 0 1.28631e-05
R315 313 314 1.648 0.8 13.184 37
I314 314 0 1.34816e-05
R316 314 315 1.68 0.8 13.44 37
I315 315 0 1.29868e-05
R317 315 316 1.712 0.8 13.696 37
I316 316 0 1.24921e-05
R318 316 317 1.648 0.8 13.184 37
I317 317 0 1.32342e-05
R319 317 318 1.616 0.8 12.928 37
I318 318 0 1.32342e-05
R320 318 319 1.712 0.8 13.696 37
I319 319 0 1.26158e-05
R321 319 320 1.664 0.8 13.312 37
I320 320 0 1.24921e-05
R322 320 321 1.712 0.8 13.696 37
I321 321 0 1.27395e-05
R323 321 322 1.712 0.8 13.696 37
I322 322 0 1.32342e-05
R324 322 323 1.648 0.8 13.184 37
I323 323 0 1.24921e-05
R325 323 324 1.728 0.8 13.824 37
I324 324 0 1.34816e-05
R326 324 325 1.728 0.8 13.824 37
I325 325 0 1.31105e-05
R327 325 326 1.632 0.8 13.056 37
I326 326 0 1.23684e-05
R328 326 327 1.632 0.8 13.056 37
I327 327 0 1.33579e-05
R329 327 328 1.68 0.8 13.44 37
I328 328 0 1.26158e-05
R330 328 329 1.696 0.8 13.568 37
I329 329 0 1.34816e-05
R331 329 330 1.664 0.8 13.312 37
I330 330 0 1.31105e-05
R332 330 331 1.744 0.8 13.952 37
I331 331 0 1.27395e-05
R333 331 332 1.712 0.8 13.696 37
I332 332 0 1.23684e-05
R334 332 333 1.728 0.8 13.824 37
I333 333 0 1.33579e-05
R335 333 334 1.712 0.8 13.696 37
I334 334 0 1.29868e-05
R336 334 335 1.632 0.8 13.056 37
I335 335 0 1.23684e-05
R337 335 336 1.648 0.8 13.184 37
I336 336 0 1.27395e-05
R338 336 337 1.616 0.8 12.928 37
I337 337 0 1.24921e-05
R339 337 338 1.632 0.8 13.056 37
I338 338 0 1.28631e-05
R340 338 339 1.68 0.8 13.44 37
I339 339 0 1.31105e-05
R341 339 340 1.728 0.8 13.824 37
I340 340 0 1.24921e-05
R342 340 341 1.632 0.8 13.056 37
I341 341 0 1.24921e-05
R343 341 342 1.744 0.8 13.952 37
I342 342 0 1.34816e-05
R344 342 343 1.632 0.8 13.056 37
I343 343 0 1.34816e-05
R345 343 344 1.728 0.8 13.824 37
I344 344 0 1.27395e-05
R346 344 345 1.712 0.8 13.696 37
I345 345 0 1.24921e-05
R347 345 346 1.664 0.8 13.312 37
I346 346 0 1.24921e-05
R348 346 347 1.664 0.8 13.312 37
I347 347 0 1.32342e-05
R349 347 348 1.68 0.8 13.44 37
I348 348 0 1.27395e-05
R350 348 349 1.616 0.8 12.928 37
I349 349 0 1.24921e-05
R351 349 350 1.664 0.8 13.312 37
I350 350 0 1.28631e-05
R352 350 351 1.648 0.8 13.184 37
I351 351 0 1.29868e-05
R353 351 352 1.744 0.8 13.952 37
I352 352 0 1.26158e-05
R354 352 353 1.616 0.8 12.928 37
I353 353 0 1.34816e-05
R355 353 354 1.616 0.8 12.928 37
I354 354 0 1.27395e-05
R356 354 355 1.664 0.8 13.312 37
I355 355 0 1.33579e-05
R357 355 356 1.616 0.8 12.928 37
I356 356 0 1.31105e-05
R358 356 357 1.648 0.8 13.184 37
I357 357 0 1.28631e-05
R359 357 358 1.6 0.8 12.8 37
I358 358 0 1.29868e-05
R360 358 359 1.696 0.8 13.568 37
I359 359 0 1.33579e-05
R361 359 360 1.6 0.8 12.8 37
I360 360 0 1.26158e-05
R362 360 361 1.648 0.8 13.184 37
I361 361 0 1.28631e-05
R363 361 362 1.712 0.8 13.696 37
I362 362 0 1.27395e-05
R364 362 363 1.648 0.8 13.184 37
I363 363 0 1.27395e-05
R365 363 364 1.696 0.8 13.568 37
I364 364 0 1.28631e-05
R366 364 365 1.616 0.8 12.928 37
I365 365 0 1.24921e-05
R367 365 366 1.648 0.8 13.184 37
I366 366 0 1.28631e-05
R368 366 367 1.728 0.8 13.824 37
I367 367 0 1.32342e-05
R369 367 368 1.728 0.8 13.824 37
I368 368 0 1.33579e-05
R370 368 369 1.616 0.8 12.928 37
I369 369 0 1.24921e-05
R371 369 370 1.744 0.8 13.952 37
I370 370 0 1.34816e-05
R372 370 371 1.728 0.8 13.824 37
I371 371 0 1.29868e-05
R373 371 372 1.632 0.8 13.056 37
I372 372 0 1.28631e-05
R374 372 373 1.744 0.8 13.952 37
I373 373 0 1.23684e-05
R375 373 374 1.664 0.8 13.312 37
I374 374 0 1.28631e-05
R376 374 375 1.744 0.8 13.952 37
I375 375 0 1.23684e-05
R377 375 376 1.744 0.8 13.952 37
I376 376 0 1.34816e-05
R378 376 377 1.6 0.8 12.8 37
I377 377 0 1.24921e-05
R379 377 378 1.664 0.8 13.312 37
I378 378 0 1.26158e-05
R380 378 379 1.712 0.8 13.696 37
I379 379 0 1.24921e-05
R381 379 380 1.728 0.8 13.824 37
I380 380 0 1.26158e-05
R382 380 381 1.728 0.8 13.824 37
I381 381 0 1.27395e-05
R383 381 382 1.744 0.8 13.952 37
I382 382 0 1.34816e-05
R384 382 383 1.744 0.8 13.952 37
I383 383 0 1.26158e-05
R385 383 384 1.744 0.8 13.952 37
I384 384 0 1.32342e-05
R386 384 385 1.6 0.8 12.8 37
I385 385 0 1.34816e-05
R387 385 386 1.648 0.8 13.184 37
I386 386 0 1.29868e-05
R388 386 387 1.712 0.8 13.696 37
I387 387 0 1.34816e-05
R389 387 388 1.68 0.8 13.44 37
I388 388 0 1.33579e-05
R390 388 389 1.648 0.8 13.184 37
I389 389 0 1.33579e-05
R391 389 390 1.632 0.8 13.056 37
I390 390 0 1.32342e-05
R392 390 391 1.648 0.8 13.184 37
I391 391 0 1.33579e-05
R393 391 392 1.712 0.8 13.696 37
I392 392 0 1.33579e-05
R394 392 393 1.616 0.8 12.928 37
I393 393 0 1.28631e-05
R395 393 394 1.744 0.8 13.952 37
I394 394 0 1.29868e-05
R396 394 395 1.648 0.8 13.184 37
I395 395 0 1.33579e-05
R397 395 396 1.6 0.8 12.8 37
I396 396 0 1.34816e-05
R398 396 397 1.632 0.8 13.056 37
I397 397 0 1.27395e-05
R399 397 398 1.744 0.8 13.952 37
I398 398 0 1.34816e-05
R400 398 399 1.68 0.8 13.44 37
I399 399 0 1.34816e-05
R401 399 400 1.664 0.8 13.312 37
I400 400 0 1.28631e-05
R402 400 401 1.664 0.8 13.312 37
I401 401 0 1.27395e-05
R403 401 402 1.616 0.8 12.928 37
I402 402 0 1.34816e-05
R404 402 403 1.712 0.8 13.696 37
I403 403 0 1.32342e-05
R405 403 404 1.632 0.8 13.056 37
I404 404 0 1.29868e-05
R406 404 405 1.744 0.8 13.952 37
I405 405 0 1.23684e-05
R407 405 406 1.6 0.8 12.8 37
I406 406 0 1.24921e-05
R408 406 407 1.648 0.8 13.184 37
I407 407 0 1.28631e-05
R409 407 408 1.632 0.8 13.056 37
I408 408 0 1.24921e-05
R410 408 409 1.632 0.8 13.056 37
I409 409 0 1.33579e-05
R411 409 410 1.616 0.8 12.928 37
I410 410 0 1.33579e-05
R412 410 411 1.664 0.8 13.312 37
I411 411 0 1.31105e-05
R413 411 412 1.616 0.8 12.928 37
I412 412 0 1.28631e-05
R414 412 413 1.664 0.8 13.312 37
I413 413 0 1.29868e-05
R415 413 414 1.712 0.8 13.696 37
I414 414 0 1.23684e-05
R416 414 415 1.728 0.8 13.824 37
I415 415 0 1.31105e-05
R417 415 416 1.696 0.8 13.568 37
I416 416 0 1.24921e-05
R418 416 417 1.616 0.8 12.928 37
I417 417 0 1.29868e-05
R419 417 418 1.632 0.8 13.056 37
I418 418 0 1.32342e-05
R420 418 419 1.6 0.8 12.8 37
I419 419 0 1.34816e-05
R421 419 420 1.728 0.8 13.824 37
I420 420 0 1.33579e-05
R422 420 421 1.744 0.8 13.952 37
I421 421 0 1.33579e-05
R423 421 422 1.712 0.8 13.696 37
I422 422 0 1.23684e-05
R424 422 423 1.728 0.8 13.824 37
I423 423 0 1.31105e-05
R425 423 424 1.744 0.8 13.952 37
I424 424 0 1.23684e-05
R426 424 425 1.616 0.8 12.928 37
I425 425 0 1.29868e-05
R427 425 426 1.712 0.8 13.696 37
I426 426 0 1.26158e-05
R428 426 427 1.696 0.8 13.568 37
I427 427 0 1.29868e-05
R429 427 428 1.68 0.8 13.44 37
I428 428 0 1.26158e-05
R430 428 429 1.616 0.8 12.928 37
I429 429 0 1.32342e-05
R431 429 430 1.6 0.8 12.8 37
I430 430 0 1.33579e-05
R432 430 431 1.696 0.8 13.568 37
I431 431 0 1.27395e-05
R433 431 432 1.616 0.8 12.928 37
I432 432 0 1.23684e-05
R434 432 433 1.616 0.8 12.928 37
I433 433 0 1.23684e-05
R435 433 434 1.6 0.8 12.8 37
I434 434 0 1.31105e-05
R436 434 435 1.728 0.8 13.824 37
I435 435 0 1.34816e-05
R437 435 436 1.744 0.8 13.952 37
I436 436 0 1.34816e-05
R438 436 437 1.712 0.8 13.696 37
I437 437 0 1.24921e-05
R439 437 438 1.664 0.8 13.312 37
I438 438 0 1.32342e-05
R440 438 439 1.6 0.8 12.8 37
I439 439 0 1.33579e-05
R441 439 440 1.632 0.8 13.056 37
I440 440 0 1.31105e-05
R442 440 441 1.632 0.8 13.056 37
I441 441 0 1.24921e-05
R443 441 442 1.68 0.8 13.44 37
I442 442 0 1.27395e-05
R444 442 443 1.664 0.8 13.312 37
I443 443 0 1.23684e-05
R445 443 444 1.664 0.8 13.312 37
I444 444 0 1.34816e-05
R446 444 445 1.632 0.8 13.056 37
I445 445 0 1.31105e-05
R447 445 446 1.664 0.8 13.312 37
I446 446 0 1.23684e-05
R448 446 447 1.712 0.8 13.696 37
I447 447 0 1.32342e-05
R449 447 448 1.664 0.8 13.312 37
I448 448 0 1.24921e-05
R450 448 449 1.696 0.8 13.568 37
I449 449 0 1.34816e-05
R451 449 450 1.712 0.8 13.696 37
I450 450 0 1.27395e-05
R452 450 451 1.6 0.8 12.8 37
I451 451 0 1.31105e-05
R453 451 452 1.664 0.8 13.312 37
I452 452 0 1.33579e-05
R454 452 453 1.648 0.8 13.184 37
I453 453 0 1.27395e-05
R455 453 454 1.728 0.8 13.824 37
I454 454 0 1.29868e-05
R456 454 455 1.744 0.8 13.952 37
I455 455 0 1.28631e-05
R457 455 456 1.728 0.8 13.824 37
I456 456 0 1.23684e-05
R458 456 457 1.68 0.8 13.44 37
I457 457 0 1.27395e-05
R459 457 458 1.6 0.8 12.8 37
I458 458 0 1.26158e-05
R460 458 459 1.728 0.8 13.824 37
I459 459 0 1.32342e-05
R461 459 460 1.712 0.8 13.696 37
I460 460 0 1.31105e-05
R462 460 461 1.728 0.8 13.824 37
I461 461 0 1.32342e-05
R463 461 462 1.632 0.8 13.056 37
I462 462 0 1.34816e-05
R464 462 463 1.68 0.8 13.44 37
I463 463 0 1.24921e-05
R465 463 464 1.6 0.8 12.8 37
I464 464 0 1.32342e-05
R466 464 465 1.696 0.8 13.568 37
I465 465 0 1.33579e-05
R467 465 466 1.728 0.8 13.824 37
I466 466 0 1.26158e-05
R468 466 467 1.632 0.8 13.056 37
I467 467 0 1.26158e-05
R469 467 468 1.6 0.8 12.8 37
I468 468 0 1.23684e-05
R470 468 469 1.696 0.8 13.568 37
I469 469 0 1.33579e-05
R471 469 470 1.728 0.8 13.824 37
I470 470 0 1.23684e-05
R472 470 471 1.696 0.8 13.568 37
I471 471 0 1.27395e-05
R473 471 472 1.664 0.8 13.312 37
I472 472 0 1.27395e-05
R474 472 473 1.616 0.8 12.928 37
I473 473 0 1.32342e-05
R475 473 474 1.696 0.8 13.568 37
I474 474 0 1.26158e-05
R476 474 475 1.664 0.8 13.312 37
I475 475 0 1.31105e-05
R477 475 476 1.728 0.8 13.824 37
I476 476 0 1.27395e-05
R478 476 477 1.648 0.8 13.184 37
I477 477 0 1.26158e-05
R479 477 478 1.6 0.8 12.8 37
I478 478 0 1.26158e-05
R480 478 479 1.664 0.8 13.312 37
I479 479 0 1.32342e-05
R481 479 480 1.616 0.8 12.928 37
I480 480 0 1.29868e-05
R482 480 481 1.648 0.8 13.184 37
I481 481 0 1.24921e-05
R483 481 482 1.728 0.8 13.824 37
I482 482 0 1.33579e-05
R484 482 483 1.728 0.8 13.824 37
I483 483 0 1.28631e-05
R485 483 484 1.696 0.8 13.568 37
I484 484 0 1.23684e-05
R486 484 485 1.648 0.8 13.184 37
I485 485 0 1.32342e-05
R487 485 486 1.632 0.8 13.056 37
I486 486 0 1.34816e-05
R488 486 487 1.696 0.8 13.568 37
I487 487 0 1.34816e-05
R489 487 488 1.696 0.8 13.568 37
I488 488 0 1.29868e-05
R490 488 489 1.744 0.8 13.952 37
I489 489 0 1.27395e-05
R491 489 490 1.664 0.8 13.312 37
I490 490 0 1.34816e-05
R492 490 491 1.68 0.8 13.44 37
I491 491 0 1.33579e-05
R493 491 492 1.696 0.8 13.568 37
I492 492 0 1.34816e-05
R494 492 493 1.648 0.8 13.184 37
I493 493 0 1.32342e-05
R495 493 494 1.712 0.8 13.696 37
I494 494 0 1.32342e-05
R496 494 495 1.664 0.8 13.312 37
I495 495 0 1.23684e-05
R497 495 496 1.728 0.8 13.824 37
I496 496 0 1.26158e-05
R498 496 497 1.728 0.8 13.824 37
I497 497 0 1.24921e-05
R499 497 498 1.648 0.8 13.184 37
I498 498 0 1.23684e-05
R500 498 499 1.6 0.8 12.8 37
I499 499 0 1.31105e-05
R501 499 500 1.68 0.8 13.44 37
I500 500 0 1.23684e-05
R502 500 1501 0.5 10 50 37
*seg: 2
R503 1501 501 0.4 20 80 37
R504 750 1250 6.16 0.8 49.28 37
I501 501 0 1.27395e-05
R505 501 502 1.664 0.8 13.312 37
I502 502 0 1.29868e-05
R506 502 503 1.68 0.8 13.44 37
I503 503 0 1.26158e-05
R507 503 504 1.744 0.8 13.952 37
I504 504 0 1.26158e-05
R508 504 505 1.664 0.8 13.312 37
I505 505 0 1.23684e-05
R509 505 506 1.712 0.8 13.696 37
I506 506 0 1.31105e-05
R510 506 507 1.696 0.8 13.568 37
I507 507 0 1.26158e-05
R511 507 508 1.744 0.8 13.952 37
I508 508 0 1.29868e-05
R512 508 509 1.696 0.8 13.568 37
I509 509 0 1.27395e-05
R513 509 510 1.68 0.8 13.44 37
I510 510 0 1.33579e-05
R514 510 511 1.696 0.8 13.568 37
I511 511 0 1.27395e-05
R515 511 512 1.6 0.8 12.8 37
I512 512 0 1.32342e-05
R516 512 513 1.616 0.8 12.928 37
I513 513 0 1.23684e-05
R517 513 514 1.616 0.8 12.928 37
I514 514 0 1.28631e-05
R518 514 515 1.68 0.8 13.44 37
I515 515 0 1.29868e-05
R519 515 516 1.696 0.8 13.568 37
I516 516 0 1.33579e-05
R520 516 517 1.744 0.8 13.952 37
I517 517 0 1.24921e-05
R521 517 518 1.664 0.8 13.312 37
I518 518 0 1.31105e-05
R522 518 519 1.744 0.8 13.952 37
I519 519 0 1.28631e-05
R523 519 520 1.696 0.8 13.568 37
I520 520 0 1.31105e-05
R524 520 521 1.632 0.8 13.056 37
I521 521 0 1.27395e-05
R525 521 522 1.664 0.8 13.312 37
I522 522 0 1.34816e-05
R526 522 523 1.616 0.8 12.928 37
I523 523 0 1.31105e-05
R527 523 524 1.664 0.8 13.312 37
I524 524 0 1.31105e-05
R528 524 525 1.6 0.8 12.8 37
I525 525 0 1.27395e-05
R529 525 526 1.68 0.8 13.44 37
I526 526 0 1.24921e-05
R530 526 527 1.632 0.8 13.056 37
I527 527 0 1.26158e-05
R531 527 528 1.6 0.8 12.8 37
I528 528 0 1.24921e-05
R532 528 529 1.616 0.8 12.928 37
I529 529 0 1.32342e-05
R533 529 530 1.6 0.8 12.8 37
I530 530 0 1.23684e-05
R534 530 531 1.648 0.8 13.184 37
I531 531 0 1.32342e-05
R535 531 532 1.664 0.8 13.312 37
I532 532 0 1.29868e-05
R536 532 533 1.712 0.8 13.696 37
I533 533 0 1.23684e-05
R537 533 534 1.744 0.8 13.952 37
I534 534 0 1.27395e-05
R538 534 535 1.728 0.8 13.824 37
I535 535 0 1.26158e-05
R539 535 536 1.712 0.8 13.696 37
I536 536 0 1.31105e-05
R540 536 537 1.632 0.8 13.056 37
I537 537 0 1.29868e-05
R541 537 538 1.696 0.8 13.568 37
I538 538 0 1.32342e-05
R542 538 539 1.664 0.8 13.312 37
I539 539 0 1.33579e-05
R543 539 540 1.728 0.8 13.824 37
I540 540 0 1.27395e-05
R544 540 541 1.728 0.8 13.824 37
I541 541 0 1.33579e-05
R545 541 542 1.616 0.8 12.928 37
I542 542 0 1.29868e-05
R546 542 543 1.696 0.8 13.568 37
I543 543 0 1.34816e-05
R547 543 544 1.696 0.8 13.568 37
I544 544 0 1.23684e-05
R548 544 545 1.696 0.8 13.568 37
I545 545 0 1.28631e-05
R549 545 546 1.744 0.8 13.952 37
I546 546 0 1.33579e-05
R550 546 547 1.68 0.8 13.44 37
I547 547 0 1.26158e-05
R551 547 548 1.728 0.8 13.824 37
I548 548 0 1.29868e-05
R552 548 549 1.616 0.8 12.928 37
I549 549 0 1.24921e-05
R553 549 550 1.648 0.8 13.184 37
I550 550 0 1.29868e-05
R554 550 551 1.744 0.8 13.952 37
I551 551 0 1.28631e-05
R555 551 552 1.632 0.8 13.056 37
I552 552 0 1.23684e-05
R556 552 553 1.616 0.8 12.928 37
I553 553 0 1.33579e-05
R557 553 554 1.616 0.8 12.928 37
I554 554 0 1.31105e-05
R558 554 555 1.664 0.8 13.312 37
I555 555 0 1.31105e-05
R559 555 556 1.632 0.8 13.056 37
I556 556 0 1.23684e-05
R560 556 557 1.6 0.8 12.8 37
I557 557 0 1.29868e-05
R561 557 558 1.68 0.8 13.44 37
I558 558 0 1.29868e-05
R562 558 559 1.6 0.8 12.8 37
I559 559 0 1.32342e-05
R563 559 560 1.728 0.8 13.824 37
I560 560 0 1.24921e-05
R564 560 561 1.68 0.8 13.44 37
I561 561 0 1.33579e-05
R565 561 562 1.696 0.8 13.568 37
I562 562 0 1.23684e-05
R566 562 563 1.632 0.8 13.056 37
I563 563 0 1.34816e-05
R567 563 564 1.6 0.8 12.8 37
I564 564 0 1.24921e-05
R568 564 565 1.728 0.8 13.824 37
I565 565 0 1.32342e-05
R569 565 566 1.728 0.8 13.824 37
I566 566 0 1.29868e-05
R570 566 567 1.648 0.8 13.184 37
I567 567 0 1.27395e-05
R571 567 568 1.712 0.8 13.696 37
I568 568 0 1.23684e-05
R572 568 569 1.728 0.8 13.824 37
I569 569 0 1.32342e-05
R573 569 570 1.648 0.8 13.184 37
I570 570 0 1.26158e-05
R574 570 571 1.632 0.8 13.056 37
I571 571 0 1.31105e-05
R575 571 572 1.6 0.8 12.8 37
I572 572 0 1.33579e-05
R576 572 573 1.664 0.8 13.312 37
I573 573 0 1.27395e-05
R577 573 574 1.648 0.8 13.184 37
I574 574 0 1.32342e-05
R578 574 575 1.744 0.8 13.952 37
I575 575 0 1.26158e-05
R579 575 576 1.664 0.8 13.312 37
I576 576 0 1.31105e-05
R580 576 577 1.712 0.8 13.696 37
I577 577 0 1.24921e-05
R581 577 578 1.712 0.8 13.696 37
I578 578 0 1.28631e-05
R582 578 579 1.6 0.8 12.8 37
I579 579 0 1.34816e-05
R583 579 580 1.712 0.8 13.696 37
I580 580 0 1.27395e-05
R584 580 581 1.696 0.8 13.568 37
I581 581 0 1.24921e-05
R585 581 582 1.696 0.8 13.568 37
I582 582 0 1.24921e-05
R586 582 583 1.616 0.8 12.928 37
I583 583 0 1.23684e-05
R587 583 584 1.6 0.8 12.8 37
I584 584 0 1.32342e-05
R588 584 585 1.68 0.8 13.44 37
I585 585 0 1.27395e-05
R589 585 586 1.6 0.8 12.8 37
I586 586 0 1.34816e-05
R590 586 587 1.632 0.8 13.056 37
I587 587 0 1.24921e-05
R591 587 588 1.68 0.8 13.44 37
I588 588 0 1.24921e-05
R592 588 589 1.744 0.8 13.952 37
I589 589 0 1.23684e-05
R593 589 590 1.616 0.8 12.928 37
I590 590 0 1.27395e-05
R594 590 591 1.712 0.8 13.696 37
I591 591 0 1.27395e-05
R595 591 592 1.632 0.8 13.056 37
I592 592 0 1.34816e-05
R596 592 593 1.664 0.8 13.312 37
I593 593 0 1.33579e-05
R597 593 594 1.664 0.8 13.312 37
I594 594 0 1.29868e-05
R598 594 595 1.744 0.8 13.952 37
I595 595 0 1.29868e-05
R599 595 596 1.616 0.8 12.928 37
I596 596 0 1.34816e-05
R600 596 597 1.6 0.8 12.8 37
I597 597 0 1.28631e-05
R601 597 598 1.616 0.8 12.928 37
I598 598 0 1.33579e-05
R602 598 599 1.632 0.8 13.056 37
I599 599 0 1.29868e-05
R603 599 600 1.648 0.8 13.184 37
I600 600 0 1.31105e-05
R604 600 601 1.616 0.8 12.928 37
I601 601 0 1.31105e-05
R605 601 602 1.648 0.8 13.184 37
I602 602 0 1.27395e-05
R606 602 603 1.712 0.8 13.696 37
I603 603 0 1.26158e-05
R607 603 604 1.712 0.8 13.696 37
I604 604 0 1.31105e-05
R608 604 605 1.712 0.8 13.696 37
I605 605 0 1.23684e-05
R609 605 606 1.712 0.8 13.696 37
I606 606 0 1.26158e-05
R610 606 607 1.664 0.8 13.312 37
I607 607 0 1.23684e-05
R611 607 608 1.632 0.8 13.056 37
I608 608 0 1.32342e-05
R612 608 609 1.744 0.8 13.952 37
I609 609 0 1.26158e-05
R613 609 610 1.632 0.8 13.056 37
I610 610 0 1.28631e-05
R614 610 611 1.68 0.8 13.44 37
I611 611 0 1.24921e-05
R615 611 612 1.648 0.8 13.184 37
I612 612 0 1.31105e-05
R616 612 613 1.712 0.8 13.696 37
I613 613 0 1.26158e-05
R617 613 614 1.6 0.8 12.8 37
I614 614 0 1.31105e-05
R618 614 615 1.632 0.8 13.056 37
I615 615 0 1.23684e-05
R619 615 616 1.696 0.8 13.568 37
I616 616 0 1.27395e-05
R620 616 617 1.696 0.8 13.568 37
I617 617 0 1.34816e-05
R621 617 618 1.696 0.8 13.568 37
I618 618 0 1.29868e-05
R622 618 619 1.68 0.8 13.44 37
I619 619 0 1.34816e-05
R623 619 620 1.744 0.8 13.952 37
I620 620 0 1.24921e-05
R624 620 621 1.648 0.8 13.184 37
I621 621 0 1.28631e-05
R625 621 622 1.664 0.8 13.312 37
I622 622 0 1.33579e-05
R626 622 623 1.712 0.8 13.696 37
I623 623 0 1.31105e-05
R627 623 624 1.696 0.8 13.568 37
I624 624 0 1.31105e-05
R628 624 625 1.728 0.8 13.824 37
I625 625 0 1.29868e-05
R629 625 626 1.6 0.8 12.8 37
I626 626 0 1.24921e-05
R630 626 627 1.6 0.8 12.8 37
I627 627 0 1.23684e-05
R631 627 628 1.696 0.8 13.568 37
I628 628 0 1.23684e-05
R632 628 629 1.696 0.8 13.568 37
I629 629 0 1.24921e-05
R633 629 630 1.712 0.8 13.696 37
I630 630 0 1.34816e-05
R634 630 631 1.744 0.8 13.952 37
I631 631 0 1.28631e-05
R635 631 632 1.712 0.8 13.696 37
I632 632 0 1.31105e-05
R636 632 633 1.6 0.8 12.8 37
I633 633 0 1.29868e-05
R637 633 634 1.632 0.8 13.056 37
I634 634 0 1.24921e-05
R638 634 635 1.648 0.8 13.184 37
I635 635 0 1.34816e-05
R639 635 636 1.6 0.8 12.8 37
I636 636 0 1.31105e-05
R640 636 637 1.616 0.8 12.928 37
I637 637 0 1.27395e-05
R641 637 638 1.6 0.8 12.8 37
I638 638 0 1.29868e-05
R642 638 639 1.68 0.8 13.44 37
I639 639 0 1.28631e-05
R643 639 640 1.68 0.8 13.44 37
I640 640 0 1.31105e-05
R644 640 641 1.696 0.8 13.568 37
I641 641 0 1.23684e-05
R645 641 642 1.728 0.8 13.824 37
I642 642 0 1.23684e-05
R646 642 643 1.648 0.8 13.184 37
I643 643 0 1.27395e-05
R647 643 644 1.648 0.8 13.184 37
I644 644 0 1.23684e-05
R648 644 645 1.664 0.8 13.312 37
I645 645 0 1.31105e-05
R649 645 646 1.744 0.8 13.952 37
I646 646 0 1.23684e-05
R650 646 647 1.664 0.8 13.312 37
I647 647 0 1.28631e-05
R651 647 648 1.616 0.8 12.928 37
I648 648 0 1.26158e-05
R652 648 649 1.648 0.8 13.184 37
I649 649 0 1.23684e-05
R653 649 650 1.696 0.8 13.568 37
I650 650 0 1.29868e-05
R654 650 651 1.616 0.8 12.928 37
I651 651 0 1.29868e-05
R655 651 652 1.616 0.8 12.928 37
I652 652 0 1.28631e-05
R656 652 653 1.68 0.8 13.44 37
I653 653 0 1.34816e-05
R657 653 654 1.68 0.8 13.44 37
I654 654 0 1.31105e-05
R658 654 655 1.696 0.8 13.568 37
I655 655 0 1.31105e-05
R659 655 656 1.616 0.8 12.928 37
I656 656 0 1.23684e-05
R660 656 657 1.68 0.8 13.44 37
I657 657 0 1.23684e-05
R661 657 658 1.744 0.8 13.952 37
I658 658 0 1.32342e-05
R662 658 659 1.616 0.8 12.928 37
I659 659 0 1.28631e-05
R663 659 660 1.712 0.8 13.696 37
I660 660 0 1.26158e-05
R664 660 661 1.616 0.8 12.928 37
I661 661 0 1.31105e-05
R665 661 662 1.68 0.8 13.44 37
I662 662 0 1.32342e-05
R666 662 663 1.68 0.8 13.44 37
I663 663 0 1.27395e-05
R667 663 664 1.632 0.8 13.056 37
I664 664 0 1.29868e-05
R668 664 665 1.68 0.8 13.44 37
I665 665 0 1.32342e-05
R669 665 666 1.696 0.8 13.568 37
I666 666 0 1.24921e-05
R670 666 667 1.6 0.8 12.8 37
I667 667 0 1.29868e-05
R671 667 668 1.744 0.8 13.952 37
I668 668 0 1.24921e-05
R672 668 669 1.6 0.8 12.8 37
I669 669 0 1.27395e-05
R673 669 670 1.712 0.8 13.696 37
I670 670 0 1.29868e-05
R674 670 671 1.632 0.8 13.056 37
I671 671 0 1.24921e-05
R675 671 672 1.744 0.8 13.952 37
I672 672 0 1.26158e-05
R676 672 673 1.632 0.8 13.056 37
I673 673 0 1.29868e-05
R677 673 674 1.744 0.8 13.952 37
I674 674 0 1.23684e-05
R678 674 675 1.616 0.8 12.928 37
I675 675 0 1.24921e-05
R679 675 676 1.696 0.8 13.568 37
I676 676 0 1.23684e-05
R680 676 677 1.664 0.8 13.312 37
I677 677 0 1.27395e-05
R681 677 678 1.648 0.8 13.184 37
I678 678 0 1.31105e-05
R682 678 679 1.744 0.8 13.952 37
I679 679 0 1.31105e-05
R683 679 680 1.632 0.8 13.056 37
I680 680 0 1.34816e-05
R684 680 681 1.744 0.8 13.952 37
I681 681 0 1.34816e-05
R685 681 682 1.632 0.8 13.056 37
I682 682 0 1.33579e-05
R686 682 683 1.68 0.8 13.44 37
I683 683 0 1.33579e-05
R687 683 684 1.696 0.8 13.568 37
I684 684 0 1.29868e-05
R688 684 685 1.616 0.8 12.928 37
I685 685 0 1.28631e-05
R689 685 686 1.664 0.8 13.312 37
I686 686 0 1.34816e-05
R690 686 687 1.696 0.8 13.568 37
I687 687 0 1.31105e-05
R691 687 688 1.664 0.8 13.312 37
I688 688 0 1.33579e-05
R692 688 689 1.6 0.8 12.8 37
I689 689 0 1.33579e-05
R693 689 690 1.6 0.8 12.8 37
I690 690 0 1.23684e-05
R694 690 691 1.744 0.8 13.952 37
I691 691 0 1.32342e-05
R695 691 692 1.648 0.8 13.184 37
I692 692 0 1.29868e-05
R696 692 693 1.664 0.8 13.312 37
I693 693 0 1.33579e-05
R697 693 694 1.616 0.8 12.928 37
I694 694 0 1.23684e-05
R698 694 695 1.712 0.8 13.696 37
I695 695 0 1.32342e-05
R699 695 696 1.712 0.8 13.696 37
I696 696 0 1.28631e-05
R700 696 697 1.648 0.8 13.184 37
I697 697 0 1.23684e-05
R701 697 698 1.6 0.8 12.8 37
I698 698 0 1.24921e-05
R702 698 699 1.696 0.8 13.568 37
I699 699 0 1.24921e-05
R703 699 700 1.648 0.8 13.184 37
I700 700 0 1.29868e-05
R704 700 701 1.632 0.8 13.056 37
I701 701 0 1.28631e-05
R705 701 702 1.632 0.8 13.056 37
I702 702 0 1.33579e-05
R706 702 703 1.648 0.8 13.184 37
I703 703 0 1.32342e-05
R707 703 704 1.6 0.8 12.8 37
I704 704 0 1.34816e-05
R708 704 705 1.696 0.8 13.568 37
I705 705 0 1.27395e-05
R709 705 706 1.6 0.8 12.8 37
I706 706 0 1.23684e-05
R710 706 707 1.728 0.8 13.824 37
I707 707 0 1.29868e-05
R711 707 708 1.712 0.8 13.696 37
I708 708 0 1.27395e-05
R712 708 709 1.6 0.8 12.8 37
I709 709 0 1.33579e-05
R713 709 710 1.648 0.8 13.184 37
I710 710 0 1.24921e-05
R714 710 711 1.696 0.8 13.568 37
I711 711 0 1.26158e-05
R715 711 712 1.648 0.8 13.184 37
I712 712 0 1.34816e-05
R716 712 713 1.6 0.8 12.8 37
I713 713 0 1.27395e-05
R717 713 714 1.6 0.8 12.8 37
I714 714 0 1.29868e-05
R718 714 715 1.696 0.8 13.568 37
I715 715 0 1.31105e-05
R719 715 716 1.664 0.8 13.312 37
I716 716 0 1.34816e-05
R720 716 717 1.616 0.8 12.928 37
I717 717 0 1.23684e-05
R721 717 718 1.744 0.8 13.952 37
I718 718 0 1.28631e-05
R722 718 719 1.68 0.8 13.44 37
I719 719 0 1.32342e-05
R723 719 720 1.68 0.8 13.44 37
I720 720 0 1.27395e-05
R724 720 721 1.616 0.8 12.928 37
I721 721 0 1.29868e-05
R725 721 722 1.6 0.8 12.8 37
I722 722 0 1.26158e-05
R726 722 723 1.744 0.8 13.952 37
I723 723 0 1.27395e-05
R727 723 724 1.664 0.8 13.312 37
I724 724 0 1.26158e-05
R728 724 725 1.744 0.8 13.952 37
I725 725 0 1.29868e-05
R729 725 726 1.712 0.8 13.696 37
I726 726 0 1.29868e-05
R730 726 727 1.712 0.8 13.696 37
I727 727 0 1.33579e-05
R731 727 728 1.728 0.8 13.824 37
I728 728 0 1.32342e-05
R732 728 729 1.744 0.8 13.952 37
I729 729 0 1.23684e-05
R733 729 730 1.712 0.8 13.696 37
I730 730 0 1.24921e-05
R734 730 731 1.648 0.8 13.184 37
I731 731 0 1.33579e-05
R735 731 732 1.6 0.8 12.8 37
I732 732 0 1.32342e-05
R736 732 733 1.712 0.8 13.696 37
I733 733 0 1.29868e-05
R737 733 734 1.68 0.8 13.44 37
I734 734 0 1.26158e-05
R738 734 735 1.744 0.8 13.952 37
I735 735 0 1.27395e-05
R739 735 736 1.664 0.8 13.312 37
I736 736 0 1.32342e-05
R740 736 737 1.696 0.8 13.568 37
I737 737 0 1.24921e-05
R741 737 738 1.664 0.8 13.312 37
I738 738 0 1.31105e-05
R742 738 739 1.68 0.8 13.44 37
I739 739 0 1.26158e-05
R743 739 740 1.68 0.8 13.44 37
I740 740 0 1.28631e-05
R744 740 741 1.632 0.8 13.056 37
I741 741 0 1.33579e-05
R745 741 742 1.6 0.8 12.8 37
I742 742 0 1.24921e-05
R746 742 743 1.728 0.8 13.824 37
I743 743 0 1.28631e-05
R747 743 744 1.728 0.8 13.824 37
I744 744 0 1.23684e-05
R748 744 745 1.632 0.8 13.056 37
I745 745 0 1.23684e-05
R749 745 746 1.728 0.8 13.824 37
I746 746 0 1.31105e-05
R750 746 747 1.664 0.8 13.312 37
I747 747 0 1.33579e-05
R751 747 748 1.712 0.8 13.696 37
I748 748 0 1.23684e-05
R752 748 749 1.6 0.8 12.8 37
I749 749 0 1.32342e-05
R753 749 750 1.632 0.8 13.056 37
I750 750 0 1.28631e-05
R754 750 751 1.696 0.8 13.568 37
I751 751 0 1.27395e-05
R755 751 752 1.728 0.8 13.824 37
I752 752 0 1.24921e-05
R756 752 753 1.6 0.8 12.8 37
I753 753 0 1.32342e-05
R757 753 754 1.68 0.8 13.44 37
I754 754 0 1.34816e-05
R758 754 755 1.648 0.8 13.184 37
I755 755 0 1.27395e-05
R759 755 756 1.6 0.8 12.8 37
I756 756 0 1.33579e-05
R760 756 757 1.6 0.8 12.8 37
I757 757 0 1.32342e-05
R761 757 758 1.6 0.8 12.8 37
I758 758 0 1.27395e-05
R762 758 759 1.728 0.8 13.824 37
I759 759 0 1.33579e-05
R763 759 760 1.664 0.8 13.312 37
I760 760 0 1.31105e-05
R764 760 761 1.712 0.8 13.696 37
I761 761 0 1.28631e-05
R765 761 762 1.712 0.8 13.696 37
I762 762 0 1.29868e-05
R766 762 763 1.616 0.8 12.928 37
I763 763 0 1.33579e-05
R767 763 764 1.6 0.8 12.8 37
I764 764 0 1.23684e-05
R768 764 765 1.648 0.8 13.184 37
I765 765 0 1.31105e-05
R769 765 766 1.744 0.8 13.952 37
I766 766 0 1.26158e-05
R770 766 767 1.68 0.8 13.44 37
I767 767 0 1.34816e-05
R771 767 768 1.68 0.8 13.44 37
I768 768 0 1.32342e-05
R772 768 769 1.616 0.8 12.928 37
I769 769 0 1.28631e-05
R773 769 770 1.68 0.8 13.44 37
I770 770 0 1.27395e-05
R774 770 771 1.744 0.8 13.952 37
I771 771 0 1.27395e-05
R775 771 772 1.744 0.8 13.952 37
I772 772 0 1.24921e-05
R776 772 773 1.728 0.8 13.824 37
I773 773 0 1.32342e-05
R777 773 774 1.68 0.8 13.44 37
I774 774 0 1.23684e-05
R778 774 775 1.68 0.8 13.44 37
I775 775 0 1.29868e-05
R779 775 776 1.664 0.8 13.312 37
I776 776 0 1.27395e-05
R780 776 777 1.632 0.8 13.056 37
I777 777 0 1.28631e-05
R781 777 778 1.648 0.8 13.184 37
I778 778 0 1.24921e-05
R782 778 779 1.648 0.8 13.184 37
I779 779 0 1.26158e-05
R783 779 780 1.664 0.8 13.312 37
I780 780 0 1.31105e-05
R784 780 781 1.648 0.8 13.184 37
I781 781 0 1.32342e-05
R785 781 782 1.728 0.8 13.824 37
I782 782 0 1.27395e-05
R786 782 783 1.68 0.8 13.44 37
I783 783 0 1.28631e-05
R787 783 784 1.696 0.8 13.568 37
I784 784 0 1.26158e-05
R788 784 785 1.696 0.8 13.568 37
I785 785 0 1.28631e-05
R789 785 786 1.616 0.8 12.928 37
I786 786 0 1.23684e-05
R790 786 787 1.6 0.8 12.8 37
I787 787 0 1.33579e-05
R791 787 788 1.664 0.8 13.312 37
I788 788 0 1.32342e-05
R792 788 789 1.712 0.8 13.696 37
I789 789 0 1.27395e-05
R793 789 790 1.6 0.8 12.8 37
I790 790 0 1.33579e-05
R794 790 791 1.664 0.8 13.312 37
I791 791 0 1.28631e-05
R795 791 792 1.6 0.8 12.8 37
I792 792 0 1.28631e-05
R796 792 793 1.616 0.8 12.928 37
I793 793 0 1.29868e-05
R797 793 794 1.664 0.8 13.312 37
I794 794 0 1.27395e-05
R798 794 795 1.616 0.8 12.928 37
I795 795 0 1.24921e-05
R799 795 796 1.744 0.8 13.952 37
I796 796 0 1.33579e-05
R800 796 797 1.68 0.8 13.44 37
I797 797 0 1.24921e-05
R801 797 798 1.712 0.8 13.696 37
I798 798 0 1.29868e-05
R802 798 799 1.632 0.8 13.056 37
I799 799 0 1.32342e-05
R803 799 800 1.648 0.8 13.184 37
I800 800 0 1.26158e-05
R804 800 801 1.728 0.8 13.824 37
I801 801 0 1.28631e-05
R805 801 802 1.744 0.8 13.952 37
I802 802 0 1.34816e-05
R806 802 803 1.632 0.8 13.056 37
I803 803 0 1.23684e-05
R807 803 804 1.696 0.8 13.568 37
I804 804 0 1.31105e-05
R808 804 805 1.616 0.8 12.928 37
I805 805 0 1.32342e-05
R809 805 806 1.616 0.8 12.928 37
I806 806 0 1.27395e-05
R810 806 807 1.712 0.8 13.696 37
I807 807 0 1.34816e-05
R811 807 808 1.648 0.8 13.184 37
I808 808 0 1.33579e-05
R812 808 809 1.712 0.8 13.696 37
I809 809 0 1.27395e-05
R813 809 810 1.696 0.8 13.568 37
I810 810 0 1.34816e-05
R814 810 811 1.664 0.8 13.312 37
I811 811 0 1.28631e-05
R815 811 812 1.632 0.8 13.056 37
I812 812 0 1.28631e-05
R816 812 813 1.664 0.8 13.312 37
I813 813 0 1.29868e-05
R817 813 814 1.664 0.8 13.312 37
I814 814 0 1.31105e-05
R818 814 815 1.664 0.8 13.312 37
I815 815 0 1.29868e-05
R819 815 816 1.696 0.8 13.568 37
I816 816 0 1.29868e-05
R820 816 817 1.632 0.8 13.056 37
I817 817 0 1.27395e-05
R821 817 818 1.712 0.8 13.696 37
I818 818 0 1.31105e-05
R822 818 819 1.664 0.8 13.312 37
I819 819 0 1.26158e-05
R823 819 820 1.616 0.8 12.928 37
I820 820 0 1.23684e-05
R824 820 821 1.68 0.8 13.44 37
I821 821 0 1.23684e-05
R825 821 822 1.632 0.8 13.056 37
I822 822 0 1.28631e-05
R826 822 823 1.744 0.8 13.952 37
I823 823 0 1.24921e-05
R827 823 824 1.68 0.8 13.44 37
I824 824 0 1.28631e-05
R828 824 825 1.712 0.8 13.696 37
I825 825 0 1.34816e-05
R829 825 826 1.648 0.8 13.184 37
I826 826 0 1.24921e-05
R830 826 827 1.648 0.8 13.184 37
I827 827 0 1.28631e-05
R831 827 828 1.616 0.8 12.928 37
I828 828 0 1.24921e-05
R832 828 829 1.648 0.8 13.184 37
I829 829 0 1.33579e-05
R833 829 830 1.744 0.8 13.952 37
I830 830 0 1.34816e-05
R834 830 831 1.632 0.8 13.056 37
I831 831 0 1.34816e-05
R835 831 832 1.744 0.8 13.952 37
I832 832 0 1.28631e-05
R836 832 833 1.712 0.8 13.696 37
I833 833 0 1.26158e-05
R837 833 834 1.728 0.8 13.824 37
I834 834 0 1.23684e-05
R838 834 835 1.728 0.8 13.824 37
I835 835 0 1.32342e-05
R839 835 836 1.632 0.8 13.056 37
I836 836 0 1.23684e-05
R840 836 837 1.696 0.8 13.568 37
I837 837 0 1.33579e-05
R841 837 838 1.712 0.8 13.696 37
I838 838 0 1.32342e-05
R842 838 839 1.744 0.8 13.952 37
I839 839 0 1.34816e-05
R843 839 840 1.6 0.8 12.8 37
I840 840 0 1.29868e-05
R844 840 841 1.68 0.8 13.44 37
I841 841 0 1.33579e-05
R845 841 842 1.648 0.8 13.184 37
I842 842 0 1.26158e-05
R846 842 843 1.664 0.8 13.312 37
I843 843 0 1.29868e-05
R847 843 844 1.712 0.8 13.696 37
I844 844 0 1.32342e-05
R848 844 845 1.648 0.8 13.184 37
I845 845 0 1.31105e-05
R849 845 846 1.696 0.8 13.568 37
I846 846 0 1.34816e-05
R850 846 847 1.632 0.8 13.056 37
I847 847 0 1.32342e-05
R851 847 848 1.696 0.8 13.568 37
I848 848 0 1.23684e-05
R852 848 849 1.696 0.8 13.568 37
I849 849 0 1.34816e-05
R853 849 850 1.744 0.8 13.952 37
I850 850 0 1.27395e-05
R854 850 851 1.68 0.8 13.44 37
I851 851 0 1.26158e-05
R855 851 852 1.712 0.8 13.696 37
I852 852 0 1.27395e-05
R856 852 853 1.68 0.8 13.44 37
I853 853 0 1.23684e-05
R857 853 854 1.616 0.8 12.928 37
I854 854 0 1.27395e-05
R858 854 855 1.648 0.8 13.184 37
I855 855 0 1.32342e-05
R859 855 856 1.664 0.8 13.312 37
I856 856 0 1.33579e-05
R860 856 857 1.664 0.8 13.312 37
I857 857 0 1.28631e-05
R861 857 858 1.728 0.8 13.824 37
I858 858 0 1.33579e-05
R862 858 859 1.696 0.8 13.568 37
I859 859 0 1.26158e-05
R863 859 860 1.6 0.8 12.8 37
I860 860 0 1.29868e-05
R864 860 861 1.696 0.8 13.568 37
I861 861 0 1.34816e-05
R865 861 862 1.648 0.8 13.184 37
I862 862 0 1.23684e-05
R866 862 863 1.744 0.8 13.952 37
I863 863 0 1.29868e-05
R867 863 864 1.648 0.8 13.184 37
I864 864 0 1.23684e-05
R868 864 865 1.664 0.8 13.312 37
I865 865 0 1.23684e-05
R869 865 866 1.6 0.8 12.8 37
I866 866 0 1.27395e-05
R870 866 867 1.632 0.8 13.056 37
I867 867 0 1.32342e-05
R871 867 868 1.712 0.8 13.696 37
I868 868 0 1.32342e-05
R872 868 869 1.616 0.8 12.928 37
I869 869 0 1.24921e-05
R873 869 870 1.696 0.8 13.568 37
I870 870 0 1.33579e-05
R874 870 871 1.696 0.8 13.568 37
I871 871 0 1.26158e-05
R875 871 872 1.6 0.8 12.8 37
I872 872 0 1.28631e-05
R876 872 873 1.632 0.8 13.056 37
I873 873 0 1.23684e-05
R877 873 874 1.616 0.8 12.928 37
I874 874 0 1.32342e-05
R878 874 875 1.616 0.8 12.928 37
I875 875 0 1.33579e-05
R879 875 876 1.68 0.8 13.44 37
I876 876 0 1.29868e-05
R880 876 877 1.744 0.8 13.952 37
I877 877 0 1.33579e-05
R881 877 878 1.68 0.8 13.44 37
I878 878 0 1.28631e-05
R882 878 879 1.728 0.8 13.824 37
I879 879 0 1.28631e-05
R883 879 880 1.648 0.8 13.184 37
I880 880 0 1.29868e-05
R884 880 881 1.744 0.8 13.952 37
I881 881 0 1.29868e-05
R885 881 882 1.6 0.8 12.8 37
I882 882 0 1.27395e-05
R886 882 883 1.648 0.8 13.184 37
I883 883 0 1.27395e-05
R887 883 884 1.696 0.8 13.568 37
I884 884 0 1.33579e-05
R888 884 885 1.744 0.8 13.952 37
I885 885 0 1.31105e-05
R889 885 886 1.6 0.8 12.8 37
I886 886 0 1.31105e-05
R890 886 887 1.696 0.8 13.568 37
I887 887 0 1.28631e-05
R891 887 888 1.696 0.8 13.568 37
I888 888 0 1.33579e-05
R892 888 889 1.648 0.8 13.184 37
I889 889 0 1.32342e-05
R893 889 890 1.696 0.8 13.568 37
I890 890 0 1.23684e-05
R894 890 891 1.616 0.8 12.928 37
I891 891 0 1.27395e-05
R895 891 892 1.744 0.8 13.952 37
I892 892 0 1.32342e-05
R896 892 893 1.744 0.8 13.952 37
I893 893 0 1.28631e-05
R897 893 894 1.664 0.8 13.312 37
I894 894 0 1.32342e-05
R898 894 895 1.664 0.8 13.312 37
I895 895 0 1.32342e-05
R899 895 896 1.696 0.8 13.568 37
I896 896 0 1.23684e-05
R900 896 897 1.728 0.8 13.824 37
I897 897 0 1.26158e-05
R901 897 898 1.68 0.8 13.44 37
I898 898 0 1.27395e-05
R902 898 899 1.712 0.8 13.696 37
I899 899 0 1.32342e-05
R903 899 900 1.728 0.8 13.824 37
I900 900 0 1.23684e-05
R904 900 901 1.728 0.8 13.824 37
I901 901 0 1.32342e-05
R905 901 902 1.696 0.8 13.568 37
I902 902 0 1.26158e-05
R906 902 903 1.664 0.8 13.312 37
I903 903 0 1.31105e-05
R907 903 904 1.728 0.8 13.824 37
I904 904 0 1.34816e-05
R908 904 905 1.648 0.8 13.184 37
I905 905 0 1.24921e-05
R909 905 906 1.6 0.8 12.8 37
I906 906 0 1.32342e-05
R910 906 907 1.648 0.8 13.184 37
I907 907 0 1.31105e-05
R911 907 908 1.616 0.8 12.928 37
I908 908 0 1.31105e-05
R912 908 909 1.648 0.8 13.184 37
I909 909 0 1.27395e-05
R913 909 910 1.728 0.8 13.824 37
I910 910 0 1.29868e-05
R914 910 911 1.664 0.8 13.312 37
I911 911 0 1.31105e-05
R915 911 912 1.744 0.8 13.952 37
I912 912 0 1.23684e-05
R916 912 913 1.68 0.8 13.44 37
I913 913 0 1.32342e-05
R917 913 914 1.648 0.8 13.184 37
I914 914 0 1.24921e-05
R918 914 915 1.696 0.8 13.568 37
I915 915 0 1.32342e-05
R919 915 916 1.664 0.8 13.312 37
I916 916 0 1.32342e-05
R920 916 917 1.6 0.8 12.8 37
I917 917 0 1.31105e-05
R921 917 918 1.6 0.8 12.8 37
I918 918 0 1.23684e-05
R922 918 919 1.696 0.8 13.568 37
I919 919 0 1.29868e-05
R923 919 920 1.68 0.8 13.44 37
I920 920 0 1.34816e-05
R924 920 921 1.696 0.8 13.568 37
I921 921 0 1.34816e-05
R925 921 922 1.664 0.8 13.312 37
I922 922 0 1.29868e-05
R926 922 923 1.6 0.8 12.8 37
I923 923 0 1.32342e-05
R927 923 924 1.664 0.8 13.312 37
I924 924 0 1.26158e-05
R928 924 925 1.632 0.8 13.056 37
I925 925 0 1.23684e-05
R929 925 926 1.616 0.8 12.928 37
I926 926 0 1.28631e-05
R930 926 927 1.616 0.8 12.928 37
I927 927 0 1.26158e-05
R931 927 928 1.744 0.8 13.952 37
I928 928 0 1.33579e-05
R932 928 929 1.744 0.8 13.952 37
I929 929 0 1.32342e-05
R933 929 930 1.6 0.8 12.8 37
I930 930 0 1.31105e-05
R934 930 931 1.744 0.8 13.952 37
I931 931 0 1.34816e-05
R935 931 932 1.648 0.8 13.184 37
I932 932 0 1.33579e-05
R936 932 933 1.632 0.8 13.056 37
I933 933 0 1.34816e-05
R937 933 934 1.632 0.8 13.056 37
I934 934 0 1.26158e-05
R938 934 935 1.616 0.8 12.928 37
I935 935 0 1.34816e-05
R939 935 936 1.712 0.8 13.696 37
I936 936 0 1.31105e-05
R940 936 937 1.744 0.8 13.952 37
I937 937 0 1.33579e-05
R941 937 938 1.728 0.8 13.824 37
I938 938 0 1.33579e-05
R942 938 939 1.712 0.8 13.696 37
I939 939 0 1.28631e-05
R943 939 940 1.664 0.8 13.312 37
I940 940 0 1.34816e-05
R944 940 941 1.744 0.8 13.952 37
I941 941 0 1.33579e-05
R945 941 942 1.744 0.8 13.952 37
I942 942 0 1.33579e-05
R946 942 943 1.728 0.8 13.824 37
I943 943 0 1.31105e-05
R947 943 944 1.728 0.8 13.824 37
I944 944 0 1.24921e-05
R948 944 945 1.632 0.8 13.056 37
I945 945 0 1.34816e-05
R949 945 946 1.6 0.8 12.8 37
I946 946 0 1.33579e-05
R950 946 947 1.728 0.8 13.824 37
I947 947 0 1.33579e-05
R951 947 948 1.712 0.8 13.696 37
I948 948 0 1.31105e-05
R952 948 949 1.632 0.8 13.056 37
I949 949 0 1.26158e-05
R953 949 950 1.728 0.8 13.824 37
I950 950 0 1.31105e-05
R954 950 951 1.6 0.8 12.8 37
I951 951 0 1.34816e-05
R955 951 952 1.664 0.8 13.312 37
I952 952 0 1.29868e-05
R956 952 953 1.696 0.8 13.568 37
I953 953 0 1.31105e-05
R957 953 954 1.696 0.8 13.568 37
I954 954 0 1.23684e-05
R958 954 955 1.648 0.8 13.184 37
I955 955 0 1.33579e-05
R959 955 956 1.696 0.8 13.568 37
I956 956 0 1.26158e-05
R960 956 957 1.712 0.8 13.696 37
I957 957 0 1.32342e-05
R961 957 958 1.632 0.8 13.056 37
I958 958 0 1.34816e-05
R962 958 959 1.712 0.8 13.696 37
I959 959 0 1.23684e-05
R963 959 960 1.664 0.8 13.312 37
I960 960 0 1.34816e-05
R964 960 961 1.648 0.8 13.184 37
I961 961 0 1.23684e-05
R965 961 962 1.744 0.8 13.952 37
I962 962 0 1.32342e-05
R966 962 963 1.632 0.8 13.056 37
I963 963 0 1.34816e-05
R967 963 964 1.744 0.8 13.952 37
I964 964 0 1.32342e-05
R968 964 965 1.632 0.8 13.056 37
I965 965 0 1.34816e-05
R969 965 966 1.664 0.8 13.312 37
I966 966 0 1.29868e-05
R970 966 967 1.6 0.8 12.8 37
I967 967 0 1.27395e-05
R971 967 968 1.696 0.8 13.568 37
I968 968 0 1.31105e-05
R972 968 969 1.664 0.8 13.312 37
I969 969 0 1.32342e-05
R973 969 970 1.744 0.8 13.952 37
I970 970 0 1.31105e-05
R974 970 971 1.632 0.8 13.056 37
I971 971 0 1.24921e-05
R975 971 972 1.616 0.8 12.928 37
I972 972 0 1.29868e-05
R976 972 973 1.648 0.8 13.184 37
I973 973 0 1.31105e-05
R977 973 974 1.696 0.8 13.568 37
I974 974 0 1.32342e-05
R978 974 975 1.744 0.8 13.952 37
I975 975 0 1.31105e-05
R979 975 976 1.616 0.8 12.928 37
I976 976 0 1.26158e-05
R980 976 977 1.744 0.8 13.952 37
I977 977 0 1.31105e-05
R981 977 978 1.744 0.8 13.952 37
I978 978 0 1.26158e-05
R982 978 979 1.696 0.8 13.568 37
I979 979 0 1.26158e-05
R983 979 980 1.744 0.8 13.952 37
I980 980 0 1.34816e-05
R984 980 981 1.712 0.8 13.696 37
I981 981 0 1.28631e-05
R985 981 982 1.648 0.8 13.184 37
I982 982 0 1.33579e-05
R986 982 983 1.6 0.8 12.8 37
I983 983 0 1.33579e-05
R987 983 984 1.648 0.8 13.184 37
I984 984 0 1.27395e-05
R988 984 985 1.6 0.8 12.8 37
I985 985 0 1.33579e-05
R989 985 986 1.728 0.8 13.824 37
I986 986 0 1.28631e-05
R990 986 987 1.6 0.8 12.8 37
I987 987 0 1.24921e-05
R991 987 988 1.648 0.8 13.184 37
I988 988 0 1.23684e-05
R992 988 989 1.632 0.8 13.056 37
I989 989 0 1.31105e-05
R993 989 990 1.616 0.8 12.928 37
I990 990 0 1.31105e-05
R994 990 991 1.744 0.8 13.952 37
I991 991 0 1.27395e-05
R995 991 992 1.616 0.8 12.928 37
I992 992 0 1.26158e-05
R996 992 993 1.696 0.8 13.568 37
I993 993 0 1.24921e-05
R997 993 994 1.696 0.8 13.568 37
I994 994 0 1.32342e-05
R998 994 995 1.744 0.8 13.952 37
I995 995 0 1.31105e-05
R999 995 996 1.648 0.8 13.184 37
I996 996 0 1.24921e-05
R1000 996 997 1.728 0.8 13.824 37
I997 997 0 1.29868e-05
R1001 997 998 1.6 0.8 12.8 37
I998 998 0 1.32342e-05
R1002 998 999 1.728 0.8 13.824 37
I999 999 0 1.24921e-05
R1003 999 1000 1.632 0.8 13.056 37
I1000 1000 0 1.23684e-05
R1004 1000 1501 0.5 10 50 37
*seg: 3
R1005 1501 1001 0.4 20 80 37
I1001 1001 0 1.24921e-05
R1006 1001 1002 1.728 0.8 13.824 37
I1002 1002 0 1.28631e-05
R1007 1002 1003 1.744 0.8 13.952 37
I1003 1003 0 1.32342e-05
R1008 1003 1004 1.648 0.8 13.184 37
I1004 1004 0 1.31105e-05
R1009 1004 1005 1.648 0.8 13.184 37
I1005 1005 0 1.28631e-05
R1010 1005 1006 1.664 0.8 13.312 37
I1006 1006 0 1.29868e-05
R1011 1006 1007 1.616 0.8 12.928 37
I1007 1007 0 1.29868e-05
R1012 1007 1008 1.728 0.8 13.824 37
I1008 1008 0 1.34816e-05
R1013 1008 1009 1.68 0.8 13.44 37
I1009 1009 0 1.31105e-05
R1014 1009 1010 1.616 0.8 12.928 37
I1010 1010 0 1.26158e-05
R1015 1010 1011 1.6 0.8 12.8 37
I1011 1011 0 1.24921e-05
R1016 1011 1012 1.6 0.8 12.8 37
I1012 1012 0 1.28631e-05
R1017 1012 1013 1.712 0.8 13.696 37
I1013 1013 0 1.32342e-05
R1018 1013 1014 1.68 0.8 13.44 37
I1014 1014 0 1.26158e-05
R1019 1014 1015 1.712 0.8 13.696 37
I1015 1015 0 1.31105e-05
R1020 1015 1016 1.744 0.8 13.952 37
I1016 1016 0 1.24921e-05
R1021 1016 1017 1.696 0.8 13.568 37
I1017 1017 0 1.26158e-05
R1022 1017 1018 1.6 0.8 12.8 37
I1018 1018 0 1.26158e-05
R1023 1018 1019 1.648 0.8 13.184 37
I1019 1019 0 1.27395e-05
R1024 1019 1020 1.6 0.8 12.8 37
I1020 1020 0 1.24921e-05
R1025 1020 1021 1.648 0.8 13.184 37
I1021 1021 0 1.29868e-05
R1026 1021 1022 1.664 0.8 13.312 37
I1022 1022 0 1.27395e-05
R1027 1022 1023 1.616 0.8 12.928 37
I1023 1023 0 1.34816e-05
R1028 1023 1024 1.744 0.8 13.952 37
I1024 1024 0 1.33579e-05
R1029 1024 1025 1.632 0.8 13.056 37
I1025 1025 0 1.27395e-05
R1030 1025 1026 1.664 0.8 13.312 37
I1026 1026 0 1.26158e-05
R1031 1026 1027 1.664 0.8 13.312 37
I1027 1027 0 1.31105e-05
R1032 1027 1028 1.664 0.8 13.312 37
I1028 1028 0 1.27395e-05
R1033 1028 1029 1.68 0.8 13.44 37
I1029 1029 0 1.32342e-05
R1034 1029 1030 1.6 0.8 12.8 37
I1030 1030 0 1.26158e-05
R1035 1030 1031 1.68 0.8 13.44 37
I1031 1031 0 1.31105e-05
R1036 1031 1032 1.648 0.8 13.184 37
I1032 1032 0 1.33579e-05
R1037 1032 1033 1.712 0.8 13.696 37
I1033 1033 0 1.23684e-05
R1038 1033 1034 1.632 0.8 13.056 37
I1034 1034 0 1.27395e-05
R1039 1034 1035 1.728 0.8 13.824 37
I1035 1035 0 1.23684e-05
R1040 1035 1036 1.648 0.8 13.184 37
I1036 1036 0 1.29868e-05
R1041 1036 1037 1.648 0.8 13.184 37
I1037 1037 0 1.28631e-05
R1042 1037 1038 1.616 0.8 12.928 37
I1038 1038 0 1.34816e-05
R1043 1038 1039 1.744 0.8 13.952 37
I1039 1039 0 1.23684e-05
R1044 1039 1040 1.68 0.8 13.44 37
I1040 1040 0 1.31105e-05
R1045 1040 1041 1.632 0.8 13.056 37
I1041 1041 0 1.34816e-05
R1046 1041 1042 1.664 0.8 13.312 37
I1042 1042 0 1.33579e-05
R1047 1042 1043 1.696 0.8 13.568 37
I1043 1043 0 1.31105e-05
R1048 1043 1044 1.6 0.8 12.8 37
I1044 1044 0 1.27395e-05
R1049 1044 1045 1.648 0.8 13.184 37
I1045 1045 0 1.28631e-05
R1050 1045 1046 1.664 0.8 13.312 37
I1046 1046 0 1.31105e-05
R1051 1046 1047 1.696 0.8 13.568 37
I1047 1047 0 1.34816e-05
R1052 1047 1048 1.616 0.8 12.928 37
I1048 1048 0 1.26158e-05
R1053 1048 1049 1.664 0.8 13.312 37
I1049 1049 0 1.26158e-05
R1054 1049 1050 1.632 0.8 13.056 37
I1050 1050 0 1.32342e-05
R1055 1050 1051 1.6 0.8 12.8 37
I1051 1051 0 1.29868e-05
R1056 1051 1052 1.696 0.8 13.568 37
I1052 1052 0 1.27395e-05
R1057 1052 1053 1.696 0.8 13.568 37
I1053 1053 0 1.27395e-05
R1058 1053 1054 1.728 0.8 13.824 37
I1054 1054 0 1.33579e-05
R1059 1054 1055 1.648 0.8 13.184 37
I1055 1055 0 1.33579e-05
R1060 1055 1056 1.744 0.8 13.952 37
I1056 1056 0 1.31105e-05
R1061 1056 1057 1.664 0.8 13.312 37
I1057 1057 0 1.33579e-05
R1062 1057 1058 1.68 0.8 13.44 37
I1058 1058 0 1.29868e-05
R1063 1058 1059 1.6 0.8 12.8 37
I1059 1059 0 1.31105e-05
R1064 1059 1060 1.6 0.8 12.8 37
I1060 1060 0 1.31105e-05
R1065 1060 1061 1.616 0.8 12.928 37
I1061 1061 0 1.23684e-05
R1066 1061 1062 1.712 0.8 13.696 37
I1062 1062 0 1.32342e-05
R1067 1062 1063 1.6 0.8 12.8 37
I1063 1063 0 1.24921e-05
R1068 1063 1064 1.616 0.8 12.928 37
I1064 1064 0 1.31105e-05
R1069 1064 1065 1.616 0.8 12.928 37
I1065 1065 0 1.27395e-05
R1070 1065 1066 1.744 0.8 13.952 37
I1066 1066 0 1.26158e-05
R1071 1066 1067 1.744 0.8 13.952 37
I1067 1067 0 1.33579e-05
R1072 1067 1068 1.68 0.8 13.44 37
I1068 1068 0 1.32342e-05
R1073 1068 1069 1.664 0.8 13.312 37
I1069 1069 0 1.33579e-05
R1074 1069 1070 1.696 0.8 13.568 37
I1070 1070 0 1.27395e-05
R1075 1070 1071 1.68 0.8 13.44 37
I1071 1071 0 1.23684e-05
R1076 1071 1072 1.6 0.8 12.8 37
I1072 1072 0 1.27395e-05
R1077 1072 1073 1.664 0.8 13.312 37
I1073 1073 0 1.28631e-05
R1078 1073 1074 1.664 0.8 13.312 37
I1074 1074 0 1.29868e-05
R1079 1074 1075 1.632 0.8 13.056 37
I1075 1075 0 1.28631e-05
R1080 1075 1076 1.744 0.8 13.952 37
I1076 1076 0 1.32342e-05
R1081 1076 1077 1.712 0.8 13.696 37
I1077 1077 0 1.28631e-05
R1082 1077 1078 1.6 0.8 12.8 37
I1078 1078 0 1.24921e-05
R1083 1078 1079 1.712 0.8 13.696 37
I1079 1079 0 1.29868e-05
R1084 1079 1080 1.6 0.8 12.8 37
I1080 1080 0 1.27395e-05
R1085 1080 1081 1.728 0.8 13.824 37
I1081 1081 0 1.32342e-05
R1086 1081 1082 1.632 0.8 13.056 37
I1082 1082 0 1.34816e-05
R1087 1082 1083 1.68 0.8 13.44 37
I1083 1083 0 1.32342e-05
R1088 1083 1084 1.696 0.8 13.568 37
I1084 1084 0 1.29868e-05
R1089 1084 1085 1.632 0.8 13.056 37
I1085 1085 0 1.26158e-05
R1090 1085 1086 1.744 0.8 13.952 37
I1086 1086 0 1.29868e-05
R1091 1086 1087 1.616 0.8 12.928 37
I1087 1087 0 1.28631e-05
R1092 1087 1088 1.728 0.8 13.824 37
I1088 1088 0 1.34816e-05
R1093 1088 1089 1.632 0.8 13.056 37
I1089 1089 0 1.28631e-05
R1094 1089 1090 1.696 0.8 13.568 37
I1090 1090 0 1.28631e-05
R1095 1090 1091 1.664 0.8 13.312 37
I1091 1091 0 1.34816e-05
R1096 1091 1092 1.696 0.8 13.568 37
I1092 1092 0 1.29868e-05
R1097 1092 1093 1.728 0.8 13.824 37
I1093 1093 0 1.23684e-05
R1098 1093 1094 1.728 0.8 13.824 37
I1094 1094 0 1.33579e-05
R1099 1094 1095 1.648 0.8 13.184 37
I1095 1095 0 1.29868e-05
R1100 1095 1096 1.648 0.8 13.184 37
I1096 1096 0 1.23684e-05
R1101 1096 1097 1.616 0.8 12.928 37
I1097 1097 0 1.26158e-05
R1102 1097 1098 1.648 0.8 13.184 37
I1098 1098 0 1.29868e-05
R1103 1098 1099 1.696 0.8 13.568 37
I1099 1099 0 1.33579e-05
R1104 1099 1100 1.6 0.8 12.8 37
I1100 1100 0 1.23684e-05
R1105 1100 1101 1.664 0.8 13.312 37
I1101 1101 0 1.24921e-05
R1106 1101 1102 1.6 0.8 12.8 37
I1102 1102 0 1.23684e-05
R1107 1102 1103 1.68 0.8 13.44 37
I1103 1103 0 1.31105e-05
R1108 1103 1104 1.632 0.8 13.056 37
I1104 1104 0 1.33579e-05
R1109 1104 1105 1.664 0.8 13.312 37
I1105 1105 0 1.28631e-05
R1110 1105 1106 1.712 0.8 13.696 37
I1106 1106 0 1.29868e-05
R1111 1106 1107 1.616 0.8 12.928 37
I1107 1107 0 1.29868e-05
R1112 1107 1108 1.6 0.8 12.8 37
I1108 1108 0 1.34816e-05
R1113 1108 1109 1.728 0.8 13.824 37
I1109 1109 0 1.23684e-05
R1114 1109 1110 1.632 0.8 13.056 37
I1110 1110 0 1.24921e-05
R1115 1110 1111 1.632 0.8 13.056 37
I1111 1111 0 1.34816e-05
R1116 1111 1112 1.696 0.8 13.568 37
I1112 1112 0 1.24921e-05
R1117 1112 1113 1.632 0.8 13.056 37
I1113 1113 0 1.31105e-05
R1118 1113 1114 1.744 0.8 13.952 37
I1114 1114 0 1.23684e-05
R1119 1114 1115 1.6 0.8 12.8 37
I1115 1115 0 1.31105e-05
R1120 1115 1116 1.744 0.8 13.952 37
I1116 1116 0 1.27395e-05
R1121 1116 1117 1.712 0.8 13.696 37
I1117 1117 0 1.23684e-05
R1122 1117 1118 1.744 0.8 13.952 37
I1118 1118 0 1.33579e-05
R1123 1118 1119 1.712 0.8 13.696 37
I1119 1119 0 1.23684e-05
R1124 1119 1120 1.632 0.8 13.056 37
I1120 1120 0 1.26158e-05
R1125 1120 1121 1.664 0.8 13.312 37
I1121 1121 0 1.33579e-05
R1126 1121 1122 1.728 0.8 13.824 37
I1122 1122 0 1.34816e-05
R1127 1122 1123 1.696 0.8 13.568 37
I1123 1123 0 1.28631e-05
R1128 1123 1124 1.6 0.8 12.8 37
I1124 1124 0 1.34816e-05
R1129 1124 1125 1.728 0.8 13.824 37
I1125 1125 0 1.32342e-05
R1130 1125 1126 1.744 0.8 13.952 37
I1126 1126 0 1.24921e-05
R1131 1126 1127 1.712 0.8 13.696 37
I1127 1127 0 1.33579e-05
R1132 1127 1128 1.632 0.8 13.056 37
I1128 1128 0 1.27395e-05
R1133 1128 1129 1.728 0.8 13.824 37
I1129 1129 0 1.28631e-05
R1134 1129 1130 1.632 0.8 13.056 37
I1130 1130 0 1.24921e-05
R1135 1130 1131 1.632 0.8 13.056 37
I1131 1131 0 1.26158e-05
R1136 1131 1132 1.664 0.8 13.312 37
I1132 1132 0 1.26158e-05
R1137 1132 1133 1.744 0.8 13.952 37
I1133 1133 0 1.32342e-05
R1138 1133 1134 1.616 0.8 12.928 37
I1134 1134 0 1.33579e-05
R1139 1134 1135 1.632 0.8 13.056 37
I1135 1135 0 1.34816e-05
R1140 1135 1136 1.6 0.8 12.8 37
I1136 1136 0 1.32342e-05
R1141 1136 1137 1.744 0.8 13.952 37
I1137 1137 0 1.29868e-05
R1142 1137 1138 1.712 0.8 13.696 37
I1138 1138 0 1.26158e-05
R1143 1138 1139 1.68 0.8 13.44 37
I1139 1139 0 1.29868e-05
R1144 1139 1140 1.648 0.8 13.184 37
I1140 1140 0 1.33579e-05
R1145 1140 1141 1.712 0.8 13.696 37
I1141 1141 0 1.29868e-05
R1146 1141 1142 1.696 0.8 13.568 37
I1142 1142 0 1.23684e-05
R1147 1142 1143 1.696 0.8 13.568 37
I1143 1143 0 1.27395e-05
R1148 1143 1144 1.744 0.8 13.952 37
I1144 1144 0 1.34816e-05
R1149 1144 1145 1.68 0.8 13.44 37
I1145 1145 0 1.31105e-05
R1150 1145 1146 1.664 0.8 13.312 37
I1146 1146 0 1.29868e-05
R1151 1146 1147 1.632 0.8 13.056 37
I1147 1147 0 1.26158e-05
R1152 1147 1148 1.6 0.8 12.8 37
I1148 1148 0 1.33579e-05
R1153 1148 1149 1.664 0.8 13.312 37
I1149 1149 0 1.26158e-05
R1154 1149 1150 1.728 0.8 13.824 37
I1150 1150 0 1.32342e-05
R1155 1150 1151 1.632 0.8 13.056 37
I1151 1151 0 1.31105e-05
R1156 1151 1152 1.648 0.8 13.184 37
I1152 1152 0 1.24921e-05
R1157 1152 1153 1.648 0.8 13.184 37
I1153 1153 0 1.28631e-05
R1158 1153 1154 1.712 0.8 13.696 37
I1154 1154 0 1.27395e-05
R1159 1154 1155 1.648 0.8 13.184 37
I1155 1155 0 1.31105e-05
R1160 1155 1156 1.6 0.8 12.8 37
I1156 1156 0 1.34816e-05
R1161 1156 1157 1.648 0.8 13.184 37
I1157 1157 0 1.23684e-05
R1162 1157 1158 1.632 0.8 13.056 37
I1158 1158 0 1.24921e-05
R1163 1158 1159 1.696 0.8 13.568 37
I1159 1159 0 1.34816e-05
R1164 1159 1160 1.728 0.8 13.824 37
I1160 1160 0 1.32342e-05
R1165 1160 1161 1.664 0.8 13.312 37
I1161 1161 0 1.26158e-05
R1166 1161 1162 1.616 0.8 12.928 37
I1162 1162 0 1.26158e-05
R1167 1162 1163 1.616 0.8 12.928 37
I1163 1163 0 1.23684e-05
R1168 1163 1164 1.712 0.8 13.696 37
I1164 1164 0 1.23684e-05
R1169 1164 1165 1.696 0.8 13.568 37
I1165 1165 0 1.26158e-05
R1170 1165 1166 1.744 0.8 13.952 37
I1166 1166 0 1.24921e-05
R1171 1166 1167 1.648 0.8 13.184 37
I1167 1167 0 1.27395e-05
R1172 1167 1168 1.664 0.8 13.312 37
I1168 1168 0 1.33579e-05
R1173 1168 1169 1.744 0.8 13.952 37
I1169 1169 0 1.34816e-05
R1174 1169 1170 1.6 0.8 12.8 37
I1170 1170 0 1.33579e-05
R1175 1170 1171 1.632 0.8 13.056 37
I1171 1171 0 1.32342e-05
R1176 1171 1172 1.744 0.8 13.952 37
I1172 1172 0 1.26158e-05
R1177 1172 1173 1.696 0.8 13.568 37
I1173 1173 0 1.29868e-05
R1178 1173 1174 1.632 0.8 13.056 37
I1174 1174 0 1.24921e-05
R1179 1174 1175 1.632 0.8 13.056 37
I1175 1175 0 1.27395e-05
R1180 1175 1176 1.712 0.8 13.696 37
I1176 1176 0 1.32342e-05
R1181 1176 1177 1.664 0.8 13.312 37
I1177 1177 0 1.34816e-05
R1182 1177 1178 1.664 0.8 13.312 37
I1178 1178 0 1.29868e-05
R1183 1178 1179 1.728 0.8 13.824 37
I1179 1179 0 1.23684e-05
R1184 1179 1180 1.68 0.8 13.44 37
I1180 1180 0 1.33579e-05
R1185 1180 1181 1.744 0.8 13.952 37
I1181 1181 0 1.32342e-05
R1186 1181 1182 1.68 0.8 13.44 37
I1182 1182 0 1.29868e-05
R1187 1182 1183 1.616 0.8 12.928 37
I1183 1183 0 1.33579e-05
R1188 1183 1184 1.616 0.8 12.928 37
I1184 1184 0 1.23684e-05
R1189 1184 1185 1.728 0.8 13.824 37
I1185 1185 0 1.26158e-05
R1190 1185 1186 1.648 0.8 13.184 37
I1186 1186 0 1.31105e-05
R1191 1186 1187 1.728 0.8 13.824 37
I1187 1187 0 1.24921e-05
R1192 1187 1188 1.712 0.8 13.696 37
I1188 1188 0 1.24921e-05
R1193 1188 1189 1.648 0.8 13.184 37
I1189 1189 0 1.29868e-05
R1194 1189 1190 1.664 0.8 13.312 37
I1190 1190 0 1.28631e-05
R1195 1190 1191 1.696 0.8 13.568 37
I1191 1191 0 1.26158e-05
R1196 1191 1192 1.616 0.8 12.928 37
I1192 1192 0 1.33579e-05
R1197 1192 1193 1.68 0.8 13.44 37
I1193 1193 0 1.32342e-05
R1198 1193 1194 1.616 0.8 12.928 37
I1194 1194 0 1.29868e-05
R1199 1194 1195 1.68 0.8 13.44 37
I1195 1195 0 1.24921e-05
R1200 1195 1196 1.664 0.8 13.312 37
I1196 1196 0 1.27395e-05
R1201 1196 1197 1.728 0.8 13.824 37
I1197 1197 0 1.32342e-05
R1202 1197 1198 1.648 0.8 13.184 37
I1198 1198 0 1.31105e-05
R1203 1198 1199 1.6 0.8 12.8 37
I1199 1199 0 1.27395e-05
R1204 1199 1200 1.68 0.8 13.44 37
I1200 1200 0 1.34816e-05
R1205 1200 1201 1.728 0.8 13.824 37
I1201 1201 0 1.27395e-05
R1206 1201 1202 1.648 0.8 13.184 37
I1202 1202 0 1.26158e-05
R1207 1202 1203 1.744 0.8 13.952 37
I1203 1203 0 1.28631e-05
R1208 1203 1204 1.6 0.8 12.8 37
I1204 1204 0 1.29868e-05
R1209 1204 1205 1.648 0.8 13.184 37
I1205 1205 0 1.33579e-05
R1210 1205 1206 1.68 0.8 13.44 37
I1206 1206 0 1.34816e-05
R1211 1206 1207 1.696 0.8 13.568 37
I1207 1207 0 1.34816e-05
R1212 1207 1208 1.68 0.8 13.44 37
I1208 1208 0 1.34816e-05
R1213 1208 1209 1.744 0.8 13.952 37
I1209 1209 0 1.32342e-05
R1214 1209 1210 1.648 0.8 13.184 37
I1210 1210 0 1.33579e-05
R1215 1210 1211 1.632 0.8 13.056 37
I1211 1211 0 1.33579e-05
R1216 1211 1212 1.6 0.8 12.8 37
I1212 1212 0 1.33579e-05
R1217 1212 1213 1.616 0.8 12.928 37
I1213 1213 0 1.27395e-05
R1218 1213 1214 1.696 0.8 13.568 37
I1214 1214 0 1.31105e-05
R1219 1214 1215 1.632 0.8 13.056 37
I1215 1215 0 1.27395e-05
R1220 1215 1216 1.6 0.8 12.8 37
I1216 1216 0 1.27395e-05
R1221 1216 1217 1.616 0.8 12.928 37
I1217 1217 0 1.31105e-05
R1222 1217 1218 1.616 0.8 12.928 37
I1218 1218 0 1.28631e-05
R1223 1218 1219 1.712 0.8 13.696 37
I1219 1219 0 1.28631e-05
R1224 1219 1220 1.6 0.8 12.8 37
I1220 1220 0 1.32342e-05
R1225 1220 1221 1.728 0.8 13.824 37
I1221 1221 0 1.23684e-05
R1226 1221 1222 1.616 0.8 12.928 37
I1222 1222 0 1.32342e-05
R1227 1222 1223 1.648 0.8 13.184 37
I1223 1223 0 1.29868e-05
R1228 1223 1224 1.696 0.8 13.568 37
I1224 1224 0 1.32342e-05
R1229 1224 1225 1.632 0.8 13.056 37
I1225 1225 0 1.32342e-05
R1230 1225 1226 1.664 0.8 13.312 37
I1226 1226 0 1.31105e-05
R1231 1226 1227 1.712 0.8 13.696 37
I1227 1227 0 1.29868e-05
R1232 1227 1228 1.696 0.8 13.568 37
I1228 1228 0 1.34816e-05
R1233 1228 1229 1.712 0.8 13.696 37
I1229 1229 0 1.27395e-05
R1234 1229 1230 1.6 0.8 12.8 37
I1230 1230 0 1.28631e-05
R1235 1230 1231 1.648 0.8 13.184 37
I1231 1231 0 1.32342e-05
R1236 1231 1232 1.616 0.8 12.928 37
I1232 1232 0 1.31105e-05
R1237 1232 1233 1.744 0.8 13.952 37
I1233 1233 0 1.34816e-05
R1238 1233 1234 1.632 0.8 13.056 37
I1234 1234 0 1.29868e-05
R1239 1234 1235 1.664 0.8 13.312 37
I1235 1235 0 1.23684e-05
R1240 1235 1236 1.6 0.8 12.8 37
I1236 1236 0 1.32342e-05
R1241 1236 1237 1.712 0.8 13.696 37
I1237 1237 0 1.29868e-05
R1242 1237 1238 1.632 0.8 13.056 37
I1238 1238 0 1.33579e-05
R1243 1238 1239 1.728 0.8 13.824 37
I1239 1239 0 1.29868e-05
R1244 1239 1240 1.744 0.8 13.952 37
I1240 1240 0 1.28631e-05
R1245 1240 1241 1.632 0.8 13.056 37
I1241 1241 0 1.27395e-05
R1246 1241 1242 1.712 0.8 13.696 37
I1242 1242 0 1.23684e-05
R1247 1242 1243 1.6 0.8 12.8 37
I1243 1243 0 1.28631e-05
R1248 1243 1244 1.728 0.8 13.824 37
I1244 1244 0 1.32342e-05
R1249 1244 1245 1.632 0.8 13.056 37
I1245 1245 0 1.27395e-05
R1250 1245 1246 1.728 0.8 13.824 37
I1246 1246 0 1.24921e-05
R1251 1246 1247 1.648 0.8 13.184 37
I1247 1247 0 1.32342e-05
R1252 1247 1248 1.632 0.8 13.056 37
I1248 1248 0 1.31105e-05
R1253 1248 1249 1.664 0.8 13.312 37
I1249 1249 0 1.31105e-05
R1254 1249 1250 1.68 0.8 13.44 37
I1250 1250 0 1.31105e-05
R1255 1250 1251 1.6 0.8 12.8 37
I1251 1251 0 1.28631e-05
R1256 1251 1252 1.712 0.8 13.696 37
I1252 1252 0 1.28631e-05
R1257 1252 1253 1.632 0.8 13.056 37
I1253 1253 0 1.27395e-05
R1258 1253 1254 1.68 0.8 13.44 37
I1254 1254 0 1.34816e-05
R1259 1254 1255 1.648 0.8 13.184 37
I1255 1255 0 1.34816e-05
R1260 1255 1256 1.744 0.8 13.952 37
I1256 1256 0 1.26158e-05
R1261 1256 1257 1.68 0.8 13.44 37
I1257 1257 0 1.28631e-05
R1262 1257 1258 1.632 0.8 13.056 37
I1258 1258 0 1.27395e-05
R1263 1258 1259 1.728 0.8 13.824 37
I1259 1259 0 1.27395e-05
R1264 1259 1260 1.712 0.8 13.696 37
I1260 1260 0 1.27395e-05
R1265 1260 1261 1.648 0.8 13.184 37
I1261 1261 0 1.23684e-05
R1266 1261 1262 1.6 0.8 12.8 37
I1262 1262 0 1.29868e-05
R1267 1262 1263 1.616 0.8 12.928 37
I1263 1263 0 1.24921e-05
R1268 1263 1264 1.696 0.8 13.568 37
I1264 1264 0 1.31105e-05
R1269 1264 1265 1.712 0.8 13.696 37
I1265 1265 0 1.34816e-05
R1270 1265 1266 1.616 0.8 12.928 37
I1266 1266 0 1.28631e-05
R1271 1266 1267 1.6 0.8 12.8 37
I1267 1267 0 1.27395e-05
R1272 1267 1268 1.68 0.8 13.44 37
I1268 1268 0 1.24921e-05
R1273 1268 1269 1.616 0.8 12.928 37
I1269 1269 0 1.24921e-05
R1274 1269 1270 1.68 0.8 13.44 37
I1270 1270 0 1.24921e-05
R1275 1270 1271 1.648 0.8 13.184 37
I1271 1271 0 1.29868e-05
R1276 1271 1272 1.744 0.8 13.952 37
I1272 1272 0 1.27395e-05
R1277 1272 1273 1.648 0.8 13.184 37
I1273 1273 0 1.23684e-05
R1278 1273 1274 1.68 0.8 13.44 37
I1274 1274 0 1.23684e-05
R1279 1274 1275 1.712 0.8 13.696 37
I1275 1275 0 1.29868e-05
R1280 1275 1276 1.68 0.8 13.44 37
I1276 1276 0 1.29868e-05
R1281 1276 1277 1.728 0.8 13.824 37
I1277 1277 0 1.23684e-05
R1282 1277 1278 1.696 0.8 13.568 37
I1278 1278 0 1.29868e-05
R1283 1278 1279 1.616 0.8 12.928 37
I1279 1279 0 1.34816e-05
R1284 1279 1280 1.728 0.8 13.824 37
I1280 1280 0 1.27395e-05
R1285 1280 1281 1.696 0.8 13.568 37
I1281 1281 0 1.26158e-05
R1286 1281 1282 1.664 0.8 13.312 37
I1282 1282 0 1.27395e-05
R1287 1282 1283 1.728 0.8 13.824 37
I1283 1283 0 1.29868e-05
R1288 1283 1284 1.6 0.8 12.8 37
I1284 1284 0 1.28631e-05
R1289 1284 1285 1.696 0.8 13.568 37
I1285 1285 0 1.23684e-05
R1290 1285 1286 1.664 0.8 13.312 37
I1286 1286 0 1.26158e-05
R1291 1286 1287 1.632 0.8 13.056 37
I1287 1287 0 1.29868e-05
R1292 1287 1288 1.648 0.8 13.184 37
I1288 1288 0 1.27395e-05
R1293 1288 1289 1.648 0.8 13.184 37
I1289 1289 0 1.33579e-05
R1294 1289 1290 1.664 0.8 13.312 37
I1290 1290 0 1.32342e-05
R1295 1290 1291 1.68 0.8 13.44 37
I1291 1291 0 1.28631e-05
R1296 1291 1292 1.728 0.8 13.824 37
I1292 1292 0 1.34816e-05
R1297 1292 1293 1.744 0.8 13.952 37
I1293 1293 0 1.28631e-05
R1298 1293 1294 1.648 0.8 13.184 37
I1294 1294 0 1.24921e-05
R1299 1294 1295 1.664 0.8 13.312 37
I1295 1295 0 1.32342e-05
R1300 1295 1296 1.648 0.8 13.184 37
I1296 1296 0 1.33579e-05
R1301 1296 1297 1.632 0.8 13.056 37
I1297 1297 0 1.24921e-05
R1302 1297 1298 1.68 0.8 13.44 37
I1298 1298 0 1.27395e-05
R1303 1298 1299 1.6 0.8 12.8 37
I1299 1299 0 1.33579e-05
R1304 1299 1300 1.648 0.8 13.184 37
I1300 1300 0 1.31105e-05
R1305 1300 1301 1.68 0.8 13.44 37
I1301 1301 0 1.31105e-05
R1306 1301 1302 1.68 0.8 13.44 37
I1302 1302 0 1.26158e-05
R1307 1302 1303 1.664 0.8 13.312 37
I1303 1303 0 1.26158e-05
R1308 1303 1304 1.6 0.8 12.8 37
I1304 1304 0 1.33579e-05
R1309 1304 1305 1.712 0.8 13.696 37
I1305 1305 0 1.23684e-05
R1310 1305 1306 1.744 0.8 13.952 37
I1306 1306 0 1.32342e-05
R1311 1306 1307 1.728 0.8 13.824 37
I1307 1307 0 1.23684e-05
R1312 1307 1308 1.744 0.8 13.952 37
I1308 1308 0 1.23684e-05
R1313 1308 1309 1.68 0.8 13.44 37
I1309 1309 0 1.31105e-05
R1314 1309 1310 1.728 0.8 13.824 37
I1310 1310 0 1.33579e-05
R1315 1310 1311 1.648 0.8 13.184 37
I1311 1311 0 1.26158e-05
R1316 1311 1312 1.664 0.8 13.312 37
I1312 1312 0 1.24921e-05
R1317 1312 1313 1.712 0.8 13.696 37
I1313 1313 0 1.34816e-05
R1318 1313 1314 1.712 0.8 13.696 37
I1314 1314 0 1.34816e-05
R1319 1314 1315 1.728 0.8 13.824 37
I1315 1315 0 1.32342e-05
R1320 1315 1316 1.664 0.8 13.312 37
I1316 1316 0 1.26158e-05
R1321 1316 1317 1.696 0.8 13.568 37
I1317 1317 0 1.34816e-05
R1322 1317 1318 1.632 0.8 13.056 37
I1318 1318 0 1.31105e-05
R1323 1318 1319 1.712 0.8 13.696 37
I1319 1319 0 1.27395e-05
R1324 1319 1320 1.712 0.8 13.696 37
I1320 1320 0 1.28631e-05
R1325 1320 1321 1.68 0.8 13.44 37
I1321 1321 0 1.31105e-05
R1326 1321 1322 1.712 0.8 13.696 37
I1322 1322 0 1.32342e-05
R1327 1322 1323 1.728 0.8 13.824 37
I1323 1323 0 1.33579e-05
R1328 1323 1324 1.68 0.8 13.44 37
I1324 1324 0 1.34816e-05
R1329 1324 1325 1.728 0.8 13.824 37
I1325 1325 0 1.23684e-05
R1330 1325 1326 1.696 0.8 13.568 37
I1326 1326 0 1.32342e-05
R1331 1326 1327 1.664 0.8 13.312 37
I1327 1327 0 1.32342e-05
R1332 1327 1328 1.712 0.8 13.696 37
I1328 1328 0 1.23684e-05
R1333 1328 1329 1.632 0.8 13.056 37
I1329 1329 0 1.32342e-05
R1334 1329 1330 1.648 0.8 13.184 37
I1330 1330 0 1.31105e-05
R1335 1330 1331 1.664 0.8 13.312 37
I1331 1331 0 1.31105e-05
R1336 1331 1332 1.632 0.8 13.056 37
I1332 1332 0 1.31105e-05
R1337 1332 1333 1.728 0.8 13.824 37
I1333 1333 0 1.24921e-05
R1338 1333 1334 1.712 0.8 13.696 37
I1334 1334 0 1.29868e-05
R1339 1334 1335 1.712 0.8 13.696 37
I1335 1335 0 1.31105e-05
R1340 1335 1336 1.712 0.8 13.696 37
I1336 1336 0 1.34816e-05
R1341 1336 1337 1.648 0.8 13.184 37
I1337 1337 0 1.32342e-05
R1342 1337 1338 1.664 0.8 13.312 37
I1338 1338 0 1.34816e-05
R1343 1338 1339 1.616 0.8 12.928 37
I1339 1339 0 1.28631e-05
R1344 1339 1340 1.6 0.8 12.8 37
I1340 1340 0 1.32342e-05
R1345 1340 1341 1.616 0.8 12.928 37
I1341 1341 0 1.24921e-05
R1346 1341 1342 1.728 0.8 13.824 37
I1342 1342 0 1.31105e-05
R1347 1342 1343 1.744 0.8 13.952 37
I1343 1343 0 1.33579e-05
R1348 1343 1344 1.68 0.8 13.44 37
I1344 1344 0 1.23684e-05
R1349 1344 1345 1.616 0.8 12.928 37
I1345 1345 0 1.32342e-05
R1350 1345 1346 1.632 0.8 13.056 37
I1346 1346 0 1.33579e-05
R1351 1346 1347 1.632 0.8 13.056 37
I1347 1347 0 1.26158e-05
R1352 1347 1348 1.616 0.8 12.928 37
I1348 1348 0 1.24921e-05
R1353 1348 1349 1.712 0.8 13.696 37
I1349 1349 0 1.27395e-05
R1354 1349 1350 1.648 0.8 13.184 37
I1350 1350 0 1.28631e-05
R1355 1350 1351 1.664 0.8 13.312 37
I1351 1351 0 1.27395e-05
R1356 1351 1352 1.712 0.8 13.696 37
I1352 1352 0 1.34816e-05
R1357 1352 1353 1.616 0.8 12.928 37
I1353 1353 0 1.29868e-05
R1358 1353 1354 1.616 0.8 12.928 37
I1354 1354 0 1.31105e-05
R1359 1354 1355 1.648 0.8 13.184 37
I1355 1355 0 1.32342e-05
R1360 1355 1356 1.6 0.8 12.8 37
I1356 1356 0 1.28631e-05
R1361 1356 1357 1.728 0.8 13.824 37
I1357 1357 0 1.24921e-05
R1362 1357 1358 1.728 0.8 13.824 37
I1358 1358 0 1.23684e-05
R1363 1358 1359 1.68 0.8 13.44 37
I1359 1359 0 1.27395e-05
R1364 1359 1360 1.68 0.8 13.44 37
I1360 1360 0 1.31105e-05
R1365 1360 1361 1.712 0.8 13.696 37
I1361 1361 0 1.24921e-05
R1366 1361 1362 1.744 0.8 13.952 37
I1362 1362 0 1.31105e-05
R1367 1362 1363 1.664 0.8 13.312 37
I1363 1363 0 1.34816e-05
R1368 1363 1364 1.68 0.8 13.44 37
I1364 1364 0 1.23684e-05
R1369 1364 1365 1.6 0.8 12.8 37
I1365 1365 0 1.23684e-05
R1370 1365 1366 1.648 0.8 13.184 37
I1366 1366 0 1.27395e-05
R1371 1366 1367 1.664 0.8 13.312 37
I1367 1367 0 1.31105e-05
R1372 1367 1368 1.6 0.8 12.8 37
I1368 1368 0 1.34816e-05
R1373 1368 1369 1.712 0.8 13.696 37
I1369 1369 0 1.26158e-05
R1374 1369 1370 1.696 0.8 13.568 37
I1370 1370 0 1.28631e-05
R1375 1370 1371 1.6 0.8 12.8 37
I1371 1371 0 1.33579e-05
R1376 1371 1372 1.6 0.8 12.8 37
I1372 1372 0 1.26158e-05
R1377 1372 1373 1.696 0.8 13.568 37
I1373 1373 0 1.24921e-05
R1378 1373 1374 1.696 0.8 13.568 37
I1374 1374 0 1.32342e-05
R1379 1374 1375 1.648 0.8 13.184 37
I1375 1375 0 1.34816e-05
R1380 1375 1376 1.632 0.8 13.056 37
I1376 1376 0 1.26158e-05
R1381 1376 1377 1.696 0.8 13.568 37
I1377 1377 0 1.31105e-05
R1382 1377 1378 1.712 0.8 13.696 37
I1378 1378 0 1.32342e-05
R1383 1378 1379 1.68 0.8 13.44 37
I1379 1379 0 1.32342e-05
R1384 1379 1380 1.744 0.8 13.952 37
I1380 1380 0 1.34816e-05
R1385 1380 1381 1.632 0.8 13.056 37
I1381 1381 0 1.34816e-05
R1386 1381 1382 1.632 0.8 13.056 37
I1382 1382 0 1.29868e-05
R1387 1382 1383 1.744 0.8 13.952 37
I1383 1383 0 1.23684e-05
R1388 1383 1384 1.616 0.8 12.928 37
I1384 1384 0 1.26158e-05
R1389 1384 1385 1.648 0.8 13.184 37
I1385 1385 0 1.34816e-05
R1390 1385 1386 1.696 0.8 13.568 37
I1386 1386 0 1.28631e-05
R1391 1386 1387 1.6 0.8 12.8 37
I1387 1387 0 1.33579e-05
R1392 1387 1388 1.664 0.8 13.312 37
I1388 1388 0 1.24921e-05
R1393 1388 1389 1.616 0.8 12.928 37
I1389 1389 0 1.27395e-05
R1394 1389 1390 1.744 0.8 13.952 37
I1390 1390 0 1.28631e-05
R1395 1390 1391 1.68 0.8 13.44 37
I1391 1391 0 1.26158e-05
R1396 1391 1392 1.728 0.8 13.824 37
I1392 1392 0 1.29868e-05
R1397 1392 1393 1.648 0.8 13.184 37
I1393 1393 0 1.33579e-05
R1398 1393 1394 1.696 0.8 13.568 37
I1394 1394 0 1.24921e-05
R1399 1394 1395 1.632 0.8 13.056 37
I1395 1395 0 1.24921e-05
R1400 1395 1396 1.664 0.8 13.312 37
I1396 1396 0 1.29868e-05
R1401 1396 1397 1.648 0.8 13.184 37
I1397 1397 0 1.29868e-05
R1402 1397 1398 1.648 0.8 13.184 37
I1398 1398 0 1.24921e-05
R1403 1398 1399 1.728 0.8 13.824 37
I1399 1399 0 1.34816e-05
R1404 1399 1400 1.664 0.8 13.312 37
I1400 1400 0 1.29868e-05
R1405 1400 1401 1.728 0.8 13.824 37
I1401 1401 0 1.23684e-05
R1406 1401 1402 1.744 0.8 13.952 37
I1402 1402 0 1.24921e-05
R1407 1402 1403 1.6 0.8 12.8 37
I1403 1403 0 1.27395e-05
R1408 1403 1404 1.712 0.8 13.696 37
I1404 1404 0 1.23684e-05
R1409 1404 1405 1.68 0.8 13.44 37
I1405 1405 0 1.29868e-05
R1410 1405 1406 1.648 0.8 13.184 37
I1406 1406 0 1.33579e-05
R1411 1406 1407 1.664 0.8 13.312 37
I1407 1407 0 1.31105e-05
R1412 1407 1408 1.744 0.8 13.952 37
I1408 1408 0 1.28631e-05
R1413 1408 1409 1.664 0.8 13.312 37
I1409 1409 0 1.34816e-05
R1414 1409 1410 1.616 0.8 12.928 37
I1410 1410 0 1.27395e-05
R1415 1410 1411 1.648 0.8 13.184 37
I1411 1411 0 1.34816e-05
R1416 1411 1412 1.696 0.8 13.568 37
I1412 1412 0 1.31105e-05
R1417 1412 1413 1.68 0.8 13.44 37
I1413 1413 0 1.27395e-05
R1418 1413 1414 1.696 0.8 13.568 37
I1414 1414 0 1.29868e-05
R1419 1414 1415 1.712 0.8 13.696 37
I1415 1415 0 1.32342e-05
R1420 1415 1416 1.6 0.8 12.8 37
I1416 1416 0 1.28631e-05
R1421 1416 1417 1.728 0.8 13.824 37
I1417 1417 0 1.24921e-05
R1422 1417 1418 1.712 0.8 13.696 37
I1418 1418 0 1.29868e-05
R1423 1418 1419 1.632 0.8 13.056 37
I1419 1419 0 1.29868e-05
R1424 1419 1420 1.632 0.8 13.056 37
I1420 1420 0 1.32342e-05
R1425 1420 1421 1.6 0.8 12.8 37
I1421 1421 0 1.26158e-05
R1426 1421 1422 1.712 0.8 13.696 37
I1422 1422 0 1.29868e-05
R1427 1422 1423 1.696 0.8 13.568 37
I1423 1423 0 1.23684e-05
R1428 1423 1424 1.68 0.8 13.44 37
I1424 1424 0 1.31105e-05
R1429 1424 1425 1.728 0.8 13.824 37
I1425 1425 0 1.23684e-05
R1430 1425 1426 1.664 0.8 13.312 37
I1426 1426 0 1.26158e-05
R1431 1426 1427 1.744 0.8 13.952 37
I1427 1427 0 1.27395e-05
R1432 1427 1428 1.744 0.8 13.952 37
I1428 1428 0 1.32342e-05
R1433 1428 1429 1.696 0.8 13.568 37
I1429 1429 0 1.23684e-05
R1434 1429 1430 1.648 0.8 13.184 37
I1430 1430 0 1.28631e-05
R1435 1430 1431 1.68 0.8 13.44 37
I1431 1431 0 1.27395e-05
R1436 1431 1432 1.664 0.8 13.312 37
I1432 1432 0 1.26158e-05
R1437 1432 1433 1.6 0.8 12.8 37
I1433 1433 0 1.27395e-05
R1438 1433 1434 1.648 0.8 13.184 37
I1434 1434 0 1.33579e-05
R1439 1434 1435 1.696 0.8 13.568 37
I1435 1435 0 1.28631e-05
R1440 1435 1436 1.664 0.8 13.312 37
I1436 1436 0 1.31105e-05
R1441 1436 1437 1.632 0.8 13.056 37
I1437 1437 0 1.33579e-05
R1442 1437 1438 1.6 0.8 12.8 37
I1438 1438 0 1.33579e-05
R1443 1438 1439 1.712 0.8 13.696 37
I1439 1439 0 1.23684e-05
R1444 1439 1440 1.696 0.8 13.568 37
I1440 1440 0 1.32342e-05
R1445 1440 1441 1.68 0.8 13.44 37
I1441 1441 0 1.29868e-05
R1446 1441 1442 1.6 0.8 12.8 37
I1442 1442 0 1.28631e-05
R1447 1442 1443 1.728 0.8 13.824 37
I1443 1443 0 1.31105e-05
R1448 1443 1444 1.696 0.8 13.568 37
I1444 1444 0 1.34816e-05
R1449 1444 1445 1.728 0.8 13.824 37
I1445 1445 0 1.27395e-05
R1450 1445 1446 1.744 0.8 13.952 37
I1446 1446 0 1.26158e-05
R1451 1446 1447 1.712 0.8 13.696 37
I1447 1447 0 1.26158e-05
R1452 1447 1448 1.648 0.8 13.184 37
I1448 1448 0 1.27395e-05
R1453 1448 1449 1.68 0.8 13.44 37
I1449 1449 0 1.24921e-05
R1454 1449 1450 1.648 0.8 13.184 37
I1450 1450 0 1.27395e-05
R1455 1450 1451 1.664 0.8 13.312 37
I1451 1451 0 1.26158e-05
R1456 1451 1452 1.696 0.8 13.568 37
I1452 1452 0 1.27395e-05
R1457 1452 1453 1.728 0.8 13.824 37
I1453 1453 0 1.24921e-05
R1458 1453 1454 1.728 0.8 13.824 37
I1454 1454 0 1.31105e-05
R1459 1454 1455 1.68 0.8 13.44 37
I1455 1455 0 1.32342e-05
R1460 1455 1456 1.744 0.8 13.952 37
I1456 1456 0 1.29868e-05
R1461 1456 1457 1.664 0.8 13.312 37
I1457 1457 0 1.28631e-05
R1462 1457 1458 1.712 0.8 13.696 37
I1458 1458 0 1.31105e-05
R1463 1458 1459 1.6 0.8 12.8 37
I1459 1459 0 1.23684e-05
R1464 1459 1460 1.616 0.8 12.928 37
I1460 1460 0 1.28631e-05
R1465 1460 1461 1.696 0.8 13.568 37
I1461 1461 0 1.34816e-05
R1466 1461 1462 1.632 0.8 13.056 37
I1462 1462 0 1.28631e-05
R1467 1462 1463 1.712 0.8 13.696 37
I1463 1463 0 1.33579e-05
R1468 1463 1464 1.632 0.8 13.056 37
I1464 1464 0 1.24921e-05
R1469 1464 1465 1.648 0.8 13.184 37
I1465 1465 0 1.27395e-05
R1470 1465 1466 1.6 0.8 12.8 37
I1466 1466 0 1.26158e-05
R1471 1466 1467 1.728 0.8 13.824 37
I1467 1467 0 1.29868e-05
R1472 1467 1468 1.616 0.8 12.928 37
I1468 1468 0 1.32342e-05
R1473 1468 1469 1.6 0.8 12.8 37
I1469 1469 0 1.33579e-05
R1474 1469 1470 1.616 0.8 12.928 37
I1470 1470 0 1.27395e-05
R1475 1470 1471 1.664 0.8 13.312 37
I1471 1471 0 1.29868e-05
R1476 1471 1472 1.6 0.8 12.8 37
I1472 1472 0 1.27395e-05
R1477 1472 1473 1.632 0.8 13.056 37
I1473 1473 0 1.26158e-05
R1478 1473 1474 1.664 0.8 13.312 37
I1474 1474 0 1.28631e-05
R1479 1474 1475 1.648 0.8 13.184 37
I1475 1475 0 1.34816e-05
R1480 1475 1476 1.616 0.8 12.928 37
I1476 1476 0 1.34816e-05
R1481 1476 1477 1.632 0.8 13.056 37
I1477 1477 0 1.33579e-05
R1482 1477 1478 1.712 0.8 13.696 37
I1478 1478 0 1.33579e-05
R1483 1478 1479 1.616 0.8 12.928 37
I1479 1479 0 1.24921e-05
R1484 1479 1480 1.664 0.8 13.312 37
I1480 1480 0 1.33579e-05
R1485 1480 1481 1.664 0.8 13.312 37
I1481 1481 0 1.24921e-05
R1486 1481 1482 1.728 0.8 13.824 37
I1482 1482 0 1.29868e-05
R1487 1482 1483 1.6 0.8 12.8 37
I1483 1483 0 1.27395e-05
R1488 1483 1484 1.728 0.8 13.824 37
I1484 1484 0 1.28631e-05
R1489 1484 1485 1.616 0.8 12.928 37
I1485 1485 0 1.29868e-05
R1490 1485 1486 1.696 0.8 13.568 37
I1486 1486 0 1.28631e-05
R1491 1486 1487 1.696 0.8 13.568 37
I1487 1487 0 1.23684e-05
R1492 1487 1488 1.664 0.8 13.312 37
I1488 1488 0 1.33579e-05
R1493 1488 1489 1.664 0.8 13.312 37
I1489 1489 0 1.24921e-05
R1494 1489 1490 1.6 0.8 12.8 37
I1490 1490 0 1.29868e-05
R1495 1490 1491 1.632 0.8 13.056 37
I1491 1491 0 1.33579e-05
R1496 1491 1492 1.68 0.8 13.44 37
I1492 1492 0 1.23684e-05
R1497 1492 1493 1.6 0.8 12.8 37
I1493 1493 0 1.31105e-05
R1498 1493 1494 1.68 0.8 13.44 37
I1494 1494 0 1.29868e-05
R1499 1494 1495 1.696 0.8 13.568 37
I1495 1495 0 1.33579e-05
R1500 1495 1496 1.632 0.8 13.056 37
I1496 1496 0 1.34816e-05
R1501 1496 1497 1.632 0.8 13.056 37
I1497 1497 0 1.27395e-05
R1502 1497 1498 1.6 0.8 12.8 37
I1498 1498 0 1.28631e-05
R1503 1498 1499 1.664 0.8 13.312 37
I1499 1499 0 1.27395e-05
R1504 1499 1500 1.712 0.8 13.696 37
I1500 1500 0 1.23684e-05
R1505 1500 1501 0.5 10 50 37
V1 1501 0 5

.op
.end
