num_node 3001
matrix_size 3002

* 300 x 10 ground network
*seg: 1
R1 3001 1 2.5 0.8 20 37
R2 5 15 6.16 0.8 49.28 37
I1 1 0 1.33579e-03
R3 1 2 1.728 0.8 13.824 37
I2 2 0 1.27395e-03
R4 2 3 1.68 0.8 13.44 37
I3 3 0 1.24921e-03
R5 3 4 1.712 0.8 13.696 37
I4 4 0 1.23684e-03
R6 4 5 1.744 0.8 13.952 37
I5 5 0 1.26158e-03
R7 5 6 1.696 0.8 13.568 37
I6 6 0 1.34816e-03
R8 6 7 1.712 0.8 13.696 37
I7 7 0 1.28631e-03
R9 7 8 1.6 0.8 12.8 37
I8 8 0 1.29868e-03
R10 8 9 1.648 0.8 13.184 37
I9 9 0 1.34816e-03
R11 9 10 1.648 0.8 13.184 37
I10 10 0 1.23684e-03
R12 10 3001 2.5 0.8 20 37
*seg: 2
R13 3001 11 2.5 0.8 20 37
R14 15 25 6.16 0.8 49.28 37
I11 11 0 1.32342e-03
R15 11 12 1.696 0.8 13.568 37
I12 12 0 1.31105e-03
R16 12 13 1.728 0.8 13.824 37
I13 13 0 1.29868e-03
R17 13 14 1.616 0.8 12.928 37
I14 14 0 1.32342e-03
R18 14 15 1.664 0.8 13.312 37
I15 15 0 1.24921e-03
R19 15 16 1.68 0.8 13.44 37
I16 16 0 1.26158e-03
R20 16 17 1.696 0.8 13.568 37
I17 17 0 1.28631e-03
R21 17 18 1.68 0.8 13.44 37
I18 18 0 1.28631e-03
R22 18 19 1.632 0.8 13.056 37
I19 19 0 1.24921e-03
R23 19 20 1.712 0.8 13.696 37
I20 20 0 1.23684e-03
R24 20 3001 2.5 0.8 20 37
*seg: 3
R25 3001 21 2.5 0.8 20 37
R26 25 35 6.16 0.8 49.28 37
I21 21 0 1.28631e-03
R27 21 22 1.648 0.8 13.184 37
I22 22 0 1.24921e-03
R28 22 23 1.696 0.8 13.568 37
I23 23 0 1.33579e-03
R29 23 24 1.728 0.8 13.824 37
I24 24 0 1.29868e-03
R30 24 25 1.648 0.8 13.184 37
I25 25 0 1.32342e-03
R31 25 26 1.696 0.8 13.568 37
I26 26 0 1.29868e-03
R32 26 27 1.648 0.8 13.184 37
I27 27 0 1.26158e-03
R33 27 28 1.664 0.8 13.312 37
I28 28 0 1.27395e-03
R34 28 29 1.6 0.8 12.8 37
I29 29 0 1.28631e-03
R35 29 30 1.648 0.8 13.184 37
I30 30 0 1.23684e-03
R36 30 3001 2.5 0.8 20 37
*seg: 4
R37 3001 31 2.5 0.8 20 37
R38 35 45 6.16 0.8 49.28 37
I31 31 0 1.26158e-03
R39 31 32 1.728 0.8 13.824 37
I32 32 0 1.26158e-03
R40 32 33 1.712 0.8 13.696 37
I33 33 0 1.32342e-03
R41 33 34 1.68 0.8 13.44 37
I34 34 0 1.34816e-03
R42 34 35 1.648 0.8 13.184 37
I35 35 0 1.24921e-03
R43 35 36 1.664 0.8 13.312 37
I36 36 0 1.23684e-03
R44 36 37 1.744 0.8 13.952 37
I37 37 0 1.33579e-03
R45 37 38 1.712 0.8 13.696 37
I38 38 0 1.34816e-03
R46 38 39 1.696 0.8 13.568 37
I39 39 0 1.31105e-03
R47 39 40 1.6 0.8 12.8 37
I40 40 0 1.23684e-03
R48 40 3001 2.5 0.8 20 37
*seg: 5
R49 3001 41 2.5 0.8 20 37
R50 45 55 6.16 0.8 49.28 37
I41 41 0 1.33579e-03
R51 41 42 1.696 0.8 13.568 37
I42 42 0 1.28631e-03
R52 42 43 1.632 0.8 13.056 37
I43 43 0 1.31105e-03
R53 43 44 1.68 0.8 13.44 37
I44 44 0 1.24921e-03
R54 44 45 1.664 0.8 13.312 37
I45 45 0 1.27395e-03
R55 45 46 1.632 0.8 13.056 37
I46 46 0 1.27395e-03
R56 46 47 1.696 0.8 13.568 37
I47 47 0 1.23684e-03
R57 47 48 1.744 0.8 13.952 37
I48 48 0 1.24921e-03
R58 48 49 1.616 0.8 12.928 37
I49 49 0 1.31105e-03
R59 49 50 1.616 0.8 12.928 37
I50 50 0 1.23684e-03
R60 50 3001 2.5 0.8 20 37
*seg: 6
R61 3001 51 2.5 0.8 20 37
R62 55 65 6.16 0.8 49.28 37
I51 51 0 1.23684e-03
R63 51 52 1.68 0.8 13.44 37
I52 52 0 1.34816e-03
R64 52 53 1.664 0.8 13.312 37
I53 53 0 1.29868e-03
R65 53 54 1.648 0.8 13.184 37
I54 54 0 1.28631e-03
R66 54 55 1.744 0.8 13.952 37
I55 55 0 1.33579e-03
R67 55 56 1.616 0.8 12.928 37
I56 56 0 1.26158e-03
R68 56 57 1.616 0.8 12.928 37
I57 57 0 1.28631e-03
R69 57 58 1.712 0.8 13.696 37
I58 58 0 1.26158e-03
R70 58 59 1.68 0.8 13.44 37
I59 59 0 1.31105e-03
R71 59 60 1.648 0.8 13.184 37
I60 60 0 1.23684e-03
R72 60 3001 2.5 0.8 20 37
*seg: 7
R73 3001 61 2.5 0.8 20 37
R74 65 75 6.16 0.8 49.28 37
I61 61 0 1.31105e-03
R75 61 62 1.664 0.8 13.312 37
I62 62 0 1.24921e-03
R76 62 63 1.728 0.8 13.824 37
I63 63 0 1.27395e-03
R77 63 64 1.664 0.8 13.312 37
I64 64 0 1.27395e-03
R78 64 65 1.6 0.8 12.8 37
I65 65 0 1.33579e-03
R79 65 66 1.6 0.8 12.8 37
I66 66 0 1.23684e-03
R80 66 67 1.744 0.8 13.952 37
I67 67 0 1.31105e-03
R81 67 68 1.632 0.8 13.056 37
I68 68 0 1.31105e-03
R82 68 69 1.712 0.8 13.696 37
I69 69 0 1.27395e-03
R83 69 70 1.6 0.8 12.8 37
I70 70 0 1.23684e-03
R84 70 3001 2.5 0.8 20 37
*seg: 8
R85 3001 71 2.5 0.8 20 37
R86 75 85 6.16 0.8 49.28 37
I71 71 0 1.24921e-03
R87 71 72 1.744 0.8 13.952 37
I72 72 0 1.31105e-03
R88 72 73 1.68 0.8 13.44 37
I73 73 0 1.29868e-03
R89 73 74 1.632 0.8 13.056 37
I74 74 0 1.23684e-03
R90 74 75 1.6 0.8 12.8 37
I75 75 0 1.26158e-03
R91 75 76 1.68 0.8 13.44 37
I76 76 0 1.23684e-03
R92 76 77 1.6 0.8 12.8 37
I77 77 0 1.34816e-03
R93 77 78 1.664 0.8 13.312 37
I78 78 0 1.29868e-03
R94 78 79 1.68 0.8 13.44 37
I79 79 0 1.29868e-03
R95 79 80 1.68 0.8 13.44 37
I80 80 0 1.23684e-03
R96 80 3001 2.5 0.8 20 37
*seg: 9
R97 3001 81 2.5 0.8 20 37
R98 85 95 6.16 0.8 49.28 37
I81 81 0 1.28631e-03
R99 81 82 1.616 0.8 12.928 37
I82 82 0 1.31105e-03
R100 82 83 1.712 0.8 13.696 37
I83 83 0 1.27395e-03
R101 83 84 1.712 0.8 13.696 37
I84 84 0 1.34816e-03
R102 84 85 1.712 0.8 13.696 37
I85 85 0 1.27395e-03
R103 85 86 1.744 0.8 13.952 37
I86 86 0 1.29868e-03
R104 86 87 1.696 0.8 13.568 37
I87 87 0 1.27395e-03
R105 87 88 1.616 0.8 12.928 37
I88 88 0 1.27395e-03
R106 88 89 1.712 0.8 13.696 37
I89 89 0 1.34816e-03
R107 89 90 1.712 0.8 13.696 37
I90 90 0 1.23684e-03
R108 90 3001 2.5 0.8 20 37
*seg: 10
R109 3001 91 2.5 0.8 20 37
R110 95 105 6.16 0.8 49.28 37
I91 91 0 1.27395e-03
R111 91 92 1.728 0.8 13.824 37
I92 92 0 1.31105e-03
R112 92 93 1.616 0.8 12.928 37
I93 93 0 1.31105e-03
R113 93 94 1.696 0.8 13.568 37
I94 94 0 1.31105e-03
R114 94 95 1.728 0.8 13.824 37
I95 95 0 1.33579e-03
R115 95 96 1.696 0.8 13.568 37
I96 96 0 1.27395e-03
R116 96 97 1.712 0.8 13.696 37
I97 97 0 1.24921e-03
R117 97 98 1.712 0.8 13.696 37
I98 98 0 1.26158e-03
R118 98 99 1.728 0.8 13.824 37
I99 99 0 1.24921e-03
R119 99 100 1.648 0.8 13.184 37
I100 100 0 1.23684e-03
R120 100 3001 2.5 0.8 20 37
*seg: 11
R121 3001 101 2.5 0.8 20 37
R122 105 115 6.16 0.8 49.28 37
I101 101 0 1.26158e-03
R123 101 102 1.664 0.8 13.312 37
I102 102 0 1.33579e-03
R124 102 103 1.68 0.8 13.44 37
I103 103 0 1.27395e-03
R125 103 104 1.744 0.8 13.952 37
I104 104 0 1.24921e-03
R126 104 105 1.696 0.8 13.568 37
I105 105 0 1.29868e-03
R127 105 106 1.728 0.8 13.824 37
I106 106 0 1.27395e-03
R128 106 107 1.68 0.8 13.44 37
I107 107 0 1.28631e-03
R129 107 108 1.744 0.8 13.952 37
I108 108 0 1.27395e-03
R130 108 109 1.616 0.8 12.928 37
I109 109 0 1.24921e-03
R131 109 110 1.696 0.8 13.568 37
I110 110 0 1.23684e-03
R132 110 3001 2.5 0.8 20 37
*seg: 12
R133 3001 111 2.5 0.8 20 37
R134 115 125 6.16 0.8 49.28 37
I111 111 0 1.29868e-03
R135 111 112 1.696 0.8 13.568 37
I112 112 0 1.27395e-03
R136 112 113 1.6 0.8 12.8 37
I113 113 0 1.23684e-03
R137 113 114 1.744 0.8 13.952 37
I114 114 0 1.34816e-03
R138 114 115 1.6 0.8 12.8 37
I115 115 0 1.32342e-03
R139 115 116 1.728 0.8 13.824 37
I116 116 0 1.29868e-03
R140 116 117 1.712 0.8 13.696 37
I117 117 0 1.26158e-03
R141 117 118 1.664 0.8 13.312 37
I118 118 0 1.24921e-03
R142 118 119 1.632 0.8 13.056 37
I119 119 0 1.26158e-03
R143 119 120 1.664 0.8 13.312 37
I120 120 0 1.23684e-03
R144 120 3001 2.5 0.8 20 37
*seg: 13
R145 3001 121 2.5 0.8 20 37
R146 125 135 6.16 0.8 49.28 37
I121 121 0 1.28631e-03
R147 121 122 1.68 0.8 13.44 37
I122 122 0 1.32342e-03
R148 122 123 1.696 0.8 13.568 37
I123 123 0 1.33579e-03
R149 123 124 1.68 0.8 13.44 37
I124 124 0 1.31105e-03
R150 124 125 1.696 0.8 13.568 37
I125 125 0 1.26158e-03
R151 125 126 1.616 0.8 12.928 37
I126 126 0 1.33579e-03
R152 126 127 1.648 0.8 13.184 37
I127 127 0 1.24921e-03
R153 127 128 1.648 0.8 13.184 37
I128 128 0 1.26158e-03
R154 128 129 1.696 0.8 13.568 37
I129 129 0 1.24921e-03
R155 129 130 1.664 0.8 13.312 37
I130 130 0 1.23684e-03
R156 130 3001 2.5 0.8 20 37
*seg: 14
R157 3001 131 2.5 0.8 20 37
R158 135 145 6.16 0.8 49.28 37
I131 131 0 1.33579e-03
R159 131 132 1.664 0.8 13.312 37
I132 132 0 1.34816e-03
R160 132 133 1.664 0.8 13.312 37
I133 133 0 1.24921e-03
R161 133 134 1.744 0.8 13.952 37
I134 134 0 1.29868e-03
R162 134 135 1.68 0.8 13.44 37
I135 135 0 1.28631e-03
R163 135 136 1.6 0.8 12.8 37
I136 136 0 1.26158e-03
R164 136 137 1.68 0.8 13.44 37
I137 137 0 1.34816e-03
R165 137 138 1.632 0.8 13.056 37
I138 138 0 1.23684e-03
R166 138 139 1.6 0.8 12.8 37
I139 139 0 1.29868e-03
R167 139 140 1.728 0.8 13.824 37
I140 140 0 1.23684e-03
R168 140 3001 2.5 0.8 20 37
*seg: 15
R169 3001 141 2.5 0.8 20 37
R170 145 155 6.16 0.8 49.28 37
I141 141 0 1.24921e-03
R171 141 142 1.744 0.8 13.952 37
I142 142 0 1.24921e-03
R172 142 143 1.632 0.8 13.056 37
I143 143 0 1.23684e-03
R173 143 144 1.696 0.8 13.568 37
I144 144 0 1.24921e-03
R174 144 145 1.6 0.8 12.8 37
I145 145 0 1.24921e-03
R175 145 146 1.712 0.8 13.696 37
I146 146 0 1.34816e-03
R176 146 147 1.6 0.8 12.8 37
I147 147 0 1.31105e-03
R177 147 148 1.648 0.8 13.184 37
I148 148 0 1.33579e-03
R178 148 149 1.648 0.8 13.184 37
I149 149 0 1.24921e-03
R179 149 150 1.616 0.8 12.928 37
I150 150 0 1.23684e-03
R180 150 3001 2.5 0.8 20 37
*seg: 16
R181 3001 151 2.5 0.8 20 37
R182 155 165 6.16 0.8 49.28 37
I151 151 0 1.34816e-03
R183 151 152 1.696 0.8 13.568 37
I152 152 0 1.28631e-03
R184 152 153 1.744 0.8 13.952 37
I153 153 0 1.26158e-03
R185 153 154 1.712 0.8 13.696 37
I154 154 0 1.33579e-03
R186 154 155 1.632 0.8 13.056 37
I155 155 0 1.29868e-03
R187 155 156 1.6 0.8 12.8 37
I156 156 0 1.34816e-03
R188 156 157 1.68 0.8 13.44 37
I157 157 0 1.34816e-03
R189 157 158 1.616 0.8 12.928 37
I158 158 0 1.33579e-03
R190 158 159 1.632 0.8 13.056 37
I159 159 0 1.27395e-03
R191 159 160 1.68 0.8 13.44 37
I160 160 0 1.23684e-03
R192 160 3001 2.5 0.8 20 37
*seg: 17
R193 3001 161 2.5 0.8 20 37
R194 165 175 6.16 0.8 49.28 37
I161 161 0 1.34816e-03
R195 161 162 1.632 0.8 13.056 37
I162 162 0 1.28631e-03
R196 162 163 1.632 0.8 13.056 37
I163 163 0 1.34816e-03
R197 163 164 1.648 0.8 13.184 37
I164 164 0 1.32342e-03
R198 164 165 1.632 0.8 13.056 37
I165 165 0 1.24921e-03
R199 165 166 1.68 0.8 13.44 37
I166 166 0 1.28631e-03
R200 166 167 1.744 0.8 13.952 37
I167 167 0 1.23684e-03
R201 167 168 1.744 0.8 13.952 37
I168 168 0 1.34816e-03
R202 168 169 1.664 0.8 13.312 37
I169 169 0 1.26158e-03
R203 169 170 1.664 0.8 13.312 37
I170 170 0 1.23684e-03
R204 170 3001 2.5 0.8 20 37
*seg: 18
R205 3001 171 2.5 0.8 20 37
R206 175 185 6.16 0.8 49.28 37
I171 171 0 1.23684e-03
R207 171 172 1.744 0.8 13.952 37
I172 172 0 1.29868e-03
R208 172 173 1.632 0.8 13.056 37
I173 173 0 1.29868e-03
R209 173 174 1.696 0.8 13.568 37
I174 174 0 1.27395e-03
R210 174 175 1.744 0.8 13.952 37
I175 175 0 1.33579e-03
R211 175 176 1.712 0.8 13.696 37
I176 176 0 1.34816e-03
R212 176 177 1.712 0.8 13.696 37
I177 177 0 1.28631e-03
R213 177 178 1.712 0.8 13.696 37
I178 178 0 1.23684e-03
R214 178 179 1.632 0.8 13.056 37
I179 179 0 1.34816e-03
R215 179 180 1.744 0.8 13.952 37
I180 180 0 1.23684e-03
R216 180 3001 2.5 0.8 20 37
*seg: 19
R217 3001 181 2.5 0.8 20 37
R218 185 195 6.16 0.8 49.28 37
I181 181 0 1.34816e-03
R219 181 182 1.648 0.8 13.184 37
I182 182 0 1.31105e-03
R220 182 183 1.632 0.8 13.056 37
I183 183 0 1.34816e-03
R221 183 184 1.648 0.8 13.184 37
I184 184 0 1.34816e-03
R222 184 185 1.696 0.8 13.568 37
I185 185 0 1.32342e-03
R223 185 186 1.616 0.8 12.928 37
I186 186 0 1.24921e-03
R224 186 187 1.6 0.8 12.8 37
I187 187 0 1.27395e-03
R225 187 188 1.68 0.8 13.44 37
I188 188 0 1.34816e-03
R226 188 189 1.6 0.8 12.8 37
I189 189 0 1.32342e-03
R227 189 190 1.664 0.8 13.312 37
I190 190 0 1.23684e-03
R228 190 3001 2.5 0.8 20 37
*seg: 20
R229 3001 191 2.5 0.8 20 37
R230 195 205 6.16 0.8 49.28 37
I191 191 0 1.28631e-03
R231 191 192 1.648 0.8 13.184 37
I192 192 0 1.26158e-03
R232 192 193 1.744 0.8 13.952 37
I193 193 0 1.31105e-03
R233 193 194 1.648 0.8 13.184 37
I194 194 0 1.32342e-03
R234 194 195 1.68 0.8 13.44 37
I195 195 0 1.27395e-03
R235 195 196 1.664 0.8 13.312 37
I196 196 0 1.26158e-03
R236 196 197 1.632 0.8 13.056 37
I197 197 0 1.29868e-03
R237 197 198 1.632 0.8 13.056 37
I198 198 0 1.28631e-03
R238 198 199 1.6 0.8 12.8 37
I199 199 0 1.29868e-03
R239 199 200 1.696 0.8 13.568 37
I200 200 0 1.23684e-03
R240 200 3001 2.5 0.8 20 37
*seg: 21
R241 3001 201 2.5 0.8 20 37
R242 205 215 6.16 0.8 49.28 37
I201 201 0 1.33579e-03
R243 201 202 1.68 0.8 13.44 37
I202 202 0 1.33579e-03
R244 202 203 1.6 0.8 12.8 37
I203 203 0 1.31105e-03
R245 203 204 1.68 0.8 13.44 37
I204 204 0 1.31105e-03
R246 204 205 1.648 0.8 13.184 37
I205 205 0 1.24921e-03
R247 205 206 1.616 0.8 12.928 37
I206 206 0 1.33579e-03
R248 206 207 1.744 0.8 13.952 37
I207 207 0 1.32342e-03
R249 207 208 1.616 0.8 12.928 37
I208 208 0 1.23684e-03
R250 208 209 1.664 0.8 13.312 37
I209 209 0 1.23684e-03
R251 209 210 1.648 0.8 13.184 37
I210 210 0 1.23684e-03
R252 210 3001 2.5 0.8 20 37
*seg: 22
R253 3001 211 2.5 0.8 20 37
R254 215 225 6.16 0.8 49.28 37
I211 211 0 1.33579e-03
R255 211 212 1.728 0.8 13.824 37
I212 212 0 1.28631e-03
R256 212 213 1.68 0.8 13.44 37
I213 213 0 1.29868e-03
R257 213 214 1.632 0.8 13.056 37
I214 214 0 1.33579e-03
R258 214 215 1.744 0.8 13.952 37
I215 215 0 1.29868e-03
R259 215 216 1.632 0.8 13.056 37
I216 216 0 1.33579e-03
R260 216 217 1.664 0.8 13.312 37
I217 217 0 1.33579e-03
R261 217 218 1.632 0.8 13.056 37
I218 218 0 1.28631e-03
R262 218 219 1.616 0.8 12.928 37
I219 219 0 1.28631e-03
R263 219 220 1.744 0.8 13.952 37
I220 220 0 1.23684e-03
R264 220 3001 2.5 0.8 20 37
*seg: 23
R265 3001 221 2.5 0.8 20 37
R266 225 235 6.16 0.8 49.28 37
I221 221 0 1.24921e-03
R267 221 222 1.632 0.8 13.056 37
I222 222 0 1.27395e-03
R268 222 223 1.728 0.8 13.824 37
I223 223 0 1.33579e-03
R269 223 224 1.648 0.8 13.184 37
I224 224 0 1.32342e-03
R270 224 225 1.632 0.8 13.056 37
I225 225 0 1.29868e-03
R271 225 226 1.744 0.8 13.952 37
I226 226 0 1.29868e-03
R272 226 227 1.68 0.8 13.44 37
I227 227 0 1.29868e-03
R273 227 228 1.728 0.8 13.824 37
I228 228 0 1.27395e-03
R274 228 229 1.712 0.8 13.696 37
I229 229 0 1.33579e-03
R275 229 230 1.632 0.8 13.056 37
I230 230 0 1.23684e-03
R276 230 3001 2.5 0.8 20 37
*seg: 24
R277 3001 231 2.5 0.8 20 37
R278 235 245 6.16 0.8 49.28 37
I231 231 0 1.33579e-03
R279 231 232 1.68 0.8 13.44 37
I232 232 0 1.28631e-03
R280 232 233 1.6 0.8 12.8 37
I233 233 0 1.24921e-03
R281 233 234 1.68 0.8 13.44 37
I234 234 0 1.24921e-03
R282 234 235 1.616 0.8 12.928 37
I235 235 0 1.33579e-03
R283 235 236 1.664 0.8 13.312 37
I236 236 0 1.32342e-03
R284 236 237 1.68 0.8 13.44 37
I237 237 0 1.34816e-03
R285 237 238 1.68 0.8 13.44 37
I238 238 0 1.23684e-03
R286 238 239 1.712 0.8 13.696 37
I239 239 0 1.34816e-03
R287 239 240 1.712 0.8 13.696 37
I240 240 0 1.23684e-03
R288 240 3001 2.5 0.8 20 37
*seg: 25
R289 3001 241 2.5 0.8 20 37
R290 245 255 6.16 0.8 49.28 37
I241 241 0 1.34816e-03
R291 241 242 1.744 0.8 13.952 37
I242 242 0 1.24921e-03
R292 242 243 1.712 0.8 13.696 37
I243 243 0 1.32342e-03
R293 243 244 1.744 0.8 13.952 37
I244 244 0 1.31105e-03
R294 244 245 1.712 0.8 13.696 37
I245 245 0 1.29868e-03
R295 245 246 1.616 0.8 12.928 37
I246 246 0 1.32342e-03
R296 246 247 1.744 0.8 13.952 37
I247 247 0 1.29868e-03
R297 247 248 1.68 0.8 13.44 37
I248 248 0 1.31105e-03
R298 248 249 1.648 0.8 13.184 37
I249 249 0 1.31105e-03
R299 249 250 1.6 0.8 12.8 37
I250 250 0 1.23684e-03
R300 250 3001 2.5 0.8 20 37
*seg: 26
R301 3001 251 2.5 0.8 20 37
R302 255 265 6.16 0.8 49.28 37
I251 251 0 1.33579e-03
R303 251 252 1.6 0.8 12.8 37
I252 252 0 1.34816e-03
R304 252 253 1.728 0.8 13.824 37
I253 253 0 1.26158e-03
R305 253 254 1.744 0.8 13.952 37
I254 254 0 1.34816e-03
R306 254 255 1.696 0.8 13.568 37
I255 255 0 1.33579e-03
R307 255 256 1.616 0.8 12.928 37
I256 256 0 1.24921e-03
R308 256 257 1.696 0.8 13.568 37
I257 257 0 1.33579e-03
R309 257 258 1.712 0.8 13.696 37
I258 258 0 1.32342e-03
R310 258 259 1.6 0.8 12.8 37
I259 259 0 1.34816e-03
R311 259 260 1.696 0.8 13.568 37
I260 260 0 1.23684e-03
R312 260 3001 2.5 0.8 20 37
*seg: 27
R313 3001 261 2.5 0.8 20 37
R314 265 275 6.16 0.8 49.28 37
I261 261 0 1.31105e-03
R315 261 262 1.68 0.8 13.44 37
I262 262 0 1.24921e-03
R316 262 263 1.696 0.8 13.568 37
I263 263 0 1.27395e-03
R317 263 264 1.744 0.8 13.952 37
I264 264 0 1.24921e-03
R318 264 265 1.632 0.8 13.056 37
I265 265 0 1.31105e-03
R319 265 266 1.712 0.8 13.696 37
I266 266 0 1.31105e-03
R320 266 267 1.632 0.8 13.056 37
I267 267 0 1.23684e-03
R321 267 268 1.664 0.8 13.312 37
I268 268 0 1.27395e-03
R322 268 269 1.744 0.8 13.952 37
I269 269 0 1.34816e-03
R323 269 270 1.632 0.8 13.056 37
I270 270 0 1.23684e-03
R324 270 3001 2.5 0.8 20 37
*seg: 28
R325 3001 271 2.5 0.8 20 37
R326 275 285 6.16 0.8 49.28 37
I271 271 0 1.26158e-03
R327 271 272 1.712 0.8 13.696 37
I272 272 0 1.33579e-03
R328 272 273 1.632 0.8 13.056 37
I273 273 0 1.26158e-03
R329 273 274 1.632 0.8 13.056 37
I274 274 0 1.29868e-03
R330 274 275 1.744 0.8 13.952 37
I275 275 0 1.31105e-03
R331 275 276 1.664 0.8 13.312 37
I276 276 0 1.23684e-03
R332 276 277 1.68 0.8 13.44 37
I277 277 0 1.34816e-03
R333 277 278 1.68 0.8 13.44 37
I278 278 0 1.27395e-03
R334 278 279 1.616 0.8 12.928 37
I279 279 0 1.28631e-03
R335 279 280 1.744 0.8 13.952 37
I280 280 0 1.23684e-03
R336 280 3001 2.5 0.8 20 37
*seg: 29
R337 3001 281 2.5 0.8 20 37
R338 285 295 6.16 0.8 49.28 37
I281 281 0 1.23684e-03
R339 281 282 1.616 0.8 12.928 37
I282 282 0 1.28631e-03
R340 282 283 1.68 0.8 13.44 37
I283 283 0 1.28631e-03
R341 283 284 1.6 0.8 12.8 37
I284 284 0 1.34816e-03
R342 284 285 1.616 0.8 12.928 37
I285 285 0 1.27395e-03
R343 285 286 1.616 0.8 12.928 37
I286 286 0 1.34816e-03
R344 286 287 1.6 0.8 12.8 37
I287 287 0 1.28631e-03
R345 287 288 1.712 0.8 13.696 37
I288 288 0 1.27395e-03
R346 288 289 1.712 0.8 13.696 37
I289 289 0 1.33579e-03
R347 289 290 1.6 0.8 12.8 37
I290 290 0 1.23684e-03
R348 290 3001 2.5 0.8 20 37
*seg: 30
R349 3001 291 2.5 0.8 20 37
R350 295 305 6.16 0.8 49.28 37
I291 291 0 1.29868e-03
R351 291 292 1.6 0.8 12.8 37
I292 292 0 1.34816e-03
R352 292 293 1.696 0.8 13.568 37
I293 293 0 1.31105e-03
R353 293 294 1.712 0.8 13.696 37
I294 294 0 1.26158e-03
R354 294 295 1.648 0.8 13.184 37
I295 295 0 1.32342e-03
R355 295 296 1.632 0.8 13.056 37
I296 296 0 1.31105e-03
R356 296 297 1.632 0.8 13.056 37
I297 297 0 1.34816e-03
R357 297 298 1.664 0.8 13.312 37
I298 298 0 1.26158e-03
R358 298 299 1.664 0.8 13.312 37
I299 299 0 1.29868e-03
R359 299 300 1.728 0.8 13.824 37
I300 300 0 1.23684e-03
R360 300 3001 2.5 0.8 20 37
*seg: 31
R361 3001 301 2.5 0.8 20 37
R362 305 315 6.16 0.8 49.28 37
I301 301 0 1.28631e-03
R363 301 302 1.712 0.8 13.696 37
I302 302 0 1.31105e-03
R364 302 303 1.632 0.8 13.056 37
I303 303 0 1.28631e-03
R365 303 304 1.696 0.8 13.568 37
I304 304 0 1.26158e-03
R366 304 305 1.68 0.8 13.44 37
I305 305 0 1.33579e-03
R367 305 306 1.632 0.8 13.056 37
I306 306 0 1.23684e-03
R368 306 307 1.616 0.8 12.928 37
I307 307 0 1.34816e-03
R369 307 308 1.712 0.8 13.696 37
I308 308 0 1.28631e-03
R370 308 309 1.664 0.8 13.312 37
I309 309 0 1.29868e-03
R371 309 310 1.712 0.8 13.696 37
I310 310 0 1.23684e-03
R372 310 3001 2.5 0.8 20 37
*seg: 32
R373 3001 311 2.5 0.8 20 37
R374 315 325 6.16 0.8 49.28 37
I311 311 0 1.29868e-03
R375 311 312 1.6 0.8 12.8 37
I312 312 0 1.33579e-03
R376 312 313 1.68 0.8 13.44 37
I313 313 0 1.23684e-03
R377 313 314 1.616 0.8 12.928 37
I314 314 0 1.34816e-03
R378 314 315 1.712 0.8 13.696 37
I315 315 0 1.32342e-03
R379 315 316 1.6 0.8 12.8 37
I316 316 0 1.32342e-03
R380 316 317 1.712 0.8 13.696 37
I317 317 0 1.31105e-03
R381 317 318 1.648 0.8 13.184 37
I318 318 0 1.27395e-03
R382 318 319 1.712 0.8 13.696 37
I319 319 0 1.32342e-03
R383 319 320 1.68 0.8 13.44 37
I320 320 0 1.23684e-03
R384 320 3001 2.5 0.8 20 37
*seg: 33
R385 3001 321 2.5 0.8 20 37
R386 325 335 6.16 0.8 49.28 37
I321 321 0 1.24921e-03
R387 321 322 1.68 0.8 13.44 37
I322 322 0 1.31105e-03
R388 322 323 1.712 0.8 13.696 37
I323 323 0 1.24921e-03
R389 323 324 1.616 0.8 12.928 37
I324 324 0 1.23684e-03
R390 324 325 1.696 0.8 13.568 37
I325 325 0 1.34816e-03
R391 325 326 1.68 0.8 13.44 37
I326 326 0 1.32342e-03
R392 326 327 1.728 0.8 13.824 37
I327 327 0 1.27395e-03
R393 327 328 1.616 0.8 12.928 37
I328 328 0 1.31105e-03
R394 328 329 1.664 0.8 13.312 37
I329 329 0 1.33579e-03
R395 329 330 1.632 0.8 13.056 37
I330 330 0 1.23684e-03
R396 330 3001 2.5 0.8 20 37
*seg: 34
R397 3001 331 2.5 0.8 20 37
R398 335 345 6.16 0.8 49.28 37
I331 331 0 1.32342e-03
R399 331 332 1.664 0.8 13.312 37
I332 332 0 1.31105e-03
R400 332 333 1.68 0.8 13.44 37
I333 333 0 1.29868e-03
R401 333 334 1.632 0.8 13.056 37
I334 334 0 1.31105e-03
R402 334 335 1.68 0.8 13.44 37
I335 335 0 1.29868e-03
R403 335 336 1.632 0.8 13.056 37
I336 336 0 1.33579e-03
R404 336 337 1.68 0.8 13.44 37
I337 337 0 1.32342e-03
R405 337 338 1.632 0.8 13.056 37
I338 338 0 1.23684e-03
R406 338 339 1.712 0.8 13.696 37
I339 339 0 1.26158e-03
R407 339 340 1.632 0.8 13.056 37
I340 340 0 1.23684e-03
R408 340 3001 2.5 0.8 20 37
*seg: 35
R409 3001 341 2.5 0.8 20 37
R410 345 355 6.16 0.8 49.28 37
I341 341 0 1.27395e-03
R411 341 342 1.728 0.8 13.824 37
I342 342 0 1.29868e-03
R412 342 343 1.6 0.8 12.8 37
I343 343 0 1.33579e-03
R413 343 344 1.696 0.8 13.568 37
I344 344 0 1.26158e-03
R414 344 345 1.632 0.8 13.056 37
I345 345 0 1.28631e-03
R415 345 346 1.712 0.8 13.696 37
I346 346 0 1.29868e-03
R416 346 347 1.744 0.8 13.952 37
I347 347 0 1.28631e-03
R417 347 348 1.648 0.8 13.184 37
I348 348 0 1.34816e-03
R418 348 349 1.68 0.8 13.44 37
I349 349 0 1.29868e-03
R419 349 350 1.712 0.8 13.696 37
I350 350 0 1.23684e-03
R420 350 3001 2.5 0.8 20 37
*seg: 36
R421 3001 351 2.5 0.8 20 37
R422 355 365 6.16 0.8 49.28 37
I351 351 0 1.24921e-03
R423 351 352 1.648 0.8 13.184 37
I352 352 0 1.32342e-03
R424 352 353 1.616 0.8 12.928 37
I353 353 0 1.32342e-03
R425 353 354 1.712 0.8 13.696 37
I354 354 0 1.26158e-03
R426 354 355 1.664 0.8 13.312 37
I355 355 0 1.24921e-03
R427 355 356 1.712 0.8 13.696 37
I356 356 0 1.27395e-03
R428 356 357 1.712 0.8 13.696 37
I357 357 0 1.32342e-03
R429 357 358 1.648 0.8 13.184 37
I358 358 0 1.24921e-03
R430 358 359 1.728 0.8 13.824 37
I359 359 0 1.34816e-03
R431 359 360 1.728 0.8 13.824 37
I360 360 0 1.23684e-03
R432 360 3001 2.5 0.8 20 37
*seg: 37
R433 3001 361 2.5 0.8 20 37
R434 365 375 6.16 0.8 49.28 37
I361 361 0 1.31105e-03
R435 361 362 1.632 0.8 13.056 37
I362 362 0 1.23684e-03
R436 362 363 1.632 0.8 13.056 37
I363 363 0 1.33579e-03
R437 363 364 1.68 0.8 13.44 37
I364 364 0 1.26158e-03
R438 364 365 1.696 0.8 13.568 37
I365 365 0 1.34816e-03
R439 365 366 1.664 0.8 13.312 37
I366 366 0 1.31105e-03
R440 366 367 1.744 0.8 13.952 37
I367 367 0 1.27395e-03
R441 367 368 1.712 0.8 13.696 37
I368 368 0 1.23684e-03
R442 368 369 1.728 0.8 13.824 37
I369 369 0 1.33579e-03
R443 369 370 1.712 0.8 13.696 37
I370 370 0 1.23684e-03
R444 370 3001 2.5 0.8 20 37
*seg: 38
R445 3001 371 2.5 0.8 20 37
R446 375 385 6.16 0.8 49.28 37
I371 371 0 1.29868e-03
R447 371 372 1.632 0.8 13.056 37
I372 372 0 1.23684e-03
R448 372 373 1.648 0.8 13.184 37
I373 373 0 1.27395e-03
R449 373 374 1.616 0.8 12.928 37
I374 374 0 1.24921e-03
R450 374 375 1.632 0.8 13.056 37
I375 375 0 1.28631e-03
R451 375 376 1.68 0.8 13.44 37
I376 376 0 1.31105e-03
R452 376 377 1.728 0.8 13.824 37
I377 377 0 1.24921e-03
R453 377 378 1.632 0.8 13.056 37
I378 378 0 1.24921e-03
R454 378 379 1.744 0.8 13.952 37
I379 379 0 1.34816e-03
R455 379 380 1.632 0.8 13.056 37
I380 380 0 1.23684e-03
R456 380 3001 2.5 0.8 20 37
*seg: 39
R457 3001 381 2.5 0.8 20 37
R458 385 395 6.16 0.8 49.28 37
I381 381 0 1.34816e-03
R459 381 382 1.728 0.8 13.824 37
I382 382 0 1.27395e-03
R460 382 383 1.712 0.8 13.696 37
I383 383 0 1.24921e-03
R461 383 384 1.664 0.8 13.312 37
I384 384 0 1.24921e-03
R462 384 385 1.664 0.8 13.312 37
I385 385 0 1.32342e-03
R463 385 386 1.68 0.8 13.44 37
I386 386 0 1.27395e-03
R464 386 387 1.616 0.8 12.928 37
I387 387 0 1.24921e-03
R465 387 388 1.664 0.8 13.312 37
I388 388 0 1.28631e-03
R466 388 389 1.648 0.8 13.184 37
I389 389 0 1.29868e-03
R467 389 390 1.744 0.8 13.952 37
I390 390 0 1.23684e-03
R468 390 3001 2.5 0.8 20 37
*seg: 40
R469 3001 391 2.5 0.8 20 37
R470 395 405 6.16 0.8 49.28 37
I391 391 0 1.26158e-03
R471 391 392 1.616 0.8 12.928 37
I392 392 0 1.34816e-03
R472 392 393 1.616 0.8 12.928 37
I393 393 0 1.27395e-03
R473 393 394 1.664 0.8 13.312 37
I394 394 0 1.33579e-03
R474 394 395 1.616 0.8 12.928 37
I395 395 0 1.31105e-03
R475 395 396 1.648 0.8 13.184 37
I396 396 0 1.28631e-03
R476 396 397 1.6 0.8 12.8 37
I397 397 0 1.29868e-03
R477 397 398 1.696 0.8 13.568 37
I398 398 0 1.33579e-03
R478 398 399 1.6 0.8 12.8 37
I399 399 0 1.26158e-03
R479 399 400 1.648 0.8 13.184 37
I400 400 0 1.23684e-03
R480 400 3001 2.5 0.8 20 37
*seg: 41
R481 3001 401 2.5 0.8 20 37
R482 405 415 6.16 0.8 49.28 37
I401 401 0 1.28631e-03
R483 401 402 1.712 0.8 13.696 37
I402 402 0 1.27395e-03
R484 402 403 1.648 0.8 13.184 37
I403 403 0 1.27395e-03
R485 403 404 1.696 0.8 13.568 37
I404 404 0 1.28631e-03
R486 404 405 1.616 0.8 12.928 37
I405 405 0 1.24921e-03
R487 405 406 1.648 0.8 13.184 37
I406 406 0 1.28631e-03
R488 406 407 1.728 0.8 13.824 37
I407 407 0 1.32342e-03
R489 407 408 1.728 0.8 13.824 37
I408 408 0 1.33579e-03
R490 408 409 1.616 0.8 12.928 37
I409 409 0 1.24921e-03
R491 409 410 1.744 0.8 13.952 37
I410 410 0 1.23684e-03
R492 410 3001 2.5 0.8 20 37
*seg: 42
R493 3001 411 2.5 0.8 20 37
R494 415 425 6.16 0.8 49.28 37
I411 411 0 1.34816e-03
R495 411 412 1.728 0.8 13.824 37
I412 412 0 1.29868e-03
R496 412 413 1.632 0.8 13.056 37
I413 413 0 1.28631e-03
R497 413 414 1.744 0.8 13.952 37
I414 414 0 1.23684e-03
R498 414 415 1.664 0.8 13.312 37
I415 415 0 1.28631e-03
R499 415 416 1.744 0.8 13.952 37
I416 416 0 1.23684e-03
R500 416 417 1.744 0.8 13.952 37
I417 417 0 1.34816e-03
R501 417 418 1.6 0.8 12.8 37
I418 418 0 1.24921e-03
R502 418 419 1.664 0.8 13.312 37
I419 419 0 1.26158e-03
R503 419 420 1.712 0.8 13.696 37
I420 420 0 1.23684e-03
R504 420 3001 2.5 0.8 20 37
*seg: 43
R505 3001 421 2.5 0.8 20 37
R506 425 435 6.16 0.8 49.28 37
I421 421 0 1.24921e-03
R507 421 422 1.728 0.8 13.824 37
I422 422 0 1.26158e-03
R508 422 423 1.728 0.8 13.824 37
I423 423 0 1.27395e-03
R509 423 424 1.744 0.8 13.952 37
I424 424 0 1.34816e-03
R510 424 425 1.744 0.8 13.952 37
I425 425 0 1.26158e-03
R511 425 426 1.744 0.8 13.952 37
I426 426 0 1.32342e-03
R512 426 427 1.6 0.8 12.8 37
I427 427 0 1.34816e-03
R513 427 428 1.648 0.8 13.184 37
I428 428 0 1.29868e-03
R514 428 429 1.712 0.8 13.696 37
I429 429 0 1.34816e-03
R515 429 430 1.68 0.8 13.44 37
I430 430 0 1.23684e-03
R516 430 3001 2.5 0.8 20 37
*seg: 44
R517 3001 431 2.5 0.8 20 37
R518 435 445 6.16 0.8 49.28 37
I431 431 0 1.33579e-03
R519 431 432 1.648 0.8 13.184 37
I432 432 0 1.33579e-03
R520 432 433 1.632 0.8 13.056 37
I433 433 0 1.32342e-03
R521 433 434 1.648 0.8 13.184 37
I434 434 0 1.33579e-03
R522 434 435 1.712 0.8 13.696 37
I435 435 0 1.33579e-03
R523 435 436 1.616 0.8 12.928 37
I436 436 0 1.28631e-03
R524 436 437 1.744 0.8 13.952 37
I437 437 0 1.29868e-03
R525 437 438 1.648 0.8 13.184 37
I438 438 0 1.33579e-03
R526 438 439 1.6 0.8 12.8 37
I439 439 0 1.34816e-03
R527 439 440 1.632 0.8 13.056 37
I440 440 0 1.23684e-03
R528 440 3001 2.5 0.8 20 37
*seg: 45
R529 3001 441 2.5 0.8 20 37
R530 445 455 6.16 0.8 49.28 37
I441 441 0 1.27395e-03
R531 441 442 1.744 0.8 13.952 37
I442 442 0 1.34816e-03
R532 442 443 1.68 0.8 13.44 37
I443 443 0 1.34816e-03
R533 443 444 1.664 0.8 13.312 37
I444 444 0 1.28631e-03
R534 444 445 1.664 0.8 13.312 37
I445 445 0 1.27395e-03
R535 445 446 1.616 0.8 12.928 37
I446 446 0 1.34816e-03
R536 446 447 1.712 0.8 13.696 37
I447 447 0 1.32342e-03
R537 447 448 1.632 0.8 13.056 37
I448 448 0 1.29868e-03
R538 448 449 1.744 0.8 13.952 37
I449 449 0 1.23684e-03
R539 449 450 1.6 0.8 12.8 37
I450 450 0 1.23684e-03
R540 450 3001 2.5 0.8 20 37
*seg: 46
R541 3001 451 2.5 0.8 20 37
R542 455 465 6.16 0.8 49.28 37
I451 451 0 1.24921e-03
R543 451 452 1.648 0.8 13.184 37
I452 452 0 1.28631e-03
R544 452 453 1.632 0.8 13.056 37
I453 453 0 1.24921e-03
R545 453 454 1.632 0.8 13.056 37
I454 454 0 1.33579e-03
R546 454 455 1.616 0.8 12.928 37
I455 455 0 1.33579e-03
R547 455 456 1.664 0.8 13.312 37
I456 456 0 1.31105e-03
R548 456 457 1.616 0.8 12.928 37
I457 457 0 1.28631e-03
R549 457 458 1.664 0.8 13.312 37
I458 458 0 1.29868e-03
R550 458 459 1.712 0.8 13.696 37
I459 459 0 1.23684e-03
R551 459 460 1.728 0.8 13.824 37
I460 460 0 1.23684e-03
R552 460 3001 2.5 0.8 20 37
*seg: 47
R553 3001 461 2.5 0.8 20 37
R554 465 475 6.16 0.8 49.28 37
I461 461 0 1.31105e-03
R555 461 462 1.696 0.8 13.568 37
I462 462 0 1.24921e-03
R556 462 463 1.616 0.8 12.928 37
I463 463 0 1.29868e-03
R557 463 464 1.632 0.8 13.056 37
I464 464 0 1.32342e-03
R558 464 465 1.6 0.8 12.8 37
I465 465 0 1.34816e-03
R559 465 466 1.728 0.8 13.824 37
I466 466 0 1.33579e-03
R560 466 467 1.744 0.8 13.952 37
I467 467 0 1.33579e-03
R561 467 468 1.712 0.8 13.696 37
I468 468 0 1.23684e-03
R562 468 469 1.728 0.8 13.824 37
I469 469 0 1.31105e-03
R563 469 470 1.744 0.8 13.952 37
I470 470 0 1.23684e-03
R564 470 3001 2.5 0.8 20 37
*seg: 48
R565 3001 471 2.5 0.8 20 37
R566 475 485 6.16 0.8 49.28 37
I471 471 0 1.23684e-03
R567 471 472 1.616 0.8 12.928 37
I472 472 0 1.29868e-03
R568 472 473 1.712 0.8 13.696 37
I473 473 0 1.26158e-03
R569 473 474 1.696 0.8 13.568 37
I474 474 0 1.29868e-03
R570 474 475 1.68 0.8 13.44 37
I475 475 0 1.26158e-03
R571 475 476 1.616 0.8 12.928 37
I476 476 0 1.32342e-03
R572 476 477 1.6 0.8 12.8 37
I477 477 0 1.33579e-03
R573 477 478 1.696 0.8 13.568 37
I478 478 0 1.27395e-03
R574 478 479 1.616 0.8 12.928 37
I479 479 0 1.23684e-03
R575 479 480 1.616 0.8 12.928 37
I480 480 0 1.23684e-03
R576 480 3001 2.5 0.8 20 37
*seg: 49
R577 3001 481 2.5 0.8 20 37
R578 485 495 6.16 0.8 49.28 37
I481 481 0 1.23684e-03
R579 481 482 1.6 0.8 12.8 37
I482 482 0 1.31105e-03
R580 482 483 1.728 0.8 13.824 37
I483 483 0 1.34816e-03
R581 483 484 1.744 0.8 13.952 37
I484 484 0 1.34816e-03
R582 484 485 1.712 0.8 13.696 37
I485 485 0 1.24921e-03
R583 485 486 1.664 0.8 13.312 37
I486 486 0 1.32342e-03
R584 486 487 1.6 0.8 12.8 37
I487 487 0 1.33579e-03
R585 487 488 1.632 0.8 13.056 37
I488 488 0 1.31105e-03
R586 488 489 1.632 0.8 13.056 37
I489 489 0 1.24921e-03
R587 489 490 1.68 0.8 13.44 37
I490 490 0 1.23684e-03
R588 490 3001 2.5 0.8 20 37
*seg: 50
R589 3001 491 2.5 0.8 20 37
R590 495 505 6.16 0.8 49.28 37
I491 491 0 1.27395e-03
R591 491 492 1.664 0.8 13.312 37
I492 492 0 1.23684e-03
R592 492 493 1.664 0.8 13.312 37
I493 493 0 1.34816e-03
R593 493 494 1.632 0.8 13.056 37
I494 494 0 1.31105e-03
R594 494 495 1.664 0.8 13.312 37
I495 495 0 1.23684e-03
R595 495 496 1.712 0.8 13.696 37
I496 496 0 1.32342e-03
R596 496 497 1.664 0.8 13.312 37
I497 497 0 1.24921e-03
R597 497 498 1.696 0.8 13.568 37
I498 498 0 1.34816e-03
R598 498 499 1.712 0.8 13.696 37
I499 499 0 1.27395e-03
R599 499 500 1.6 0.8 12.8 37
I500 500 0 1.23684e-03
R600 500 3001 2.5 0.8 20 37
*seg: 51
R601 3001 501 2.5 0.8 20 37
R602 505 515 6.16 0.8 49.28 37
I501 501 0 1.31105e-03
R603 501 502 1.664 0.8 13.312 37
I502 502 0 1.33579e-03
R604 502 503 1.648 0.8 13.184 37
I503 503 0 1.27395e-03
R605 503 504 1.728 0.8 13.824 37
I504 504 0 1.29868e-03
R606 504 505 1.744 0.8 13.952 37
I505 505 0 1.28631e-03
R607 505 506 1.728 0.8 13.824 37
I506 506 0 1.23684e-03
R608 506 507 1.68 0.8 13.44 37
I507 507 0 1.27395e-03
R609 507 508 1.6 0.8 12.8 37
I508 508 0 1.26158e-03
R610 508 509 1.728 0.8 13.824 37
I509 509 0 1.32342e-03
R611 509 510 1.712 0.8 13.696 37
I510 510 0 1.23684e-03
R612 510 3001 2.5 0.8 20 37
*seg: 52
R613 3001 511 2.5 0.8 20 37
R614 515 525 6.16 0.8 49.28 37
I511 511 0 1.31105e-03
R615 511 512 1.728 0.8 13.824 37
I512 512 0 1.32342e-03
R616 512 513 1.632 0.8 13.056 37
I513 513 0 1.34816e-03
R617 513 514 1.68 0.8 13.44 37
I514 514 0 1.24921e-03
R618 514 515 1.6 0.8 12.8 37
I515 515 0 1.32342e-03
R619 515 516 1.696 0.8 13.568 37
I516 516 0 1.33579e-03
R620 516 517 1.728 0.8 13.824 37
I517 517 0 1.26158e-03
R621 517 518 1.632 0.8 13.056 37
I518 518 0 1.26158e-03
R622 518 519 1.6 0.8 12.8 37
I519 519 0 1.23684e-03
R623 519 520 1.696 0.8 13.568 37
I520 520 0 1.23684e-03
R624 520 3001 2.5 0.8 20 37
*seg: 53
R625 3001 521 2.5 0.8 20 37
R626 525 535 6.16 0.8 49.28 37
I521 521 0 1.33579e-03
R627 521 522 1.728 0.8 13.824 37
I522 522 0 1.23684e-03
R628 522 523 1.696 0.8 13.568 37
I523 523 0 1.27395e-03
R629 523 524 1.664 0.8 13.312 37
I524 524 0 1.27395e-03
R630 524 525 1.616 0.8 12.928 37
I525 525 0 1.32342e-03
R631 525 526 1.696 0.8 13.568 37
I526 526 0 1.26158e-03
R632 526 527 1.664 0.8 13.312 37
I527 527 0 1.31105e-03
R633 527 528 1.728 0.8 13.824 37
I528 528 0 1.27395e-03
R634 528 529 1.648 0.8 13.184 37
I529 529 0 1.26158e-03
R635 529 530 1.6 0.8 12.8 37
I530 530 0 1.23684e-03
R636 530 3001 2.5 0.8 20 37
*seg: 54
R637 3001 531 2.5 0.8 20 37
R638 535 545 6.16 0.8 49.28 37
I531 531 0 1.26158e-03
R639 531 532 1.664 0.8 13.312 37
I532 532 0 1.32342e-03
R640 532 533 1.616 0.8 12.928 37
I533 533 0 1.29868e-03
R641 533 534 1.648 0.8 13.184 37
I534 534 0 1.24921e-03
R642 534 535 1.728 0.8 13.824 37
I535 535 0 1.33579e-03
R643 535 536 1.728 0.8 13.824 37
I536 536 0 1.28631e-03
R644 536 537 1.696 0.8 13.568 37
I537 537 0 1.23684e-03
R645 537 538 1.648 0.8 13.184 37
I538 538 0 1.32342e-03
R646 538 539 1.632 0.8 13.056 37
I539 539 0 1.34816e-03
R647 539 540 1.696 0.8 13.568 37
I540 540 0 1.23684e-03
R648 540 3001 2.5 0.8 20 37
*seg: 55
R649 3001 541 2.5 0.8 20 37
R650 545 555 6.16 0.8 49.28 37
I541 541 0 1.34816e-03
R651 541 542 1.696 0.8 13.568 37
I542 542 0 1.29868e-03
R652 542 543 1.744 0.8 13.952 37
I543 543 0 1.27395e-03
R653 543 544 1.664 0.8 13.312 37
I544 544 0 1.34816e-03
R654 544 545 1.68 0.8 13.44 37
I545 545 0 1.33579e-03
R655 545 546 1.696 0.8 13.568 37
I546 546 0 1.34816e-03
R656 546 547 1.648 0.8 13.184 37
I547 547 0 1.32342e-03
R657 547 548 1.712 0.8 13.696 37
I548 548 0 1.32342e-03
R658 548 549 1.664 0.8 13.312 37
I549 549 0 1.23684e-03
R659 549 550 1.728 0.8 13.824 37
I550 550 0 1.23684e-03
R660 550 3001 2.5 0.8 20 37
*seg: 56
R661 3001 551 2.5 0.8 20 37
R662 555 565 6.16 0.8 49.28 37
I551 551 0 1.26158e-03
R663 551 552 1.728 0.8 13.824 37
I552 552 0 1.24921e-03
R664 552 553 1.648 0.8 13.184 37
I553 553 0 1.23684e-03
R665 553 554 1.6 0.8 12.8 37
I554 554 0 1.31105e-03
R666 554 555 1.68 0.8 13.44 37
I555 555 0 1.27395e-03
R667 555 556 1.664 0.8 13.312 37
I556 556 0 1.29868e-03
R668 556 557 1.68 0.8 13.44 37
I557 557 0 1.26158e-03
R669 557 558 1.744 0.8 13.952 37
I558 558 0 1.26158e-03
R670 558 559 1.664 0.8 13.312 37
I559 559 0 1.23684e-03
R671 559 560 1.712 0.8 13.696 37
I560 560 0 1.23684e-03
R672 560 3001 2.5 0.8 20 37
*seg: 57
R673 3001 561 2.5 0.8 20 37
R674 565 575 6.16 0.8 49.28 37
I561 561 0 1.31105e-03
R675 561 562 1.696 0.8 13.568 37
I562 562 0 1.26158e-03
R676 562 563 1.744 0.8 13.952 37
I563 563 0 1.29868e-03
R677 563 564 1.696 0.8 13.568 37
I564 564 0 1.27395e-03
R678 564 565 1.68 0.8 13.44 37
I565 565 0 1.33579e-03
R679 565 566 1.696 0.8 13.568 37
I566 566 0 1.27395e-03
R680 566 567 1.6 0.8 12.8 37
I567 567 0 1.32342e-03
R681 567 568 1.616 0.8 12.928 37
I568 568 0 1.23684e-03
R682 568 569 1.616 0.8 12.928 37
I569 569 0 1.28631e-03
R683 569 570 1.68 0.8 13.44 37
I570 570 0 1.23684e-03
R684 570 3001 2.5 0.8 20 37
*seg: 58
R685 3001 571 2.5 0.8 20 37
R686 575 585 6.16 0.8 49.28 37
I571 571 0 1.29868e-03
R687 571 572 1.696 0.8 13.568 37
I572 572 0 1.33579e-03
R688 572 573 1.744 0.8 13.952 37
I573 573 0 1.24921e-03
R689 573 574 1.664 0.8 13.312 37
I574 574 0 1.31105e-03
R690 574 575 1.744 0.8 13.952 37
I575 575 0 1.28631e-03
R691 575 576 1.696 0.8 13.568 37
I576 576 0 1.31105e-03
R692 576 577 1.632 0.8 13.056 37
I577 577 0 1.27395e-03
R693 577 578 1.664 0.8 13.312 37
I578 578 0 1.34816e-03
R694 578 579 1.616 0.8 12.928 37
I579 579 0 1.31105e-03
R695 579 580 1.664 0.8 13.312 37
I580 580 0 1.23684e-03
R696 580 3001 2.5 0.8 20 37
*seg: 59
R697 3001 581 2.5 0.8 20 37
R698 585 595 6.16 0.8 49.28 37
I581 581 0 1.31105e-03
R699 581 582 1.6 0.8 12.8 37
I582 582 0 1.27395e-03
R700 582 583 1.68 0.8 13.44 37
I583 583 0 1.24921e-03
R701 583 584 1.632 0.8 13.056 37
I584 584 0 1.26158e-03
R702 584 585 1.6 0.8 12.8 37
I585 585 0 1.24921e-03
R703 585 586 1.616 0.8 12.928 37
I586 586 0 1.32342e-03
R704 586 587 1.6 0.8 12.8 37
I587 587 0 1.23684e-03
R705 587 588 1.648 0.8 13.184 37
I588 588 0 1.32342e-03
R706 588 589 1.664 0.8 13.312 37
I589 589 0 1.29868e-03
R707 589 590 1.712 0.8 13.696 37
I590 590 0 1.23684e-03
R708 590 3001 2.5 0.8 20 37
*seg: 60
R709 3001 591 2.5 0.8 20 37
R710 595 605 6.16 0.8 49.28 37
I591 591 0 1.23684e-03
R711 591 592 1.744 0.8 13.952 37
I592 592 0 1.27395e-03
R712 592 593 1.728 0.8 13.824 37
I593 593 0 1.26158e-03
R713 593 594 1.712 0.8 13.696 37
I594 594 0 1.31105e-03
R714 594 595 1.632 0.8 13.056 37
I595 595 0 1.29868e-03
R715 595 596 1.696 0.8 13.568 37
I596 596 0 1.32342e-03
R716 596 597 1.664 0.8 13.312 37
I597 597 0 1.33579e-03
R717 597 598 1.728 0.8 13.824 37
I598 598 0 1.27395e-03
R718 598 599 1.728 0.8 13.824 37
I599 599 0 1.33579e-03
R719 599 600 1.616 0.8 12.928 37
I600 600 0 1.23684e-03
R720 600 3001 2.5 0.8 20 37
*seg: 61
R721 3001 601 2.5 0.8 20 37
R722 605 615 6.16 0.8 49.28 37
I601 601 0 1.29868e-03
R723 601 602 1.696 0.8 13.568 37
I602 602 0 1.34816e-03
R724 602 603 1.696 0.8 13.568 37
I603 603 0 1.23684e-03
R725 603 604 1.696 0.8 13.568 37
I604 604 0 1.28631e-03
R726 604 605 1.744 0.8 13.952 37
I605 605 0 1.33579e-03
R727 605 606 1.68 0.8 13.44 37
I606 606 0 1.26158e-03
R728 606 607 1.728 0.8 13.824 37
I607 607 0 1.29868e-03
R729 607 608 1.616 0.8 12.928 37
I608 608 0 1.24921e-03
R730 608 609 1.648 0.8 13.184 37
I609 609 0 1.29868e-03
R731 609 610 1.744 0.8 13.952 37
I610 610 0 1.23684e-03
R732 610 3001 2.5 0.8 20 37
*seg: 62
R733 3001 611 2.5 0.8 20 37
R734 615 625 6.16 0.8 49.28 37
I611 611 0 1.28631e-03
R735 611 612 1.632 0.8 13.056 37
I612 612 0 1.23684e-03
R736 612 613 1.616 0.8 12.928 37
I613 613 0 1.33579e-03
R737 613 614 1.616 0.8 12.928 37
I614 614 0 1.31105e-03
R738 614 615 1.664 0.8 13.312 37
I615 615 0 1.31105e-03
R739 615 616 1.632 0.8 13.056 37
I616 616 0 1.23684e-03
R740 616 617 1.6 0.8 12.8 37
I617 617 0 1.29868e-03
R741 617 618 1.68 0.8 13.44 37
I618 618 0 1.29868e-03
R742 618 619 1.6 0.8 12.8 37
I619 619 0 1.32342e-03
R743 619 620 1.728 0.8 13.824 37
I620 620 0 1.23684e-03
R744 620 3001 2.5 0.8 20 37
*seg: 63
R745 3001 621 2.5 0.8 20 37
R746 625 635 6.16 0.8 49.28 37
I621 621 0 1.24921e-03
R747 621 622 1.68 0.8 13.44 37
I622 622 0 1.33579e-03
R748 622 623 1.696 0.8 13.568 37
I623 623 0 1.23684e-03
R749 623 624 1.632 0.8 13.056 37
I624 624 0 1.34816e-03
R750 624 625 1.6 0.8 12.8 37
I625 625 0 1.24921e-03
R751 625 626 1.728 0.8 13.824 37
I626 626 0 1.32342e-03
R752 626 627 1.728 0.8 13.824 37
I627 627 0 1.29868e-03
R753 627 628 1.648 0.8 13.184 37
I628 628 0 1.27395e-03
R754 628 629 1.712 0.8 13.696 37
I629 629 0 1.23684e-03
R755 629 630 1.728 0.8 13.824 37
I630 630 0 1.23684e-03
R756 630 3001 2.5 0.8 20 37
*seg: 64
R757 3001 631 2.5 0.8 20 37
R758 635 645 6.16 0.8 49.28 37
I631 631 0 1.32342e-03
R759 631 632 1.648 0.8 13.184 37
I632 632 0 1.26158e-03
R760 632 633 1.632 0.8 13.056 37
I633 633 0 1.31105e-03
R761 633 634 1.6 0.8 12.8 37
I634 634 0 1.33579e-03
R762 634 635 1.664 0.8 13.312 37
I635 635 0 1.27395e-03
R763 635 636 1.648 0.8 13.184 37
I636 636 0 1.32342e-03
R764 636 637 1.744 0.8 13.952 37
I637 637 0 1.26158e-03
R765 637 638 1.664 0.8 13.312 37
I638 638 0 1.31105e-03
R766 638 639 1.712 0.8 13.696 37
I639 639 0 1.24921e-03
R767 639 640 1.712 0.8 13.696 37
I640 640 0 1.23684e-03
R768 640 3001 2.5 0.8 20 37
*seg: 65
R769 3001 641 2.5 0.8 20 37
R770 645 655 6.16 0.8 49.28 37
I641 641 0 1.28631e-03
R771 641 642 1.6 0.8 12.8 37
I642 642 0 1.34816e-03
R772 642 643 1.712 0.8 13.696 37
I643 643 0 1.27395e-03
R773 643 644 1.696 0.8 13.568 37
I644 644 0 1.24921e-03
R774 644 645 1.696 0.8 13.568 37
I645 645 0 1.24921e-03
R775 645 646 1.616 0.8 12.928 37
I646 646 0 1.23684e-03
R776 646 647 1.6 0.8 12.8 37
I647 647 0 1.32342e-03
R777 647 648 1.68 0.8 13.44 37
I648 648 0 1.27395e-03
R778 648 649 1.6 0.8 12.8 37
I649 649 0 1.34816e-03
R779 649 650 1.632 0.8 13.056 37
I650 650 0 1.23684e-03
R780 650 3001 2.5 0.8 20 37
*seg: 66
R781 3001 651 2.5 0.8 20 37
R782 655 665 6.16 0.8 49.28 37
I651 651 0 1.24921e-03
R783 651 652 1.68 0.8 13.44 37
I652 652 0 1.24921e-03
R784 652 653 1.744 0.8 13.952 37
I653 653 0 1.23684e-03
R785 653 654 1.616 0.8 12.928 37
I654 654 0 1.27395e-03
R786 654 655 1.712 0.8 13.696 37
I655 655 0 1.27395e-03
R787 655 656 1.632 0.8 13.056 37
I656 656 0 1.34816e-03
R788 656 657 1.664 0.8 13.312 37
I657 657 0 1.33579e-03
R789 657 658 1.664 0.8 13.312 37
I658 658 0 1.29868e-03
R790 658 659 1.744 0.8 13.952 37
I659 659 0 1.29868e-03
R791 659 660 1.616 0.8 12.928 37
I660 660 0 1.23684e-03
R792 660 3001 2.5 0.8 20 37
*seg: 67
R793 3001 661 2.5 0.8 20 37
R794 665 675 6.16 0.8 49.28 37
I661 661 0 1.34816e-03
R795 661 662 1.6 0.8 12.8 37
I662 662 0 1.28631e-03
R796 662 663 1.616 0.8 12.928 37
I663 663 0 1.33579e-03
R797 663 664 1.632 0.8 13.056 37
I664 664 0 1.29868e-03
R798 664 665 1.648 0.8 13.184 37
I665 665 0 1.31105e-03
R799 665 666 1.616 0.8 12.928 37
I666 666 0 1.31105e-03
R800 666 667 1.648 0.8 13.184 37
I667 667 0 1.27395e-03
R801 667 668 1.712 0.8 13.696 37
I668 668 0 1.26158e-03
R802 668 669 1.712 0.8 13.696 37
I669 669 0 1.31105e-03
R803 669 670 1.712 0.8 13.696 37
I670 670 0 1.23684e-03
R804 670 3001 2.5 0.8 20 37
*seg: 68
R805 3001 671 2.5 0.8 20 37
R806 675 685 6.16 0.8 49.28 37
I671 671 0 1.23684e-03
R807 671 672 1.712 0.8 13.696 37
I672 672 0 1.26158e-03
R808 672 673 1.664 0.8 13.312 37
I673 673 0 1.23684e-03
R809 673 674 1.632 0.8 13.056 37
I674 674 0 1.32342e-03
R810 674 675 1.744 0.8 13.952 37
I675 675 0 1.26158e-03
R811 675 676 1.632 0.8 13.056 37
I676 676 0 1.28631e-03
R812 676 677 1.68 0.8 13.44 37
I677 677 0 1.24921e-03
R813 677 678 1.648 0.8 13.184 37
I678 678 0 1.31105e-03
R814 678 679 1.712 0.8 13.696 37
I679 679 0 1.26158e-03
R815 679 680 1.6 0.8 12.8 37
I680 680 0 1.23684e-03
R816 680 3001 2.5 0.8 20 37
*seg: 69
R817 3001 681 2.5 0.8 20 37
R818 685 695 6.16 0.8 49.28 37
I681 681 0 1.31105e-03
R819 681 682 1.632 0.8 13.056 37
I682 682 0 1.23684e-03
R820 682 683 1.696 0.8 13.568 37
I683 683 0 1.27395e-03
R821 683 684 1.696 0.8 13.568 37
I684 684 0 1.34816e-03
R822 684 685 1.696 0.8 13.568 37
I685 685 0 1.29868e-03
R823 685 686 1.68 0.8 13.44 37
I686 686 0 1.34816e-03
R824 686 687 1.744 0.8 13.952 37
I687 687 0 1.24921e-03
R825 687 688 1.648 0.8 13.184 37
I688 688 0 1.28631e-03
R826 688 689 1.664 0.8 13.312 37
I689 689 0 1.33579e-03
R827 689 690 1.712 0.8 13.696 37
I690 690 0 1.23684e-03
R828 690 3001 2.5 0.8 20 37
*seg: 70
R829 3001 691 2.5 0.8 20 37
R830 695 705 6.16 0.8 49.28 37
I691 691 0 1.31105e-03
R831 691 692 1.696 0.8 13.568 37
I692 692 0 1.31105e-03
R832 692 693 1.728 0.8 13.824 37
I693 693 0 1.29868e-03
R833 693 694 1.6 0.8 12.8 37
I694 694 0 1.24921e-03
R834 694 695 1.6 0.8 12.8 37
I695 695 0 1.23684e-03
R835 695 696 1.696 0.8 13.568 37
I696 696 0 1.23684e-03
R836 696 697 1.696 0.8 13.568 37
I697 697 0 1.24921e-03
R837 697 698 1.712 0.8 13.696 37
I698 698 0 1.34816e-03
R838 698 699 1.744 0.8 13.952 37
I699 699 0 1.28631e-03
R839 699 700 1.712 0.8 13.696 37
I700 700 0 1.23684e-03
R840 700 3001 2.5 0.8 20 37
*seg: 71
R841 3001 701 2.5 0.8 20 37
R842 705 715 6.16 0.8 49.28 37
I701 701 0 1.31105e-03
R843 701 702 1.6 0.8 12.8 37
I702 702 0 1.29868e-03
R844 702 703 1.632 0.8 13.056 37
I703 703 0 1.24921e-03
R845 703 704 1.648 0.8 13.184 37
I704 704 0 1.34816e-03
R846 704 705 1.6 0.8 12.8 37
I705 705 0 1.31105e-03
R847 705 706 1.616 0.8 12.928 37
I706 706 0 1.27395e-03
R848 706 707 1.6 0.8 12.8 37
I707 707 0 1.29868e-03
R849 707 708 1.68 0.8 13.44 37
I708 708 0 1.28631e-03
R850 708 709 1.68 0.8 13.44 37
I709 709 0 1.31105e-03
R851 709 710 1.696 0.8 13.568 37
I710 710 0 1.23684e-03
R852 710 3001 2.5 0.8 20 37
*seg: 72
R853 3001 711 2.5 0.8 20 37
R854 715 725 6.16 0.8 49.28 37
I711 711 0 1.23684e-03
R855 711 712 1.728 0.8 13.824 37
I712 712 0 1.23684e-03
R856 712 713 1.648 0.8 13.184 37
I713 713 0 1.27395e-03
R857 713 714 1.648 0.8 13.184 37
I714 714 0 1.23684e-03
R858 714 715 1.664 0.8 13.312 37
I715 715 0 1.31105e-03
R859 715 716 1.744 0.8 13.952 37
I716 716 0 1.23684e-03
R860 716 717 1.664 0.8 13.312 37
I717 717 0 1.28631e-03
R861 717 718 1.616 0.8 12.928 37
I718 718 0 1.26158e-03
R862 718 719 1.648 0.8 13.184 37
I719 719 0 1.23684e-03
R863 719 720 1.696 0.8 13.568 37
I720 720 0 1.23684e-03
R864 720 3001 2.5 0.8 20 37
*seg: 73
R865 3001 721 2.5 0.8 20 37
R866 725 735 6.16 0.8 49.28 37
I721 721 0 1.29868e-03
R867 721 722 1.616 0.8 12.928 37
I722 722 0 1.29868e-03
R868 722 723 1.616 0.8 12.928 37
I723 723 0 1.28631e-03
R869 723 724 1.68 0.8 13.44 37
I724 724 0 1.34816e-03
R870 724 725 1.68 0.8 13.44 37
I725 725 0 1.31105e-03
R871 725 726 1.696 0.8 13.568 37
I726 726 0 1.31105e-03
R872 726 727 1.616 0.8 12.928 37
I727 727 0 1.23684e-03
R873 727 728 1.68 0.8 13.44 37
I728 728 0 1.23684e-03
R874 728 729 1.744 0.8 13.952 37
I729 729 0 1.32342e-03
R875 729 730 1.616 0.8 12.928 37
I730 730 0 1.23684e-03
R876 730 3001 2.5 0.8 20 37
*seg: 74
R877 3001 731 2.5 0.8 20 37
R878 735 745 6.16 0.8 49.28 37
I731 731 0 1.28631e-03
R879 731 732 1.712 0.8 13.696 37
I732 732 0 1.26158e-03
R880 732 733 1.616 0.8 12.928 37
I733 733 0 1.31105e-03
R881 733 734 1.68 0.8 13.44 37
I734 734 0 1.32342e-03
R882 734 735 1.68 0.8 13.44 37
I735 735 0 1.27395e-03
R883 735 736 1.632 0.8 13.056 37
I736 736 0 1.29868e-03
R884 736 737 1.68 0.8 13.44 37
I737 737 0 1.32342e-03
R885 737 738 1.696 0.8 13.568 37
I738 738 0 1.24921e-03
R886 738 739 1.6 0.8 12.8 37
I739 739 0 1.29868e-03
R887 739 740 1.744 0.8 13.952 37
I740 740 0 1.23684e-03
R888 740 3001 2.5 0.8 20 37
*seg: 75
R889 3001 741 2.5 0.8 20 37
R890 745 755 6.16 0.8 49.28 37
I741 741 0 1.24921e-03
R891 741 742 1.6 0.8 12.8 37
I742 742 0 1.27395e-03
R892 742 743 1.712 0.8 13.696 37
I743 743 0 1.29868e-03
R893 743 744 1.632 0.8 13.056 37
I744 744 0 1.24921e-03
R894 744 745 1.744 0.8 13.952 37
I745 745 0 1.26158e-03
R895 745 746 1.632 0.8 13.056 37
I746 746 0 1.29868e-03
R896 746 747 1.744 0.8 13.952 37
I747 747 0 1.23684e-03
R897 747 748 1.616 0.8 12.928 37
I748 748 0 1.24921e-03
R898 748 749 1.696 0.8 13.568 37
I749 749 0 1.23684e-03
R899 749 750 1.664 0.8 13.312 37
I750 750 0 1.23684e-03
R900 750 3001 2.5 0.8 20 37
*seg: 76
R901 3001 751 2.5 0.8 20 37
R902 755 765 6.16 0.8 49.28 37
I751 751 0 1.27395e-03
R903 751 752 1.648 0.8 13.184 37
I752 752 0 1.31105e-03
R904 752 753 1.744 0.8 13.952 37
I753 753 0 1.31105e-03
R905 753 754 1.632 0.8 13.056 37
I754 754 0 1.34816e-03
R906 754 755 1.744 0.8 13.952 37
I755 755 0 1.34816e-03
R907 755 756 1.632 0.8 13.056 37
I756 756 0 1.33579e-03
R908 756 757 1.68 0.8 13.44 37
I757 757 0 1.33579e-03
R909 757 758 1.696 0.8 13.568 37
I758 758 0 1.29868e-03
R910 758 759 1.616 0.8 12.928 37
I759 759 0 1.28631e-03
R911 759 760 1.664 0.8 13.312 37
I760 760 0 1.23684e-03
R912 760 3001 2.5 0.8 20 37
*seg: 77
R913 3001 761 2.5 0.8 20 37
R914 765 775 6.16 0.8 49.28 37
I761 761 0 1.34816e-03
R915 761 762 1.696 0.8 13.568 37
I762 762 0 1.31105e-03
R916 762 763 1.664 0.8 13.312 37
I763 763 0 1.33579e-03
R917 763 764 1.6 0.8 12.8 37
I764 764 0 1.33579e-03
R918 764 765 1.6 0.8 12.8 37
I765 765 0 1.23684e-03
R919 765 766 1.744 0.8 13.952 37
I766 766 0 1.32342e-03
R920 766 767 1.648 0.8 13.184 37
I767 767 0 1.29868e-03
R921 767 768 1.664 0.8 13.312 37
I768 768 0 1.33579e-03
R922 768 769 1.616 0.8 12.928 37
I769 769 0 1.23684e-03
R923 769 770 1.712 0.8 13.696 37
I770 770 0 1.23684e-03
R924 770 3001 2.5 0.8 20 37
*seg: 78
R925 3001 771 2.5 0.8 20 37
R926 775 785 6.16 0.8 49.28 37
I771 771 0 1.32342e-03
R927 771 772 1.712 0.8 13.696 37
I772 772 0 1.28631e-03
R928 772 773 1.648 0.8 13.184 37
I773 773 0 1.23684e-03
R929 773 774 1.6 0.8 12.8 37
I774 774 0 1.24921e-03
R930 774 775 1.696 0.8 13.568 37
I775 775 0 1.24921e-03
R931 775 776 1.648 0.8 13.184 37
I776 776 0 1.29868e-03
R932 776 777 1.632 0.8 13.056 37
I777 777 0 1.28631e-03
R933 777 778 1.632 0.8 13.056 37
I778 778 0 1.33579e-03
R934 778 779 1.648 0.8 13.184 37
I779 779 0 1.32342e-03
R935 779 780 1.6 0.8 12.8 37
I780 780 0 1.23684e-03
R936 780 3001 2.5 0.8 20 37
*seg: 79
R937 3001 781 2.5 0.8 20 37
R938 785 795 6.16 0.8 49.28 37
I781 781 0 1.34816e-03
R939 781 782 1.696 0.8 13.568 37
I782 782 0 1.27395e-03
R940 782 783 1.6 0.8 12.8 37
I783 783 0 1.23684e-03
R941 783 784 1.728 0.8 13.824 37
I784 784 0 1.29868e-03
R942 784 785 1.712 0.8 13.696 37
I785 785 0 1.27395e-03
R943 785 786 1.6 0.8 12.8 37
I786 786 0 1.33579e-03
R944 786 787 1.648 0.8 13.184 37
I787 787 0 1.24921e-03
R945 787 788 1.696 0.8 13.568 37
I788 788 0 1.26158e-03
R946 788 789 1.648 0.8 13.184 37
I789 789 0 1.34816e-03
R947 789 790 1.6 0.8 12.8 37
I790 790 0 1.23684e-03
R948 790 3001 2.5 0.8 20 37
*seg: 80
R949 3001 791 2.5 0.8 20 37
R950 795 805 6.16 0.8 49.28 37
I791 791 0 1.27395e-03
R951 791 792 1.6 0.8 12.8 37
I792 792 0 1.29868e-03
R952 792 793 1.696 0.8 13.568 37
I793 793 0 1.31105e-03
R953 793 794 1.664 0.8 13.312 37
I794 794 0 1.34816e-03
R954 794 795 1.616 0.8 12.928 37
I795 795 0 1.23684e-03
R955 795 796 1.744 0.8 13.952 37
I796 796 0 1.28631e-03
R956 796 797 1.68 0.8 13.44 37
I797 797 0 1.32342e-03
R957 797 798 1.68 0.8 13.44 37
I798 798 0 1.27395e-03
R958 798 799 1.616 0.8 12.928 37
I799 799 0 1.29868e-03
R959 799 800 1.6 0.8 12.8 37
I800 800 0 1.23684e-03
R960 800 3001 2.5 0.8 20 37
*seg: 81
R961 3001 801 2.5 0.8 20 37
R962 805 815 6.16 0.8 49.28 37
I801 801 0 1.26158e-03
R963 801 802 1.744 0.8 13.952 37
I802 802 0 1.27395e-03
R964 802 803 1.664 0.8 13.312 37
I803 803 0 1.26158e-03
R965 803 804 1.744 0.8 13.952 37
I804 804 0 1.29868e-03
R966 804 805 1.712 0.8 13.696 37
I805 805 0 1.29868e-03
R967 805 806 1.712 0.8 13.696 37
I806 806 0 1.33579e-03
R968 806 807 1.728 0.8 13.824 37
I807 807 0 1.32342e-03
R969 807 808 1.744 0.8 13.952 37
I808 808 0 1.23684e-03
R970 808 809 1.712 0.8 13.696 37
I809 809 0 1.24921e-03
R971 809 810 1.648 0.8 13.184 37
I810 810 0 1.23684e-03
R972 810 3001 2.5 0.8 20 37
*seg: 82
R973 3001 811 2.5 0.8 20 37
R974 815 825 6.16 0.8 49.28 37
I811 811 0 1.33579e-03
R975 811 812 1.6 0.8 12.8 37
I812 812 0 1.32342e-03
R976 812 813 1.712 0.8 13.696 37
I813 813 0 1.29868e-03
R977 813 814 1.68 0.8 13.44 37
I814 814 0 1.26158e-03
R978 814 815 1.744 0.8 13.952 37
I815 815 0 1.27395e-03
R979 815 816 1.664 0.8 13.312 37
I816 816 0 1.32342e-03
R980 816 817 1.696 0.8 13.568 37
I817 817 0 1.24921e-03
R981 817 818 1.664 0.8 13.312 37
I818 818 0 1.31105e-03
R982 818 819 1.68 0.8 13.44 37
I819 819 0 1.26158e-03
R983 819 820 1.68 0.8 13.44 37
I820 820 0 1.23684e-03
R984 820 3001 2.5 0.8 20 37
*seg: 83
R985 3001 821 2.5 0.8 20 37
R986 825 835 6.16 0.8 49.28 37
I821 821 0 1.28631e-03
R987 821 822 1.632 0.8 13.056 37
I822 822 0 1.33579e-03
R988 822 823 1.6 0.8 12.8 37
I823 823 0 1.24921e-03
R989 823 824 1.728 0.8 13.824 37
I824 824 0 1.28631e-03
R990 824 825 1.728 0.8 13.824 37
I825 825 0 1.23684e-03
R991 825 826 1.632 0.8 13.056 37
I826 826 0 1.23684e-03
R992 826 827 1.728 0.8 13.824 37
I827 827 0 1.31105e-03
R993 827 828 1.664 0.8 13.312 37
I828 828 0 1.33579e-03
R994 828 829 1.712 0.8 13.696 37
I829 829 0 1.23684e-03
R995 829 830 1.6 0.8 12.8 37
I830 830 0 1.23684e-03
R996 830 3001 2.5 0.8 20 37
*seg: 84
R997 3001 831 2.5 0.8 20 37
R998 835 845 6.16 0.8 49.28 37
I831 831 0 1.32342e-03
R999 831 832 1.632 0.8 13.056 37
I832 832 0 1.28631e-03
R1000 832 833 1.696 0.8 13.568 37
I833 833 0 1.27395e-03
R1001 833 834 1.728 0.8 13.824 37
I834 834 0 1.24921e-03
R1002 834 835 1.6 0.8 12.8 37
I835 835 0 1.32342e-03
R1003 835 836 1.68 0.8 13.44 37
I836 836 0 1.34816e-03
R1004 836 837 1.648 0.8 13.184 37
I837 837 0 1.27395e-03
R1005 837 838 1.6 0.8 12.8 37
I838 838 0 1.33579e-03
R1006 838 839 1.6 0.8 12.8 37
I839 839 0 1.32342e-03
R1007 839 840 1.6 0.8 12.8 37
I840 840 0 1.23684e-03
R1008 840 3001 2.5 0.8 20 37
*seg: 85
R1009 3001 841 2.5 0.8 20 37
R1010 845 855 6.16 0.8 49.28 37
I841 841 0 1.27395e-03
R1011 841 842 1.728 0.8 13.824 37
I842 842 0 1.33579e-03
R1012 842 843 1.664 0.8 13.312 37
I843 843 0 1.31105e-03
R1013 843 844 1.712 0.8 13.696 37
I844 844 0 1.28631e-03
R1014 844 845 1.712 0.8 13.696 37
I845 845 0 1.29868e-03
R1015 845 846 1.616 0.8 12.928 37
I846 846 0 1.33579e-03
R1016 846 847 1.6 0.8 12.8 37
I847 847 0 1.23684e-03
R1017 847 848 1.648 0.8 13.184 37
I848 848 0 1.31105e-03
R1018 848 849 1.744 0.8 13.952 37
I849 849 0 1.26158e-03
R1019 849 850 1.68 0.8 13.44 37
I850 850 0 1.23684e-03
R1020 850 3001 2.5 0.8 20 37
*seg: 86
R1021 3001 851 2.5 0.8 20 37
R1022 855 865 6.16 0.8 49.28 37
I851 851 0 1.34816e-03
R1023 851 852 1.68 0.8 13.44 37
I852 852 0 1.32342e-03
R1024 852 853 1.616 0.8 12.928 37
I853 853 0 1.28631e-03
R1025 853 854 1.68 0.8 13.44 37
I854 854 0 1.27395e-03
R1026 854 855 1.744 0.8 13.952 37
I855 855 0 1.27395e-03
R1027 855 856 1.744 0.8 13.952 37
I856 856 0 1.24921e-03
R1028 856 857 1.728 0.8 13.824 37
I857 857 0 1.32342e-03
R1029 857 858 1.68 0.8 13.44 37
I858 858 0 1.23684e-03
R1030 858 859 1.68 0.8 13.44 37
I859 859 0 1.29868e-03
R1031 859 860 1.664 0.8 13.312 37
I860 860 0 1.23684e-03
R1032 860 3001 2.5 0.8 20 37
*seg: 87
R1033 3001 861 2.5 0.8 20 37
R1034 865 875 6.16 0.8 49.28 37
I861 861 0 1.27395e-03
R1035 861 862 1.632 0.8 13.056 37
I862 862 0 1.28631e-03
R1036 862 863 1.648 0.8 13.184 37
I863 863 0 1.24921e-03
R1037 863 864 1.648 0.8 13.184 37
I864 864 0 1.26158e-03
R1038 864 865 1.664 0.8 13.312 37
I865 865 0 1.31105e-03
R1039 865 866 1.648 0.8 13.184 37
I866 866 0 1.32342e-03
R1040 866 867 1.728 0.8 13.824 37
I867 867 0 1.27395e-03
R1041 867 868 1.68 0.8 13.44 37
I868 868 0 1.28631e-03
R1042 868 869 1.696 0.8 13.568 37
I869 869 0 1.26158e-03
R1043 869 870 1.696 0.8 13.568 37
I870 870 0 1.23684e-03
R1044 870 3001 2.5 0.8 20 37
*seg: 88
R1045 3001 871 2.5 0.8 20 37
R1046 875 885 6.16 0.8 49.28 37
I871 871 0 1.28631e-03
R1047 871 872 1.616 0.8 12.928 37
I872 872 0 1.23684e-03
R1048 872 873 1.6 0.8 12.8 37
I873 873 0 1.33579e-03
R1049 873 874 1.664 0.8 13.312 37
I874 874 0 1.32342e-03
R1050 874 875 1.712 0.8 13.696 37
I875 875 0 1.27395e-03
R1051 875 876 1.6 0.8 12.8 37
I876 876 0 1.33579e-03
R1052 876 877 1.664 0.8 13.312 37
I877 877 0 1.28631e-03
R1053 877 878 1.6 0.8 12.8 37
I878 878 0 1.28631e-03
R1054 878 879 1.616 0.8 12.928 37
I879 879 0 1.29868e-03
R1055 879 880 1.664 0.8 13.312 37
I880 880 0 1.23684e-03
R1056 880 3001 2.5 0.8 20 37
*seg: 89
R1057 3001 881 2.5 0.8 20 37
R1058 885 895 6.16 0.8 49.28 37
I881 881 0 1.27395e-03
R1059 881 882 1.616 0.8 12.928 37
I882 882 0 1.24921e-03
R1060 882 883 1.744 0.8 13.952 37
I883 883 0 1.33579e-03
R1061 883 884 1.68 0.8 13.44 37
I884 884 0 1.24921e-03
R1062 884 885 1.712 0.8 13.696 37
I885 885 0 1.29868e-03
R1063 885 886 1.632 0.8 13.056 37
I886 886 0 1.32342e-03
R1064 886 887 1.648 0.8 13.184 37
I887 887 0 1.26158e-03
R1065 887 888 1.728 0.8 13.824 37
I888 888 0 1.28631e-03
R1066 888 889 1.744 0.8 13.952 37
I889 889 0 1.34816e-03
R1067 889 890 1.632 0.8 13.056 37
I890 890 0 1.23684e-03
R1068 890 3001 2.5 0.8 20 37
*seg: 90
R1069 3001 891 2.5 0.8 20 37
R1070 895 905 6.16 0.8 49.28 37
I891 891 0 1.23684e-03
R1071 891 892 1.696 0.8 13.568 37
I892 892 0 1.31105e-03
R1072 892 893 1.616 0.8 12.928 37
I893 893 0 1.32342e-03
R1073 893 894 1.616 0.8 12.928 37
I894 894 0 1.27395e-03
R1074 894 895 1.712 0.8 13.696 37
I895 895 0 1.34816e-03
R1075 895 896 1.648 0.8 13.184 37
I896 896 0 1.33579e-03
R1076 896 897 1.712 0.8 13.696 37
I897 897 0 1.27395e-03
R1077 897 898 1.696 0.8 13.568 37
I898 898 0 1.34816e-03
R1078 898 899 1.664 0.8 13.312 37
I899 899 0 1.28631e-03
R1079 899 900 1.632 0.8 13.056 37
I900 900 0 1.23684e-03
R1080 900 3001 2.5 0.8 20 37
*seg: 91
R1081 3001 901 2.5 0.8 20 37
R1082 905 915 6.16 0.8 49.28 37
I901 901 0 1.28631e-03
R1083 901 902 1.664 0.8 13.312 37
I902 902 0 1.29868e-03
R1084 902 903 1.664 0.8 13.312 37
I903 903 0 1.31105e-03
R1085 903 904 1.664 0.8 13.312 37
I904 904 0 1.29868e-03
R1086 904 905 1.696 0.8 13.568 37
I905 905 0 1.29868e-03
R1087 905 906 1.632 0.8 13.056 37
I906 906 0 1.27395e-03
R1088 906 907 1.712 0.8 13.696 37
I907 907 0 1.31105e-03
R1089 907 908 1.664 0.8 13.312 37
I908 908 0 1.26158e-03
R1090 908 909 1.616 0.8 12.928 37
I909 909 0 1.23684e-03
R1091 909 910 1.68 0.8 13.44 37
I910 910 0 1.23684e-03
R1092 910 3001 2.5 0.8 20 37
*seg: 92
R1093 3001 911 2.5 0.8 20 37
R1094 915 925 6.16 0.8 49.28 37
I911 911 0 1.23684e-03
R1095 911 912 1.632 0.8 13.056 37
I912 912 0 1.28631e-03
R1096 912 913 1.744 0.8 13.952 37
I913 913 0 1.24921e-03
R1097 913 914 1.68 0.8 13.44 37
I914 914 0 1.28631e-03
R1098 914 915 1.712 0.8 13.696 37
I915 915 0 1.34816e-03
R1099 915 916 1.648 0.8 13.184 37
I916 916 0 1.24921e-03
R1100 916 917 1.648 0.8 13.184 37
I917 917 0 1.28631e-03
R1101 917 918 1.616 0.8 12.928 37
I918 918 0 1.24921e-03
R1102 918 919 1.648 0.8 13.184 37
I919 919 0 1.33579e-03
R1103 919 920 1.744 0.8 13.952 37
I920 920 0 1.23684e-03
R1104 920 3001 2.5 0.8 20 37
*seg: 93
R1105 3001 921 2.5 0.8 20 37
R1106 925 935 6.16 0.8 49.28 37
I921 921 0 1.34816e-03
R1107 921 922 1.632 0.8 13.056 37
I922 922 0 1.34816e-03
R1108 922 923 1.744 0.8 13.952 37
I923 923 0 1.28631e-03
R1109 923 924 1.712 0.8 13.696 37
I924 924 0 1.26158e-03
R1110 924 925 1.728 0.8 13.824 37
I925 925 0 1.23684e-03
R1111 925 926 1.728 0.8 13.824 37
I926 926 0 1.32342e-03
R1112 926 927 1.632 0.8 13.056 37
I927 927 0 1.23684e-03
R1113 927 928 1.696 0.8 13.568 37
I928 928 0 1.33579e-03
R1114 928 929 1.712 0.8 13.696 37
I929 929 0 1.32342e-03
R1115 929 930 1.744 0.8 13.952 37
I930 930 0 1.23684e-03
R1116 930 3001 2.5 0.8 20 37
*seg: 94
R1117 3001 931 2.5 0.8 20 37
R1118 935 945 6.16 0.8 49.28 37
I931 931 0 1.34816e-03
R1119 931 932 1.6 0.8 12.8 37
I932 932 0 1.29868e-03
R1120 932 933 1.68 0.8 13.44 37
I933 933 0 1.33579e-03
R1121 933 934 1.648 0.8 13.184 37
I934 934 0 1.26158e-03
R1122 934 935 1.664 0.8 13.312 37
I935 935 0 1.29868e-03
R1123 935 936 1.712 0.8 13.696 37
I936 936 0 1.32342e-03
R1124 936 937 1.648 0.8 13.184 37
I937 937 0 1.31105e-03
R1125 937 938 1.696 0.8 13.568 37
I938 938 0 1.34816e-03
R1126 938 939 1.632 0.8 13.056 37
I939 939 0 1.32342e-03
R1127 939 940 1.696 0.8 13.568 37
I940 940 0 1.23684e-03
R1128 940 3001 2.5 0.8 20 37
*seg: 95
R1129 3001 941 2.5 0.8 20 37
R1130 945 955 6.16 0.8 49.28 37
I941 941 0 1.23684e-03
R1131 941 942 1.696 0.8 13.568 37
I942 942 0 1.34816e-03
R1132 942 943 1.744 0.8 13.952 37
I943 943 0 1.27395e-03
R1133 943 944 1.68 0.8 13.44 37
I944 944 0 1.26158e-03
R1134 944 945 1.712 0.8 13.696 37
I945 945 0 1.27395e-03
R1135 945 946 1.68 0.8 13.44 37
I946 946 0 1.23684e-03
R1136 946 947 1.616 0.8 12.928 37
I947 947 0 1.27395e-03
R1137 947 948 1.648 0.8 13.184 37
I948 948 0 1.32342e-03
R1138 948 949 1.664 0.8 13.312 37
I949 949 0 1.33579e-03
R1139 949 950 1.664 0.8 13.312 37
I950 950 0 1.23684e-03
R1140 950 3001 2.5 0.8 20 37
*seg: 96
R1141 3001 951 2.5 0.8 20 37
R1142 955 965 6.16 0.8 49.28 37
I951 951 0 1.28631e-03
R1143 951 952 1.728 0.8 13.824 37
I952 952 0 1.33579e-03
R1144 952 953 1.696 0.8 13.568 37
I953 953 0 1.26158e-03
R1145 953 954 1.6 0.8 12.8 37
I954 954 0 1.29868e-03
R1146 954 955 1.696 0.8 13.568 37
I955 955 0 1.34816e-03
R1147 955 956 1.648 0.8 13.184 37
I956 956 0 1.23684e-03
R1148 956 957 1.744 0.8 13.952 37
I957 957 0 1.29868e-03
R1149 957 958 1.648 0.8 13.184 37
I958 958 0 1.23684e-03
R1150 958 959 1.664 0.8 13.312 37
I959 959 0 1.23684e-03
R1151 959 960 1.6 0.8 12.8 37
I960 960 0 1.23684e-03
R1152 960 3001 2.5 0.8 20 37
*seg: 97
R1153 3001 961 2.5 0.8 20 37
R1154 965 975 6.16 0.8 49.28 37
I961 961 0 1.27395e-03
R1155 961 962 1.632 0.8 13.056 37
I962 962 0 1.32342e-03
R1156 962 963 1.712 0.8 13.696 37
I963 963 0 1.32342e-03
R1157 963 964 1.616 0.8 12.928 37
I964 964 0 1.24921e-03
R1158 964 965 1.696 0.8 13.568 37
I965 965 0 1.33579e-03
R1159 965 966 1.696 0.8 13.568 37
I966 966 0 1.26158e-03
R1160 966 967 1.6 0.8 12.8 37
I967 967 0 1.28631e-03
R1161 967 968 1.632 0.8 13.056 37
I968 968 0 1.23684e-03
R1162 968 969 1.616 0.8 12.928 37
I969 969 0 1.32342e-03
R1163 969 970 1.616 0.8 12.928 37
I970 970 0 1.23684e-03
R1164 970 3001 2.5 0.8 20 37
*seg: 98
R1165 3001 971 2.5 0.8 20 37
R1166 975 985 6.16 0.8 49.28 37
I971 971 0 1.33579e-03
R1167 971 972 1.68 0.8 13.44 37
I972 972 0 1.29868e-03
R1168 972 973 1.744 0.8 13.952 37
I973 973 0 1.33579e-03
R1169 973 974 1.68 0.8 13.44 37
I974 974 0 1.28631e-03
R1170 974 975 1.728 0.8 13.824 37
I975 975 0 1.28631e-03
R1171 975 976 1.648 0.8 13.184 37
I976 976 0 1.29868e-03
R1172 976 977 1.744 0.8 13.952 37
I977 977 0 1.29868e-03
R1173 977 978 1.6 0.8 12.8 37
I978 978 0 1.27395e-03
R1174 978 979 1.648 0.8 13.184 37
I979 979 0 1.27395e-03
R1175 979 980 1.696 0.8 13.568 37
I980 980 0 1.23684e-03
R1176 980 3001 2.5 0.8 20 37
*seg: 99
R1177 3001 981 2.5 0.8 20 37
R1178 985 995 6.16 0.8 49.28 37
I981 981 0 1.33579e-03
R1179 981 982 1.744 0.8 13.952 37
I982 982 0 1.31105e-03
R1180 982 983 1.6 0.8 12.8 37
I983 983 0 1.31105e-03
R1181 983 984 1.696 0.8 13.568 37
I984 984 0 1.28631e-03
R1182 984 985 1.696 0.8 13.568 37
I985 985 0 1.33579e-03
R1183 985 986 1.648 0.8 13.184 37
I986 986 0 1.32342e-03
R1184 986 987 1.696 0.8 13.568 37
I987 987 0 1.23684e-03
R1185 987 988 1.616 0.8 12.928 37
I988 988 0 1.27395e-03
R1186 988 989 1.744 0.8 13.952 37
I989 989 0 1.32342e-03
R1187 989 990 1.744 0.8 13.952 37
I990 990 0 1.23684e-03
R1188 990 3001 2.5 0.8 20 37
*seg: 100
R1189 3001 991 2.5 0.8 20 37
R1190 995 1005 6.16 0.8 49.28 37
I991 991 0 1.28631e-03
R1191 991 992 1.664 0.8 13.312 37
I992 992 0 1.32342e-03
R1192 992 993 1.664 0.8 13.312 37
I993 993 0 1.32342e-03
R1193 993 994 1.696 0.8 13.568 37
I994 994 0 1.23684e-03
R1194 994 995 1.728 0.8 13.824 37
I995 995 0 1.26158e-03
R1195 995 996 1.68 0.8 13.44 37
I996 996 0 1.27395e-03
R1196 996 997 1.712 0.8 13.696 37
I997 997 0 1.32342e-03
R1197 997 998 1.728 0.8 13.824 37
I998 998 0 1.23684e-03
R1198 998 999 1.728 0.8 13.824 37
I999 999 0 1.32342e-03
R1199 999 1000 1.696 0.8 13.568 37
I1000 1000 0 1.23684e-03
R1200 1000 3001 2.5 0.8 20 37
*seg: 101
R1201 3001 1001 2.5 0.8 20 37
R1202 1005 1015 6.16 0.8 49.28 37
I1001 1001 0 1.26158e-03
R1203 1001 1002 1.664 0.8 13.312 37
I1002 1002 0 1.31105e-03
R1204 1002 1003 1.728 0.8 13.824 37
I1003 1003 0 1.34816e-03
R1205 1003 1004 1.648 0.8 13.184 37
I1004 1004 0 1.24921e-03
R1206 1004 1005 1.6 0.8 12.8 37
I1005 1005 0 1.32342e-03
R1207 1005 1006 1.648 0.8 13.184 37
I1006 1006 0 1.31105e-03
R1208 1006 1007 1.616 0.8 12.928 37
I1007 1007 0 1.31105e-03
R1209 1007 1008 1.648 0.8 13.184 37
I1008 1008 0 1.27395e-03
R1210 1008 1009 1.728 0.8 13.824 37
I1009 1009 0 1.29868e-03
R1211 1009 1010 1.664 0.8 13.312 37
I1010 1010 0 1.23684e-03
R1212 1010 3001 2.5 0.8 20 37
*seg: 102
R1213 3001 1011 2.5 0.8 20 37
R1214 1015 1025 6.16 0.8 49.28 37
I1011 1011 0 1.31105e-03
R1215 1011 1012 1.744 0.8 13.952 37
I1012 1012 0 1.23684e-03
R1216 1012 1013 1.68 0.8 13.44 37
I1013 1013 0 1.32342e-03
R1217 1013 1014 1.648 0.8 13.184 37
I1014 1014 0 1.24921e-03
R1218 1014 1015 1.696 0.8 13.568 37
I1015 1015 0 1.32342e-03
R1219 1015 1016 1.664 0.8 13.312 37
I1016 1016 0 1.32342e-03
R1220 1016 1017 1.6 0.8 12.8 37
I1017 1017 0 1.31105e-03
R1221 1017 1018 1.6 0.8 12.8 37
I1018 1018 0 1.23684e-03
R1222 1018 1019 1.696 0.8 13.568 37
I1019 1019 0 1.29868e-03
R1223 1019 1020 1.68 0.8 13.44 37
I1020 1020 0 1.23684e-03
R1224 1020 3001 2.5 0.8 20 37
*seg: 103
R1225 3001 1021 2.5 0.8 20 37
R1226 1025 1035 6.16 0.8 49.28 37
I1021 1021 0 1.34816e-03
R1227 1021 1022 1.696 0.8 13.568 37
I1022 1022 0 1.34816e-03
R1228 1022 1023 1.664 0.8 13.312 37
I1023 1023 0 1.29868e-03
R1229 1023 1024 1.6 0.8 12.8 37
I1024 1024 0 1.32342e-03
R1230 1024 1025 1.664 0.8 13.312 37
I1025 1025 0 1.26158e-03
R1231 1025 1026 1.632 0.8 13.056 37
I1026 1026 0 1.23684e-03
R1232 1026 1027 1.616 0.8 12.928 37
I1027 1027 0 1.28631e-03
R1233 1027 1028 1.616 0.8 12.928 37
I1028 1028 0 1.26158e-03
R1234 1028 1029 1.744 0.8 13.952 37
I1029 1029 0 1.33579e-03
R1235 1029 1030 1.744 0.8 13.952 37
I1030 1030 0 1.23684e-03
R1236 1030 3001 2.5 0.8 20 37
*seg: 104
R1237 3001 1031 2.5 0.8 20 37
R1238 1035 1045 6.16 0.8 49.28 37
I1031 1031 0 1.32342e-03
R1239 1031 1032 1.6 0.8 12.8 37
I1032 1032 0 1.31105e-03
R1240 1032 1033 1.744 0.8 13.952 37
I1033 1033 0 1.34816e-03
R1241 1033 1034 1.648 0.8 13.184 37
I1034 1034 0 1.33579e-03
R1242 1034 1035 1.632 0.8 13.056 37
I1035 1035 0 1.34816e-03
R1243 1035 1036 1.632 0.8 13.056 37
I1036 1036 0 1.26158e-03
R1244 1036 1037 1.616 0.8 12.928 37
I1037 1037 0 1.34816e-03
R1245 1037 1038 1.712 0.8 13.696 37
I1038 1038 0 1.31105e-03
R1246 1038 1039 1.744 0.8 13.952 37
I1039 1039 0 1.33579e-03
R1247 1039 1040 1.728 0.8 13.824 37
I1040 1040 0 1.23684e-03
R1248 1040 3001 2.5 0.8 20 37
*seg: 105
R1249 3001 1041 2.5 0.8 20 37
R1250 1045 1055 6.16 0.8 49.28 37
I1041 1041 0 1.33579e-03
R1251 1041 1042 1.712 0.8 13.696 37
I1042 1042 0 1.28631e-03
R1252 1042 1043 1.664 0.8 13.312 37
I1043 1043 0 1.34816e-03
R1253 1043 1044 1.744 0.8 13.952 37
I1044 1044 0 1.33579e-03
R1254 1044 1045 1.744 0.8 13.952 37
I1045 1045 0 1.33579e-03
R1255 1045 1046 1.728 0.8 13.824 37
I1046 1046 0 1.31105e-03
R1256 1046 1047 1.728 0.8 13.824 37
I1047 1047 0 1.24921e-03
R1257 1047 1048 1.632 0.8 13.056 37
I1048 1048 0 1.34816e-03
R1258 1048 1049 1.6 0.8 12.8 37
I1049 1049 0 1.33579e-03
R1259 1049 1050 1.728 0.8 13.824 37
I1050 1050 0 1.23684e-03
R1260 1050 3001 2.5 0.8 20 37
*seg: 106
R1261 3001 1051 2.5 0.8 20 37
R1262 1055 1065 6.16 0.8 49.28 37
I1051 1051 0 1.33579e-03
R1263 1051 1052 1.712 0.8 13.696 37
I1052 1052 0 1.31105e-03
R1264 1052 1053 1.632 0.8 13.056 37
I1053 1053 0 1.26158e-03
R1265 1053 1054 1.728 0.8 13.824 37
I1054 1054 0 1.31105e-03
R1266 1054 1055 1.6 0.8 12.8 37
I1055 1055 0 1.34816e-03
R1267 1055 1056 1.664 0.8 13.312 37
I1056 1056 0 1.29868e-03
R1268 1056 1057 1.696 0.8 13.568 37
I1057 1057 0 1.31105e-03
R1269 1057 1058 1.696 0.8 13.568 37
I1058 1058 0 1.23684e-03
R1270 1058 1059 1.648 0.8 13.184 37
I1059 1059 0 1.33579e-03
R1271 1059 1060 1.696 0.8 13.568 37
I1060 1060 0 1.23684e-03
R1272 1060 3001 2.5 0.8 20 37
*seg: 107
R1273 3001 1061 2.5 0.8 20 37
R1274 1065 1075 6.16 0.8 49.28 37
I1061 1061 0 1.26158e-03
R1275 1061 1062 1.712 0.8 13.696 37
I1062 1062 0 1.32342e-03
R1276 1062 1063 1.632 0.8 13.056 37
I1063 1063 0 1.34816e-03
R1277 1063 1064 1.712 0.8 13.696 37
I1064 1064 0 1.23684e-03
R1278 1064 1065 1.664 0.8 13.312 37
I1065 1065 0 1.34816e-03
R1279 1065 1066 1.648 0.8 13.184 37
I1066 1066 0 1.23684e-03
R1280 1066 1067 1.744 0.8 13.952 37
I1067 1067 0 1.32342e-03
R1281 1067 1068 1.632 0.8 13.056 37
I1068 1068 0 1.34816e-03
R1282 1068 1069 1.744 0.8 13.952 37
I1069 1069 0 1.32342e-03
R1283 1069 1070 1.632 0.8 13.056 37
I1070 1070 0 1.23684e-03
R1284 1070 3001 2.5 0.8 20 37
*seg: 108
R1285 3001 1071 2.5 0.8 20 37
R1286 1075 1085 6.16 0.8 49.28 37
I1071 1071 0 1.34816e-03
R1287 1071 1072 1.664 0.8 13.312 37
I1072 1072 0 1.29868e-03
R1288 1072 1073 1.6 0.8 12.8 37
I1073 1073 0 1.27395e-03
R1289 1073 1074 1.696 0.8 13.568 37
I1074 1074 0 1.31105e-03
R1290 1074 1075 1.664 0.8 13.312 37
I1075 1075 0 1.32342e-03
R1291 1075 1076 1.744 0.8 13.952 37
I1076 1076 0 1.31105e-03
R1292 1076 1077 1.632 0.8 13.056 37
I1077 1077 0 1.24921e-03
R1293 1077 1078 1.616 0.8 12.928 37
I1078 1078 0 1.29868e-03
R1294 1078 1079 1.648 0.8 13.184 37
I1079 1079 0 1.31105e-03
R1295 1079 1080 1.696 0.8 13.568 37
I1080 1080 0 1.23684e-03
R1296 1080 3001 2.5 0.8 20 37
*seg: 109
R1297 3001 1081 2.5 0.8 20 37
R1298 1085 1095 6.16 0.8 49.28 37
I1081 1081 0 1.32342e-03
R1299 1081 1082 1.744 0.8 13.952 37
I1082 1082 0 1.31105e-03
R1300 1082 1083 1.616 0.8 12.928 37
I1083 1083 0 1.26158e-03
R1301 1083 1084 1.744 0.8 13.952 37
I1084 1084 0 1.31105e-03
R1302 1084 1085 1.744 0.8 13.952 37
I1085 1085 0 1.26158e-03
R1303 1085 1086 1.696 0.8 13.568 37
I1086 1086 0 1.26158e-03
R1304 1086 1087 1.744 0.8 13.952 37
I1087 1087 0 1.34816e-03
R1305 1087 1088 1.712 0.8 13.696 37
I1088 1088 0 1.28631e-03
R1306 1088 1089 1.648 0.8 13.184 37
I1089 1089 0 1.33579e-03
R1307 1089 1090 1.6 0.8 12.8 37
I1090 1090 0 1.23684e-03
R1308 1090 3001 2.5 0.8 20 37
*seg: 110
R1309 3001 1091 2.5 0.8 20 37
R1310 1095 1105 6.16 0.8 49.28 37
I1091 1091 0 1.33579e-03
R1311 1091 1092 1.648 0.8 13.184 37
I1092 1092 0 1.27395e-03
R1312 1092 1093 1.6 0.8 12.8 37
I1093 1093 0 1.33579e-03
R1313 1093 1094 1.728 0.8 13.824 37
I1094 1094 0 1.28631e-03
R1314 1094 1095 1.6 0.8 12.8 37
I1095 1095 0 1.24921e-03
R1315 1095 1096 1.648 0.8 13.184 37
I1096 1096 0 1.23684e-03
R1316 1096 1097 1.632 0.8 13.056 37
I1097 1097 0 1.31105e-03
R1317 1097 1098 1.616 0.8 12.928 37
I1098 1098 0 1.31105e-03
R1318 1098 1099 1.744 0.8 13.952 37
I1099 1099 0 1.27395e-03
R1319 1099 1100 1.616 0.8 12.928 37
I1100 1100 0 1.23684e-03
R1320 1100 3001 2.5 0.8 20 37
*seg: 111
R1321 3001 1101 2.5 0.8 20 37
R1322 1105 1115 6.16 0.8 49.28 37
I1101 1101 0 1.26158e-03
R1323 1101 1102 1.696 0.8 13.568 37
I1102 1102 0 1.24921e-03
R1324 1102 1103 1.696 0.8 13.568 37
I1103 1103 0 1.32342e-03
R1325 1103 1104 1.744 0.8 13.952 37
I1104 1104 0 1.31105e-03
R1326 1104 1105 1.648 0.8 13.184 37
I1105 1105 0 1.24921e-03
R1327 1105 1106 1.728 0.8 13.824 37
I1106 1106 0 1.29868e-03
R1328 1106 1107 1.6 0.8 12.8 37
I1107 1107 0 1.32342e-03
R1329 1107 1108 1.728 0.8 13.824 37
I1108 1108 0 1.24921e-03
R1330 1108 1109 1.632 0.8 13.056 37
I1109 1109 0 1.24921e-03
R1331 1109 1110 1.728 0.8 13.824 37
I1110 1110 0 1.23684e-03
R1332 1110 3001 2.5 0.8 20 37
*seg: 112
R1333 3001 1111 2.5 0.8 20 37
R1334 1115 1125 6.16 0.8 49.28 37
I1111 1111 0 1.28631e-03
R1335 1111 1112 1.744 0.8 13.952 37
I1112 1112 0 1.32342e-03
R1336 1112 1113 1.648 0.8 13.184 37
I1113 1113 0 1.31105e-03
R1337 1113 1114 1.648 0.8 13.184 37
I1114 1114 0 1.28631e-03
R1338 1114 1115 1.664 0.8 13.312 37
I1115 1115 0 1.29868e-03
R1339 1115 1116 1.616 0.8 12.928 37
I1116 1116 0 1.29868e-03
R1340 1116 1117 1.728 0.8 13.824 37
I1117 1117 0 1.34816e-03
R1341 1117 1118 1.68 0.8 13.44 37
I1118 1118 0 1.31105e-03
R1342 1118 1119 1.616 0.8 12.928 37
I1119 1119 0 1.26158e-03
R1343 1119 1120 1.6 0.8 12.8 37
I1120 1120 0 1.23684e-03
R1344 1120 3001 2.5 0.8 20 37
*seg: 113
R1345 3001 1121 2.5 0.8 20 37
R1346 1125 1135 6.16 0.8 49.28 37
I1121 1121 0 1.24921e-03
R1347 1121 1122 1.6 0.8 12.8 37
I1122 1122 0 1.28631e-03
R1348 1122 1123 1.712 0.8 13.696 37
I1123 1123 0 1.32342e-03
R1349 1123 1124 1.68 0.8 13.44 37
I1124 1124 0 1.26158e-03
R1350 1124 1125 1.712 0.8 13.696 37
I1125 1125 0 1.31105e-03
R1351 1125 1126 1.744 0.8 13.952 37
I1126 1126 0 1.24921e-03
R1352 1126 1127 1.696 0.8 13.568 37
I1127 1127 0 1.26158e-03
R1353 1127 1128 1.6 0.8 12.8 37
I1128 1128 0 1.26158e-03
R1354 1128 1129 1.648 0.8 13.184 37
I1129 1129 0 1.27395e-03
R1355 1129 1130 1.6 0.8 12.8 37
I1130 1130 0 1.23684e-03
R1356 1130 3001 2.5 0.8 20 37
*seg: 114
R1357 3001 1131 2.5 0.8 20 37
R1358 1135 1145 6.16 0.8 49.28 37
I1131 1131 0 1.24921e-03
R1359 1131 1132 1.648 0.8 13.184 37
I1132 1132 0 1.29868e-03
R1360 1132 1133 1.664 0.8 13.312 37
I1133 1133 0 1.27395e-03
R1361 1133 1134 1.616 0.8 12.928 37
I1134 1134 0 1.34816e-03
R1362 1134 1135 1.744 0.8 13.952 37
I1135 1135 0 1.33579e-03
R1363 1135 1136 1.632 0.8 13.056 37
I1136 1136 0 1.27395e-03
R1364 1136 1137 1.664 0.8 13.312 37
I1137 1137 0 1.26158e-03
R1365 1137 1138 1.664 0.8 13.312 37
I1138 1138 0 1.31105e-03
R1366 1138 1139 1.664 0.8 13.312 37
I1139 1139 0 1.27395e-03
R1367 1139 1140 1.68 0.8 13.44 37
I1140 1140 0 1.23684e-03
R1368 1140 3001 2.5 0.8 20 37
*seg: 115
R1369 3001 1141 2.5 0.8 20 37
R1370 1145 1155 6.16 0.8 49.28 37
I1141 1141 0 1.32342e-03
R1371 1141 1142 1.6 0.8 12.8 37
I1142 1142 0 1.26158e-03
R1372 1142 1143 1.68 0.8 13.44 37
I1143 1143 0 1.31105e-03
R1373 1143 1144 1.648 0.8 13.184 37
I1144 1144 0 1.33579e-03
R1374 1144 1145 1.712 0.8 13.696 37
I1145 1145 0 1.23684e-03
R1375 1145 1146 1.632 0.8 13.056 37
I1146 1146 0 1.27395e-03
R1376 1146 1147 1.728 0.8 13.824 37
I1147 1147 0 1.23684e-03
R1377 1147 1148 1.648 0.8 13.184 37
I1148 1148 0 1.29868e-03
R1378 1148 1149 1.648 0.8 13.184 37
I1149 1149 0 1.28631e-03
R1379 1149 1150 1.616 0.8 12.928 37
I1150 1150 0 1.23684e-03
R1380 1150 3001 2.5 0.8 20 37
*seg: 116
R1381 3001 1151 2.5 0.8 20 37
R1382 1155 1165 6.16 0.8 49.28 37
I1151 1151 0 1.34816e-03
R1383 1151 1152 1.744 0.8 13.952 37
I1152 1152 0 1.23684e-03
R1384 1152 1153 1.68 0.8 13.44 37
I1153 1153 0 1.31105e-03
R1385 1153 1154 1.632 0.8 13.056 37
I1154 1154 0 1.34816e-03
R1386 1154 1155 1.664 0.8 13.312 37
I1155 1155 0 1.33579e-03
R1387 1155 1156 1.696 0.8 13.568 37
I1156 1156 0 1.31105e-03
R1388 1156 1157 1.6 0.8 12.8 37
I1157 1157 0 1.27395e-03
R1389 1157 1158 1.648 0.8 13.184 37
I1158 1158 0 1.28631e-03
R1390 1158 1159 1.664 0.8 13.312 37
I1159 1159 0 1.31105e-03
R1391 1159 1160 1.696 0.8 13.568 37
I1160 1160 0 1.23684e-03
R1392 1160 3001 2.5 0.8 20 37
*seg: 117
R1393 3001 1161 2.5 0.8 20 37
R1394 1165 1175 6.16 0.8 49.28 37
I1161 1161 0 1.34816e-03
R1395 1161 1162 1.616 0.8 12.928 37
I1162 1162 0 1.26158e-03
R1396 1162 1163 1.664 0.8 13.312 37
I1163 1163 0 1.26158e-03
R1397 1163 1164 1.632 0.8 13.056 37
I1164 1164 0 1.32342e-03
R1398 1164 1165 1.6 0.8 12.8 37
I1165 1165 0 1.29868e-03
R1399 1165 1166 1.696 0.8 13.568 37
I1166 1166 0 1.27395e-03
R1400 1166 1167 1.696 0.8 13.568 37
I1167 1167 0 1.27395e-03
R1401 1167 1168 1.728 0.8 13.824 37
I1168 1168 0 1.33579e-03
R1402 1168 1169 1.648 0.8 13.184 37
I1169 1169 0 1.33579e-03
R1403 1169 1170 1.744 0.8 13.952 37
I1170 1170 0 1.23684e-03
R1404 1170 3001 2.5 0.8 20 37
*seg: 118
R1405 3001 1171 2.5 0.8 20 37
R1406 1175 1185 6.16 0.8 49.28 37
I1171 1171 0 1.31105e-03
R1407 1171 1172 1.664 0.8 13.312 37
I1172 1172 0 1.33579e-03
R1408 1172 1173 1.68 0.8 13.44 37
I1173 1173 0 1.29868e-03
R1409 1173 1174 1.6 0.8 12.8 37
I1174 1174 0 1.31105e-03
R1410 1174 1175 1.6 0.8 12.8 37
I1175 1175 0 1.31105e-03
R1411 1175 1176 1.616 0.8 12.928 37
I1176 1176 0 1.23684e-03
R1412 1176 1177 1.712 0.8 13.696 37
I1177 1177 0 1.32342e-03
R1413 1177 1178 1.6 0.8 12.8 37
I1178 1178 0 1.24921e-03
R1414 1178 1179 1.616 0.8 12.928 37
I1179 1179 0 1.31105e-03
R1415 1179 1180 1.616 0.8 12.928 37
I1180 1180 0 1.23684e-03
R1416 1180 3001 2.5 0.8 20 37
*seg: 119
R1417 3001 1181 2.5 0.8 20 37
R1418 1185 1195 6.16 0.8 49.28 37
I1181 1181 0 1.27395e-03
R1419 1181 1182 1.744 0.8 13.952 37
I1182 1182 0 1.26158e-03
R1420 1182 1183 1.744 0.8 13.952 37
I1183 1183 0 1.33579e-03
R1421 1183 1184 1.68 0.8 13.44 37
I1184 1184 0 1.32342e-03
R1422 1184 1185 1.664 0.8 13.312 37
I1185 1185 0 1.33579e-03
R1423 1185 1186 1.696 0.8 13.568 37
I1186 1186 0 1.27395e-03
R1424 1186 1187 1.68 0.8 13.44 37
I1187 1187 0 1.23684e-03
R1425 1187 1188 1.6 0.8 12.8 37
I1188 1188 0 1.27395e-03
R1426 1188 1189 1.664 0.8 13.312 37
I1189 1189 0 1.28631e-03
R1427 1189 1190 1.664 0.8 13.312 37
I1190 1190 0 1.23684e-03
R1428 1190 3001 2.5 0.8 20 37
*seg: 120
R1429 3001 1191 2.5 0.8 20 37
R1430 1195 1205 6.16 0.8 49.28 37
I1191 1191 0 1.29868e-03
R1431 1191 1192 1.632 0.8 13.056 37
I1192 1192 0 1.28631e-03
R1432 1192 1193 1.744 0.8 13.952 37
I1193 1193 0 1.32342e-03
R1433 1193 1194 1.712 0.8 13.696 37
I1194 1194 0 1.28631e-03
R1434 1194 1195 1.6 0.8 12.8 37
I1195 1195 0 1.24921e-03
R1435 1195 1196 1.712 0.8 13.696 37
I1196 1196 0 1.29868e-03
R1436 1196 1197 1.6 0.8 12.8 37
I1197 1197 0 1.27395e-03
R1437 1197 1198 1.728 0.8 13.824 37
I1198 1198 0 1.32342e-03
R1438 1198 1199 1.632 0.8 13.056 37
I1199 1199 0 1.34816e-03
R1439 1199 1200 1.68 0.8 13.44 37
I1200 1200 0 1.23684e-03
R1440 1200 3001 2.5 0.8 20 37
*seg: 121
R1441 3001 1201 2.5 0.8 20 37
R1442 1205 1215 6.16 0.8 49.28 37
I1201 1201 0 1.32342e-03
R1443 1201 1202 1.696 0.8 13.568 37
I1202 1202 0 1.29868e-03
R1444 1202 1203 1.632 0.8 13.056 37
I1203 1203 0 1.26158e-03
R1445 1203 1204 1.744 0.8 13.952 37
I1204 1204 0 1.29868e-03
R1446 1204 1205 1.616 0.8 12.928 37
I1205 1205 0 1.28631e-03
R1447 1205 1206 1.728 0.8 13.824 37
I1206 1206 0 1.34816e-03
R1448 1206 1207 1.632 0.8 13.056 37
I1207 1207 0 1.28631e-03
R1449 1207 1208 1.696 0.8 13.568 37
I1208 1208 0 1.28631e-03
R1450 1208 1209 1.664 0.8 13.312 37
I1209 1209 0 1.34816e-03
R1451 1209 1210 1.696 0.8 13.568 37
I1210 1210 0 1.23684e-03
R1452 1210 3001 2.5 0.8 20 37
*seg: 122
R1453 3001 1211 2.5 0.8 20 37
R1454 1215 1225 6.16 0.8 49.28 37
I1211 1211 0 1.29868e-03
R1455 1211 1212 1.728 0.8 13.824 37
I1212 1212 0 1.23684e-03
R1456 1212 1213 1.728 0.8 13.824 37
I1213 1213 0 1.33579e-03
R1457 1213 1214 1.648 0.8 13.184 37
I1214 1214 0 1.29868e-03
R1458 1214 1215 1.648 0.8 13.184 37
I1215 1215 0 1.23684e-03
R1459 1215 1216 1.616 0.8 12.928 37
I1216 1216 0 1.26158e-03
R1460 1216 1217 1.648 0.8 13.184 37
I1217 1217 0 1.29868e-03
R1461 1217 1218 1.696 0.8 13.568 37
I1218 1218 0 1.33579e-03
R1462 1218 1219 1.6 0.8 12.8 37
I1219 1219 0 1.23684e-03
R1463 1219 1220 1.664 0.8 13.312 37
I1220 1220 0 1.23684e-03
R1464 1220 3001 2.5 0.8 20 37
*seg: 123
R1465 3001 1221 2.5 0.8 20 37
R1466 1225 1235 6.16 0.8 49.28 37
I1221 1221 0 1.24921e-03
R1467 1221 1222 1.6 0.8 12.8 37
I1222 1222 0 1.23684e-03
R1468 1222 1223 1.68 0.8 13.44 37
I1223 1223 0 1.31105e-03
R1469 1223 1224 1.632 0.8 13.056 37
I1224 1224 0 1.33579e-03
R1470 1224 1225 1.664 0.8 13.312 37
I1225 1225 0 1.28631e-03
R1471 1225 1226 1.712 0.8 13.696 37
I1226 1226 0 1.29868e-03
R1472 1226 1227 1.616 0.8 12.928 37
I1227 1227 0 1.29868e-03
R1473 1227 1228 1.6 0.8 12.8 37
I1228 1228 0 1.34816e-03
R1474 1228 1229 1.728 0.8 13.824 37
I1229 1229 0 1.23684e-03
R1475 1229 1230 1.632 0.8 13.056 37
I1230 1230 0 1.23684e-03
R1476 1230 3001 2.5 0.8 20 37
*seg: 124
R1477 3001 1231 2.5 0.8 20 37
R1478 1235 1245 6.16 0.8 49.28 37
I1231 1231 0 1.24921e-03
R1479 1231 1232 1.632 0.8 13.056 37
I1232 1232 0 1.34816e-03
R1480 1232 1233 1.696 0.8 13.568 37
I1233 1233 0 1.24921e-03
R1481 1233 1234 1.632 0.8 13.056 37
I1234 1234 0 1.31105e-03
R1482 1234 1235 1.744 0.8 13.952 37
I1235 1235 0 1.23684e-03
R1483 1235 1236 1.6 0.8 12.8 37
I1236 1236 0 1.31105e-03
R1484 1236 1237 1.744 0.8 13.952 37
I1237 1237 0 1.27395e-03
R1485 1237 1238 1.712 0.8 13.696 37
I1238 1238 0 1.23684e-03
R1486 1238 1239 1.744 0.8 13.952 37
I1239 1239 0 1.33579e-03
R1487 1239 1240 1.712 0.8 13.696 37
I1240 1240 0 1.23684e-03
R1488 1240 3001 2.5 0.8 20 37
*seg: 125
R1489 3001 1241 2.5 0.8 20 37
R1490 1245 1255 6.16 0.8 49.28 37
I1241 1241 0 1.23684e-03
R1491 1241 1242 1.632 0.8 13.056 37
I1242 1242 0 1.26158e-03
R1492 1242 1243 1.664 0.8 13.312 37
I1243 1243 0 1.33579e-03
R1493 1243 1244 1.728 0.8 13.824 37
I1244 1244 0 1.34816e-03
R1494 1244 1245 1.696 0.8 13.568 37
I1245 1245 0 1.28631e-03
R1495 1245 1246 1.6 0.8 12.8 37
I1246 1246 0 1.34816e-03
R1496 1246 1247 1.728 0.8 13.824 37
I1247 1247 0 1.32342e-03
R1497 1247 1248 1.744 0.8 13.952 37
I1248 1248 0 1.24921e-03
R1498 1248 1249 1.712 0.8 13.696 37
I1249 1249 0 1.33579e-03
R1499 1249 1250 1.632 0.8 13.056 37
I1250 1250 0 1.23684e-03
R1500 1250 3001 2.5 0.8 20 37
*seg: 126
R1501 3001 1251 2.5 0.8 20 37
R1502 1255 1265 6.16 0.8 49.28 37
I1251 1251 0 1.27395e-03
R1503 1251 1252 1.728 0.8 13.824 37
I1252 1252 0 1.28631e-03
R1504 1252 1253 1.632 0.8 13.056 37
I1253 1253 0 1.24921e-03
R1505 1253 1254 1.632 0.8 13.056 37
I1254 1254 0 1.26158e-03
R1506 1254 1255 1.664 0.8 13.312 37
I1255 1255 0 1.26158e-03
R1507 1255 1256 1.744 0.8 13.952 37
I1256 1256 0 1.32342e-03
R1508 1256 1257 1.616 0.8 12.928 37
I1257 1257 0 1.33579e-03
R1509 1257 1258 1.632 0.8 13.056 37
I1258 1258 0 1.34816e-03
R1510 1258 1259 1.6 0.8 12.8 37
I1259 1259 0 1.32342e-03
R1511 1259 1260 1.744 0.8 13.952 37
I1260 1260 0 1.23684e-03
R1512 1260 3001 2.5 0.8 20 37
*seg: 127
R1513 3001 1261 2.5 0.8 20 37
R1514 1265 1275 6.16 0.8 49.28 37
I1261 1261 0 1.29868e-03
R1515 1261 1262 1.712 0.8 13.696 37
I1262 1262 0 1.26158e-03
R1516 1262 1263 1.68 0.8 13.44 37
I1263 1263 0 1.29868e-03
R1517 1263 1264 1.648 0.8 13.184 37
I1264 1264 0 1.33579e-03
R1518 1264 1265 1.712 0.8 13.696 37
I1265 1265 0 1.29868e-03
R1519 1265 1266 1.696 0.8 13.568 37
I1266 1266 0 1.23684e-03
R1520 1266 1267 1.696 0.8 13.568 37
I1267 1267 0 1.27395e-03
R1521 1267 1268 1.744 0.8 13.952 37
I1268 1268 0 1.34816e-03
R1522 1268 1269 1.68 0.8 13.44 37
I1269 1269 0 1.31105e-03
R1523 1269 1270 1.664 0.8 13.312 37
I1270 1270 0 1.23684e-03
R1524 1270 3001 2.5 0.8 20 37
*seg: 128
R1525 3001 1271 2.5 0.8 20 37
R1526 1275 1285 6.16 0.8 49.28 37
I1271 1271 0 1.29868e-03
R1527 1271 1272 1.632 0.8 13.056 37
I1272 1272 0 1.26158e-03
R1528 1272 1273 1.6 0.8 12.8 37
I1273 1273 0 1.33579e-03
R1529 1273 1274 1.664 0.8 13.312 37
I1274 1274 0 1.26158e-03
R1530 1274 1275 1.728 0.8 13.824 37
I1275 1275 0 1.32342e-03
R1531 1275 1276 1.632 0.8 13.056 37
I1276 1276 0 1.31105e-03
R1532 1276 1277 1.648 0.8 13.184 37
I1277 1277 0 1.24921e-03
R1533 1277 1278 1.648 0.8 13.184 37
I1278 1278 0 1.28631e-03
R1534 1278 1279 1.712 0.8 13.696 37
I1279 1279 0 1.27395e-03
R1535 1279 1280 1.648 0.8 13.184 37
I1280 1280 0 1.23684e-03
R1536 1280 3001 2.5 0.8 20 37
*seg: 129
R1537 3001 1281 2.5 0.8 20 37
R1538 1285 1295 6.16 0.8 49.28 37
I1281 1281 0 1.31105e-03
R1539 1281 1282 1.6 0.8 12.8 37
I1282 1282 0 1.34816e-03
R1540 1282 1283 1.648 0.8 13.184 37
I1283 1283 0 1.23684e-03
R1541 1283 1284 1.632 0.8 13.056 37
I1284 1284 0 1.24921e-03
R1542 1284 1285 1.696 0.8 13.568 37
I1285 1285 0 1.34816e-03
R1543 1285 1286 1.728 0.8 13.824 37
I1286 1286 0 1.32342e-03
R1544 1286 1287 1.664 0.8 13.312 37
I1287 1287 0 1.26158e-03
R1545 1287 1288 1.616 0.8 12.928 37
I1288 1288 0 1.26158e-03
R1546 1288 1289 1.616 0.8 12.928 37
I1289 1289 0 1.23684e-03
R1547 1289 1290 1.712 0.8 13.696 37
I1290 1290 0 1.23684e-03
R1548 1290 3001 2.5 0.8 20 37
*seg: 130
R1549 3001 1291 2.5 0.8 20 37
R1550 1295 1305 6.16 0.8 49.28 37
I1291 1291 0 1.23684e-03
R1551 1291 1292 1.696 0.8 13.568 37
I1292 1292 0 1.26158e-03
R1552 1292 1293 1.744 0.8 13.952 37
I1293 1293 0 1.24921e-03
R1553 1293 1294 1.648 0.8 13.184 37
I1294 1294 0 1.27395e-03
R1554 1294 1295 1.664 0.8 13.312 37
I1295 1295 0 1.33579e-03
R1555 1295 1296 1.744 0.8 13.952 37
I1296 1296 0 1.34816e-03
R1556 1296 1297 1.6 0.8 12.8 37
I1297 1297 0 1.33579e-03
R1557 1297 1298 1.632 0.8 13.056 37
I1298 1298 0 1.32342e-03
R1558 1298 1299 1.744 0.8 13.952 37
I1299 1299 0 1.26158e-03
R1559 1299 1300 1.696 0.8 13.568 37
I1300 1300 0 1.23684e-03
R1560 1300 3001 2.5 0.8 20 37
*seg: 131
R1561 3001 1301 2.5 0.8 20 37
R1562 1305 1315 6.16 0.8 49.28 37
I1301 1301 0 1.29868e-03
R1563 1301 1302 1.632 0.8 13.056 37
I1302 1302 0 1.24921e-03
R1564 1302 1303 1.632 0.8 13.056 37
I1303 1303 0 1.27395e-03
R1565 1303 1304 1.712 0.8 13.696 37
I1304 1304 0 1.32342e-03
R1566 1304 1305 1.664 0.8 13.312 37
I1305 1305 0 1.34816e-03
R1567 1305 1306 1.664 0.8 13.312 37
I1306 1306 0 1.29868e-03
R1568 1306 1307 1.728 0.8 13.824 37
I1307 1307 0 1.23684e-03
R1569 1307 1308 1.68 0.8 13.44 37
I1308 1308 0 1.33579e-03
R1570 1308 1309 1.744 0.8 13.952 37
I1309 1309 0 1.32342e-03
R1571 1309 1310 1.68 0.8 13.44 37
I1310 1310 0 1.23684e-03
R1572 1310 3001 2.5 0.8 20 37
*seg: 132
R1573 3001 1311 2.5 0.8 20 37
R1574 1315 1325 6.16 0.8 49.28 37
I1311 1311 0 1.29868e-03
R1575 1311 1312 1.616 0.8 12.928 37
I1312 1312 0 1.33579e-03
R1576 1312 1313 1.616 0.8 12.928 37
I1313 1313 0 1.23684e-03
R1577 1313 1314 1.728 0.8 13.824 37
I1314 1314 0 1.26158e-03
R1578 1314 1315 1.648 0.8 13.184 37
I1315 1315 0 1.31105e-03
R1579 1315 1316 1.728 0.8 13.824 37
I1316 1316 0 1.24921e-03
R1580 1316 1317 1.712 0.8 13.696 37
I1317 1317 0 1.24921e-03
R1581 1317 1318 1.648 0.8 13.184 37
I1318 1318 0 1.29868e-03
R1582 1318 1319 1.664 0.8 13.312 37
I1319 1319 0 1.28631e-03
R1583 1319 1320 1.696 0.8 13.568 37
I1320 1320 0 1.23684e-03
R1584 1320 3001 2.5 0.8 20 37
*seg: 133
R1585 3001 1321 2.5 0.8 20 37
R1586 1325 1335 6.16 0.8 49.28 37
I1321 1321 0 1.26158e-03
R1587 1321 1322 1.616 0.8 12.928 37
I1322 1322 0 1.33579e-03
R1588 1322 1323 1.68 0.8 13.44 37
I1323 1323 0 1.32342e-03
R1589 1323 1324 1.616 0.8 12.928 37
I1324 1324 0 1.29868e-03
R1590 1324 1325 1.68 0.8 13.44 37
I1325 1325 0 1.24921e-03
R1591 1325 1326 1.664 0.8 13.312 37
I1326 1326 0 1.27395e-03
R1592 1326 1327 1.728 0.8 13.824 37
I1327 1327 0 1.32342e-03
R1593 1327 1328 1.648 0.8 13.184 37
I1328 1328 0 1.31105e-03
R1594 1328 1329 1.6 0.8 12.8 37
I1329 1329 0 1.27395e-03
R1595 1329 1330 1.68 0.8 13.44 37
I1330 1330 0 1.23684e-03
R1596 1330 3001 2.5 0.8 20 37
*seg: 134
R1597 3001 1331 2.5 0.8 20 37
R1598 1335 1345 6.16 0.8 49.28 37
I1331 1331 0 1.34816e-03
R1599 1331 1332 1.728 0.8 13.824 37
I1332 1332 0 1.27395e-03
R1600 1332 1333 1.648 0.8 13.184 37
I1333 1333 0 1.26158e-03
R1601 1333 1334 1.744 0.8 13.952 37
I1334 1334 0 1.28631e-03
R1602 1334 1335 1.6 0.8 12.8 37
I1335 1335 0 1.29868e-03
R1603 1335 1336 1.648 0.8 13.184 37
I1336 1336 0 1.33579e-03
R1604 1336 1337 1.68 0.8 13.44 37
I1337 1337 0 1.34816e-03
R1605 1337 1338 1.696 0.8 13.568 37
I1338 1338 0 1.34816e-03
R1606 1338 1339 1.68 0.8 13.44 37
I1339 1339 0 1.34816e-03
R1607 1339 1340 1.744 0.8 13.952 37
I1340 1340 0 1.23684e-03
R1608 1340 3001 2.5 0.8 20 37
*seg: 135
R1609 3001 1341 2.5 0.8 20 37
R1610 1345 1355 6.16 0.8 49.28 37
I1341 1341 0 1.32342e-03
R1611 1341 1342 1.648 0.8 13.184 37
I1342 1342 0 1.33579e-03
R1612 1342 1343 1.632 0.8 13.056 37
I1343 1343 0 1.33579e-03
R1613 1343 1344 1.6 0.8 12.8 37
I1344 1344 0 1.33579e-03
R1614 1344 1345 1.616 0.8 12.928 37
I1345 1345 0 1.27395e-03
R1615 1345 1346 1.696 0.8 13.568 37
I1346 1346 0 1.31105e-03
R1616 1346 1347 1.632 0.8 13.056 37
I1347 1347 0 1.27395e-03
R1617 1347 1348 1.6 0.8 12.8 37
I1348 1348 0 1.27395e-03
R1618 1348 1349 1.616 0.8 12.928 37
I1349 1349 0 1.31105e-03
R1619 1349 1350 1.616 0.8 12.928 37
I1350 1350 0 1.23684e-03
R1620 1350 3001 2.5 0.8 20 37
*seg: 136
R1621 3001 1351 2.5 0.8 20 37
R1622 1355 1365 6.16 0.8 49.28 37
I1351 1351 0 1.28631e-03
R1623 1351 1352 1.712 0.8 13.696 37
I1352 1352 0 1.28631e-03
R1624 1352 1353 1.6 0.8 12.8 37
I1353 1353 0 1.32342e-03
R1625 1353 1354 1.728 0.8 13.824 37
I1354 1354 0 1.23684e-03
R1626 1354 1355 1.616 0.8 12.928 37
I1355 1355 0 1.32342e-03
R1627 1355 1356 1.648 0.8 13.184 37
I1356 1356 0 1.29868e-03
R1628 1356 1357 1.696 0.8 13.568 37
I1357 1357 0 1.32342e-03
R1629 1357 1358 1.632 0.8 13.056 37
I1358 1358 0 1.32342e-03
R1630 1358 1359 1.664 0.8 13.312 37
I1359 1359 0 1.31105e-03
R1631 1359 1360 1.712 0.8 13.696 37
I1360 1360 0 1.23684e-03
R1632 1360 3001 2.5 0.8 20 37
*seg: 137
R1633 3001 1361 2.5 0.8 20 37
R1634 1365 1375 6.16 0.8 49.28 37
I1361 1361 0 1.29868e-03
R1635 1361 1362 1.696 0.8 13.568 37
I1362 1362 0 1.34816e-03
R1636 1362 1363 1.712 0.8 13.696 37
I1363 1363 0 1.27395e-03
R1637 1363 1364 1.6 0.8 12.8 37
I1364 1364 0 1.28631e-03
R1638 1364 1365 1.648 0.8 13.184 37
I1365 1365 0 1.32342e-03
R1639 1365 1366 1.616 0.8 12.928 37
I1366 1366 0 1.31105e-03
R1640 1366 1367 1.744 0.8 13.952 37
I1367 1367 0 1.34816e-03
R1641 1367 1368 1.632 0.8 13.056 37
I1368 1368 0 1.29868e-03
R1642 1368 1369 1.664 0.8 13.312 37
I1369 1369 0 1.23684e-03
R1643 1369 1370 1.6 0.8 12.8 37
I1370 1370 0 1.23684e-03
R1644 1370 3001 2.5 0.8 20 37
*seg: 138
R1645 3001 1371 2.5 0.8 20 37
R1646 1375 1385 6.16 0.8 49.28 37
I1371 1371 0 1.32342e-03
R1647 1371 1372 1.712 0.8 13.696 37
I1372 1372 0 1.29868e-03
R1648 1372 1373 1.632 0.8 13.056 37
I1373 1373 0 1.33579e-03
R1649 1373 1374 1.728 0.8 13.824 37
I1374 1374 0 1.29868e-03
R1650 1374 1375 1.744 0.8 13.952 37
I1375 1375 0 1.28631e-03
R1651 1375 1376 1.632 0.8 13.056 37
I1376 1376 0 1.27395e-03
R1652 1376 1377 1.712 0.8 13.696 37
I1377 1377 0 1.23684e-03
R1653 1377 1378 1.6 0.8 12.8 37
I1378 1378 0 1.28631e-03
R1654 1378 1379 1.728 0.8 13.824 37
I1379 1379 0 1.32342e-03
R1655 1379 1380 1.632 0.8 13.056 37
I1380 1380 0 1.23684e-03
R1656 1380 3001 2.5 0.8 20 37
*seg: 139
R1657 3001 1381 2.5 0.8 20 37
R1658 1385 1395 6.16 0.8 49.28 37
I1381 1381 0 1.27395e-03
R1659 1381 1382 1.728 0.8 13.824 37
I1382 1382 0 1.24921e-03
R1660 1382 1383 1.648 0.8 13.184 37
I1383 1383 0 1.32342e-03
R1661 1383 1384 1.632 0.8 13.056 37
I1384 1384 0 1.31105e-03
R1662 1384 1385 1.664 0.8 13.312 37
I1385 1385 0 1.31105e-03
R1663 1385 1386 1.68 0.8 13.44 37
I1386 1386 0 1.31105e-03
R1664 1386 1387 1.6 0.8 12.8 37
I1387 1387 0 1.28631e-03
R1665 1387 1388 1.712 0.8 13.696 37
I1388 1388 0 1.28631e-03
R1666 1388 1389 1.632 0.8 13.056 37
I1389 1389 0 1.27395e-03
R1667 1389 1390 1.68 0.8 13.44 37
I1390 1390 0 1.23684e-03
R1668 1390 3001 2.5 0.8 20 37
*seg: 140
R1669 3001 1391 2.5 0.8 20 37
R1670 1395 1405 6.16 0.8 49.28 37
I1391 1391 0 1.34816e-03
R1671 1391 1392 1.648 0.8 13.184 37
I1392 1392 0 1.34816e-03
R1672 1392 1393 1.744 0.8 13.952 37
I1393 1393 0 1.26158e-03
R1673 1393 1394 1.68 0.8 13.44 37
I1394 1394 0 1.28631e-03
R1674 1394 1395 1.632 0.8 13.056 37
I1395 1395 0 1.27395e-03
R1675 1395 1396 1.728 0.8 13.824 37
I1396 1396 0 1.27395e-03
R1676 1396 1397 1.712 0.8 13.696 37
I1397 1397 0 1.27395e-03
R1677 1397 1398 1.648 0.8 13.184 37
I1398 1398 0 1.23684e-03
R1678 1398 1399 1.6 0.8 12.8 37
I1399 1399 0 1.29868e-03
R1679 1399 1400 1.616 0.8 12.928 37
I1400 1400 0 1.23684e-03
R1680 1400 3001 2.5 0.8 20 37
*seg: 141
R1681 3001 1401 2.5 0.8 20 37
R1682 1405 1415 6.16 0.8 49.28 37
I1401 1401 0 1.24921e-03
R1683 1401 1402 1.696 0.8 13.568 37
I1402 1402 0 1.31105e-03
R1684 1402 1403 1.712 0.8 13.696 37
I1403 1403 0 1.34816e-03
R1685 1403 1404 1.616 0.8 12.928 37
I1404 1404 0 1.28631e-03
R1686 1404 1405 1.6 0.8 12.8 37
I1405 1405 0 1.27395e-03
R1687 1405 1406 1.68 0.8 13.44 37
I1406 1406 0 1.24921e-03
R1688 1406 1407 1.616 0.8 12.928 37
I1407 1407 0 1.24921e-03
R1689 1407 1408 1.68 0.8 13.44 37
I1408 1408 0 1.24921e-03
R1690 1408 1409 1.648 0.8 13.184 37
I1409 1409 0 1.29868e-03
R1691 1409 1410 1.744 0.8 13.952 37
I1410 1410 0 1.23684e-03
R1692 1410 3001 2.5 0.8 20 37
*seg: 142
R1693 3001 1411 2.5 0.8 20 37
R1694 1415 1425 6.16 0.8 49.28 37
I1411 1411 0 1.27395e-03
R1695 1411 1412 1.648 0.8 13.184 37
I1412 1412 0 1.23684e-03
R1696 1412 1413 1.68 0.8 13.44 37
I1413 1413 0 1.23684e-03
R1697 1413 1414 1.712 0.8 13.696 37
I1414 1414 0 1.29868e-03
R1698 1414 1415 1.68 0.8 13.44 37
I1415 1415 0 1.29868e-03
R1699 1415 1416 1.728 0.8 13.824 37
I1416 1416 0 1.23684e-03
R1700 1416 1417 1.696 0.8 13.568 37
I1417 1417 0 1.29868e-03
R1701 1417 1418 1.616 0.8 12.928 37
I1418 1418 0 1.34816e-03
R1702 1418 1419 1.728 0.8 13.824 37
I1419 1419 0 1.27395e-03
R1703 1419 1420 1.696 0.8 13.568 37
I1420 1420 0 1.23684e-03
R1704 1420 3001 2.5 0.8 20 37
*seg: 143
R1705 3001 1421 2.5 0.8 20 37
R1706 1425 1435 6.16 0.8 49.28 37
I1421 1421 0 1.26158e-03
R1707 1421 1422 1.664 0.8 13.312 37
I1422 1422 0 1.27395e-03
R1708 1422 1423 1.728 0.8 13.824 37
I1423 1423 0 1.29868e-03
R1709 1423 1424 1.6 0.8 12.8 37
I1424 1424 0 1.28631e-03
R1710 1424 1425 1.696 0.8 13.568 37
I1425 1425 0 1.23684e-03
R1711 1425 1426 1.664 0.8 13.312 37
I1426 1426 0 1.26158e-03
R1712 1426 1427 1.632 0.8 13.056 37
I1427 1427 0 1.29868e-03
R1713 1427 1428 1.648 0.8 13.184 37
I1428 1428 0 1.27395e-03
R1714 1428 1429 1.648 0.8 13.184 37
I1429 1429 0 1.33579e-03
R1715 1429 1430 1.664 0.8 13.312 37
I1430 1430 0 1.23684e-03
R1716 1430 3001 2.5 0.8 20 37
*seg: 144
R1717 3001 1431 2.5 0.8 20 37
R1718 1435 1445 6.16 0.8 49.28 37
I1431 1431 0 1.32342e-03
R1719 1431 1432 1.68 0.8 13.44 37
I1432 1432 0 1.28631e-03
R1720 1432 1433 1.728 0.8 13.824 37
I1433 1433 0 1.34816e-03
R1721 1433 1434 1.744 0.8 13.952 37
I1434 1434 0 1.28631e-03
R1722 1434 1435 1.648 0.8 13.184 37
I1435 1435 0 1.24921e-03
R1723 1435 1436 1.664 0.8 13.312 37
I1436 1436 0 1.32342e-03
R1724 1436 1437 1.648 0.8 13.184 37
I1437 1437 0 1.33579e-03
R1725 1437 1438 1.632 0.8 13.056 37
I1438 1438 0 1.24921e-03
R1726 1438 1439 1.68 0.8 13.44 37
I1439 1439 0 1.27395e-03
R1727 1439 1440 1.6 0.8 12.8 37
I1440 1440 0 1.23684e-03
R1728 1440 3001 2.5 0.8 20 37
*seg: 145
R1729 3001 1441 2.5 0.8 20 37
R1730 1445 1455 6.16 0.8 49.28 37
I1441 1441 0 1.33579e-03
R1731 1441 1442 1.648 0.8 13.184 37
I1442 1442 0 1.31105e-03
R1732 1442 1443 1.68 0.8 13.44 37
I1443 1443 0 1.31105e-03
R1733 1443 1444 1.68 0.8 13.44 37
I1444 1444 0 1.26158e-03
R1734 1444 1445 1.664 0.8 13.312 37
I1445 1445 0 1.26158e-03
R1735 1445 1446 1.6 0.8 12.8 37
I1446 1446 0 1.33579e-03
R1736 1446 1447 1.712 0.8 13.696 37
I1447 1447 0 1.23684e-03
R1737 1447 1448 1.744 0.8 13.952 37
I1448 1448 0 1.32342e-03
R1738 1448 1449 1.728 0.8 13.824 37
I1449 1449 0 1.23684e-03
R1739 1449 1450 1.744 0.8 13.952 37
I1450 1450 0 1.23684e-03
R1740 1450 3001 2.5 0.8 20 37
*seg: 146
R1741 3001 1451 2.5 0.8 20 37
R1742 1455 1465 6.16 0.8 49.28 37
I1451 1451 0 1.23684e-03
R1743 1451 1452 1.68 0.8 13.44 37
I1452 1452 0 1.31105e-03
R1744 1452 1453 1.728 0.8 13.824 37
I1453 1453 0 1.33579e-03
R1745 1453 1454 1.648 0.8 13.184 37
I1454 1454 0 1.26158e-03
R1746 1454 1455 1.664 0.8 13.312 37
I1455 1455 0 1.24921e-03
R1747 1455 1456 1.712 0.8 13.696 37
I1456 1456 0 1.34816e-03
R1748 1456 1457 1.712 0.8 13.696 37
I1457 1457 0 1.34816e-03
R1749 1457 1458 1.728 0.8 13.824 37
I1458 1458 0 1.32342e-03
R1750 1458 1459 1.664 0.8 13.312 37
I1459 1459 0 1.26158e-03
R1751 1459 1460 1.696 0.8 13.568 37
I1460 1460 0 1.23684e-03
R1752 1460 3001 2.5 0.8 20 37
*seg: 147
R1753 3001 1461 2.5 0.8 20 37
R1754 1465 1475 6.16 0.8 49.28 37
I1461 1461 0 1.34816e-03
R1755 1461 1462 1.632 0.8 13.056 37
I1462 1462 0 1.31105e-03
R1756 1462 1463 1.712 0.8 13.696 37
I1463 1463 0 1.27395e-03
R1757 1463 1464 1.712 0.8 13.696 37
I1464 1464 0 1.28631e-03
R1758 1464 1465 1.68 0.8 13.44 37
I1465 1465 0 1.31105e-03
R1759 1465 1466 1.712 0.8 13.696 37
I1466 1466 0 1.32342e-03
R1760 1466 1467 1.728 0.8 13.824 37
I1467 1467 0 1.33579e-03
R1761 1467 1468 1.68 0.8 13.44 37
I1468 1468 0 1.34816e-03
R1762 1468 1469 1.728 0.8 13.824 37
I1469 1469 0 1.23684e-03
R1763 1469 1470 1.696 0.8 13.568 37
I1470 1470 0 1.23684e-03
R1764 1470 3001 2.5 0.8 20 37
*seg: 148
R1765 3001 1471 2.5 0.8 20 37
R1766 1475 1485 6.16 0.8 49.28 37
I1471 1471 0 1.32342e-03
R1767 1471 1472 1.664 0.8 13.312 37
I1472 1472 0 1.32342e-03
R1768 1472 1473 1.712 0.8 13.696 37
I1473 1473 0 1.23684e-03
R1769 1473 1474 1.632 0.8 13.056 37
I1474 1474 0 1.32342e-03
R1770 1474 1475 1.648 0.8 13.184 37
I1475 1475 0 1.31105e-03
R1771 1475 1476 1.664 0.8 13.312 37
I1476 1476 0 1.31105e-03
R1772 1476 1477 1.632 0.8 13.056 37
I1477 1477 0 1.31105e-03
R1773 1477 1478 1.728 0.8 13.824 37
I1478 1478 0 1.24921e-03
R1774 1478 1479 1.712 0.8 13.696 37
I1479 1479 0 1.29868e-03
R1775 1479 1480 1.712 0.8 13.696 37
I1480 1480 0 1.23684e-03
R1776 1480 3001 2.5 0.8 20 37
*seg: 149
R1777 3001 1481 2.5 0.8 20 37
R1778 1485 1495 6.16 0.8 49.28 37
I1481 1481 0 1.31105e-03
R1779 1481 1482 1.712 0.8 13.696 37
I1482 1482 0 1.34816e-03
R1780 1482 1483 1.648 0.8 13.184 37
I1483 1483 0 1.32342e-03
R1781 1483 1484 1.664 0.8 13.312 37
I1484 1484 0 1.34816e-03
R1782 1484 1485 1.616 0.8 12.928 37
I1485 1485 0 1.28631e-03
R1783 1485 1486 1.6 0.8 12.8 37
I1486 1486 0 1.32342e-03
R1784 1486 1487 1.616 0.8 12.928 37
I1487 1487 0 1.24921e-03
R1785 1487 1488 1.728 0.8 13.824 37
I1488 1488 0 1.31105e-03
R1786 1488 1489 1.744 0.8 13.952 37
I1489 1489 0 1.33579e-03
R1787 1489 1490 1.68 0.8 13.44 37
I1490 1490 0 1.23684e-03
R1788 1490 3001 2.5 0.8 20 37
*seg: 150
R1789 3001 1491 2.5 0.8 20 37
R1790 1495 1505 6.16 0.8 49.28 37
I1491 1491 0 1.23684e-03
R1791 1491 1492 1.616 0.8 12.928 37
I1492 1492 0 1.32342e-03
R1792 1492 1493 1.632 0.8 13.056 37
I1493 1493 0 1.33579e-03
R1793 1493 1494 1.632 0.8 13.056 37
I1494 1494 0 1.26158e-03
R1794 1494 1495 1.616 0.8 12.928 37
I1495 1495 0 1.24921e-03
R1795 1495 1496 1.712 0.8 13.696 37
I1496 1496 0 1.27395e-03
R1796 1496 1497 1.648 0.8 13.184 37
I1497 1497 0 1.28631e-03
R1797 1497 1498 1.664 0.8 13.312 37
I1498 1498 0 1.27395e-03
R1798 1498 1499 1.712 0.8 13.696 37
I1499 1499 0 1.34816e-03
R1799 1499 1500 1.616 0.8 12.928 37
I1500 1500 0 1.23684e-03
R1800 1500 3001 2.5 0.8 20 37
*seg: 151
R1801 3001 1501 2.5 0.8 20 37
R1802 1505 1515 6.16 0.8 49.28 37
I1501 1501 0 1.29868e-03
R1803 1501 1502 1.616 0.8 12.928 37
I1502 1502 0 1.31105e-03
R1804 1502 1503 1.648 0.8 13.184 37
I1503 1503 0 1.32342e-03
R1805 1503 1504 1.6 0.8 12.8 37
I1504 1504 0 1.28631e-03
R1806 1504 1505 1.728 0.8 13.824 37
I1505 1505 0 1.24921e-03
R1807 1505 1506 1.728 0.8 13.824 37
I1506 1506 0 1.23684e-03
R1808 1506 1507 1.68 0.8 13.44 37
I1507 1507 0 1.27395e-03
R1809 1507 1508 1.68 0.8 13.44 37
I1508 1508 0 1.31105e-03
R1810 1508 1509 1.712 0.8 13.696 37
I1509 1509 0 1.24921e-03
R1811 1509 1510 1.744 0.8 13.952 37
I1510 1510 0 1.23684e-03
R1812 1510 3001 2.5 0.8 20 37
*seg: 152
R1813 3001 1511 2.5 0.8 20 37
R1814 1515 1525 6.16 0.8 49.28 37
I1511 1511 0 1.31105e-03
R1815 1511 1512 1.664 0.8 13.312 37
I1512 1512 0 1.34816e-03
R1816 1512 1513 1.68 0.8 13.44 37
I1513 1513 0 1.23684e-03
R1817 1513 1514 1.6 0.8 12.8 37
I1514 1514 0 1.23684e-03
R1818 1514 1515 1.648 0.8 13.184 37
I1515 1515 0 1.27395e-03
R1819 1515 1516 1.664 0.8 13.312 37
I1516 1516 0 1.31105e-03
R1820 1516 1517 1.6 0.8 12.8 37
I1517 1517 0 1.34816e-03
R1821 1517 1518 1.712 0.8 13.696 37
I1518 1518 0 1.26158e-03
R1822 1518 1519 1.696 0.8 13.568 37
I1519 1519 0 1.28631e-03
R1823 1519 1520 1.6 0.8 12.8 37
I1520 1520 0 1.23684e-03
R1824 1520 3001 2.5 0.8 20 37
*seg: 153
R1825 3001 1521 2.5 0.8 20 37
R1826 1525 1535 6.16 0.8 49.28 37
I1521 1521 0 1.33579e-03
R1827 1521 1522 1.6 0.8 12.8 37
I1522 1522 0 1.26158e-03
R1828 1522 1523 1.696 0.8 13.568 37
I1523 1523 0 1.24921e-03
R1829 1523 1524 1.696 0.8 13.568 37
I1524 1524 0 1.32342e-03
R1830 1524 1525 1.648 0.8 13.184 37
I1525 1525 0 1.34816e-03
R1831 1525 1526 1.632 0.8 13.056 37
I1526 1526 0 1.26158e-03
R1832 1526 1527 1.696 0.8 13.568 37
I1527 1527 0 1.31105e-03
R1833 1527 1528 1.712 0.8 13.696 37
I1528 1528 0 1.32342e-03
R1834 1528 1529 1.68 0.8 13.44 37
I1529 1529 0 1.32342e-03
R1835 1529 1530 1.744 0.8 13.952 37
I1530 1530 0 1.23684e-03
R1836 1530 3001 2.5 0.8 20 37
*seg: 154
R1837 3001 1531 2.5 0.8 20 37
R1838 1535 1545 6.16 0.8 49.28 37
I1531 1531 0 1.34816e-03
R1839 1531 1532 1.632 0.8 13.056 37
I1532 1532 0 1.34816e-03
R1840 1532 1533 1.632 0.8 13.056 37
I1533 1533 0 1.29868e-03
R1841 1533 1534 1.744 0.8 13.952 37
I1534 1534 0 1.23684e-03
R1842 1534 1535 1.616 0.8 12.928 37
I1535 1535 0 1.26158e-03
R1843 1535 1536 1.648 0.8 13.184 37
I1536 1536 0 1.34816e-03
R1844 1536 1537 1.696 0.8 13.568 37
I1537 1537 0 1.28631e-03
R1845 1537 1538 1.6 0.8 12.8 37
I1538 1538 0 1.33579e-03
R1846 1538 1539 1.664 0.8 13.312 37
I1539 1539 0 1.24921e-03
R1847 1539 1540 1.616 0.8 12.928 37
I1540 1540 0 1.23684e-03
R1848 1540 3001 2.5 0.8 20 37
*seg: 155
R1849 3001 1541 2.5 0.8 20 37
R1850 1545 1555 6.16 0.8 49.28 37
I1541 1541 0 1.27395e-03
R1851 1541 1542 1.744 0.8 13.952 37
I1542 1542 0 1.28631e-03
R1852 1542 1543 1.68 0.8 13.44 37
I1543 1543 0 1.26158e-03
R1853 1543 1544 1.728 0.8 13.824 37
I1544 1544 0 1.29868e-03
R1854 1544 1545 1.648 0.8 13.184 37
I1545 1545 0 1.33579e-03
R1855 1545 1546 1.696 0.8 13.568 37
I1546 1546 0 1.24921e-03
R1856 1546 1547 1.632 0.8 13.056 37
I1547 1547 0 1.24921e-03
R1857 1547 1548 1.664 0.8 13.312 37
I1548 1548 0 1.29868e-03
R1858 1548 1549 1.648 0.8 13.184 37
I1549 1549 0 1.29868e-03
R1859 1549 1550 1.648 0.8 13.184 37
I1550 1550 0 1.23684e-03
R1860 1550 3001 2.5 0.8 20 37
*seg: 156
R1861 3001 1551 2.5 0.8 20 37
R1862 1555 1565 6.16 0.8 49.28 37
I1551 1551 0 1.24921e-03
R1863 1551 1552 1.728 0.8 13.824 37
I1552 1552 0 1.34816e-03
R1864 1552 1553 1.664 0.8 13.312 37
I1553 1553 0 1.29868e-03
R1865 1553 1554 1.728 0.8 13.824 37
I1554 1554 0 1.23684e-03
R1866 1554 1555 1.744 0.8 13.952 37
I1555 1555 0 1.24921e-03
R1867 1555 1556 1.6 0.8 12.8 37
I1556 1556 0 1.27395e-03
R1868 1556 1557 1.712 0.8 13.696 37
I1557 1557 0 1.23684e-03
R1869 1557 1558 1.68 0.8 13.44 37
I1558 1558 0 1.29868e-03
R1870 1558 1559 1.648 0.8 13.184 37
I1559 1559 0 1.33579e-03
R1871 1559 1560 1.664 0.8 13.312 37
I1560 1560 0 1.23684e-03
R1872 1560 3001 2.5 0.8 20 37
*seg: 157
R1873 3001 1561 2.5 0.8 20 37
R1874 1565 1575 6.16 0.8 49.28 37
I1561 1561 0 1.31105e-03
R1875 1561 1562 1.744 0.8 13.952 37
I1562 1562 0 1.28631e-03
R1876 1562 1563 1.664 0.8 13.312 37
I1563 1563 0 1.34816e-03
R1877 1563 1564 1.616 0.8 12.928 37
I1564 1564 0 1.27395e-03
R1878 1564 1565 1.648 0.8 13.184 37
I1565 1565 0 1.34816e-03
R1879 1565 1566 1.696 0.8 13.568 37
I1566 1566 0 1.31105e-03
R1880 1566 1567 1.68 0.8 13.44 37
I1567 1567 0 1.27395e-03
R1881 1567 1568 1.696 0.8 13.568 37
I1568 1568 0 1.29868e-03
R1882 1568 1569 1.712 0.8 13.696 37
I1569 1569 0 1.32342e-03
R1883 1569 1570 1.6 0.8 12.8 37
I1570 1570 0 1.23684e-03
R1884 1570 3001 2.5 0.8 20 37
*seg: 158
R1885 3001 1571 2.5 0.8 20 37
R1886 1575 1585 6.16 0.8 49.28 37
I1571 1571 0 1.28631e-03
R1887 1571 1572 1.728 0.8 13.824 37
I1572 1572 0 1.24921e-03
R1888 1572 1573 1.712 0.8 13.696 37
I1573 1573 0 1.29868e-03
R1889 1573 1574 1.632 0.8 13.056 37
I1574 1574 0 1.29868e-03
R1890 1574 1575 1.632 0.8 13.056 37
I1575 1575 0 1.32342e-03
R1891 1575 1576 1.6 0.8 12.8 37
I1576 1576 0 1.26158e-03
R1892 1576 1577 1.712 0.8 13.696 37
I1577 1577 0 1.29868e-03
R1893 1577 1578 1.696 0.8 13.568 37
I1578 1578 0 1.23684e-03
R1894 1578 1579 1.68 0.8 13.44 37
I1579 1579 0 1.31105e-03
R1895 1579 1580 1.728 0.8 13.824 37
I1580 1580 0 1.23684e-03
R1896 1580 3001 2.5 0.8 20 37
*seg: 159
R1897 3001 1581 2.5 0.8 20 37
R1898 1585 1595 6.16 0.8 49.28 37
I1581 1581 0 1.23684e-03
R1899 1581 1582 1.664 0.8 13.312 37
I1582 1582 0 1.26158e-03
R1900 1582 1583 1.744 0.8 13.952 37
I1583 1583 0 1.27395e-03
R1901 1583 1584 1.744 0.8 13.952 37
I1584 1584 0 1.32342e-03
R1902 1584 1585 1.696 0.8 13.568 37
I1585 1585 0 1.23684e-03
R1903 1585 1586 1.648 0.8 13.184 37
I1586 1586 0 1.28631e-03
R1904 1586 1587 1.68 0.8 13.44 37
I1587 1587 0 1.27395e-03
R1905 1587 1588 1.664 0.8 13.312 37
I1588 1588 0 1.26158e-03
R1906 1588 1589 1.6 0.8 12.8 37
I1589 1589 0 1.27395e-03
R1907 1589 1590 1.648 0.8 13.184 37
I1590 1590 0 1.23684e-03
R1908 1590 3001 2.5 0.8 20 37
*seg: 160
R1909 3001 1591 2.5 0.8 20 37
R1910 1595 1605 6.16 0.8 49.28 37
I1591 1591 0 1.33579e-03
R1911 1591 1592 1.696 0.8 13.568 37
I1592 1592 0 1.28631e-03
R1912 1592 1593 1.664 0.8 13.312 37
I1593 1593 0 1.31105e-03
R1913 1593 1594 1.632 0.8 13.056 37
I1594 1594 0 1.33579e-03
R1914 1594 1595 1.6 0.8 12.8 37
I1595 1595 0 1.33579e-03
R1915 1595 1596 1.712 0.8 13.696 37
I1596 1596 0 1.23684e-03
R1916 1596 1597 1.696 0.8 13.568 37
I1597 1597 0 1.32342e-03
R1917 1597 1598 1.68 0.8 13.44 37
I1598 1598 0 1.29868e-03
R1918 1598 1599 1.6 0.8 12.8 37
I1599 1599 0 1.28631e-03
R1919 1599 1600 1.728 0.8 13.824 37
I1600 1600 0 1.23684e-03
R1920 1600 3001 2.5 0.8 20 37
*seg: 161
R1921 3001 1601 2.5 0.8 20 37
R1922 1605 1615 6.16 0.8 49.28 37
I1601 1601 0 1.31105e-03
R1923 1601 1602 1.696 0.8 13.568 37
I1602 1602 0 1.34816e-03
R1924 1602 1603 1.728 0.8 13.824 37
I1603 1603 0 1.27395e-03
R1925 1603 1604 1.744 0.8 13.952 37
I1604 1604 0 1.26158e-03
R1926 1604 1605 1.712 0.8 13.696 37
I1605 1605 0 1.26158e-03
R1927 1605 1606 1.648 0.8 13.184 37
I1606 1606 0 1.27395e-03
R1928 1606 1607 1.68 0.8 13.44 37
I1607 1607 0 1.24921e-03
R1929 1607 1608 1.648 0.8 13.184 37
I1608 1608 0 1.27395e-03
R1930 1608 1609 1.664 0.8 13.312 37
I1609 1609 0 1.26158e-03
R1931 1609 1610 1.696 0.8 13.568 37
I1610 1610 0 1.23684e-03
R1932 1610 3001 2.5 0.8 20 37
*seg: 162
R1933 3001 1611 2.5 0.8 20 37
R1934 1615 1625 6.16 0.8 49.28 37
I1611 1611 0 1.27395e-03
R1935 1611 1612 1.728 0.8 13.824 37
I1612 1612 0 1.24921e-03
R1936 1612 1613 1.728 0.8 13.824 37
I1613 1613 0 1.31105e-03
R1937 1613 1614 1.68 0.8 13.44 37
I1614 1614 0 1.32342e-03
R1938 1614 1615 1.744 0.8 13.952 37
I1615 1615 0 1.29868e-03
R1939 1615 1616 1.664 0.8 13.312 37
I1616 1616 0 1.28631e-03
R1940 1616 1617 1.712 0.8 13.696 37
I1617 1617 0 1.31105e-03
R1941 1617 1618 1.6 0.8 12.8 37
I1618 1618 0 1.23684e-03
R1942 1618 1619 1.616 0.8 12.928 37
I1619 1619 0 1.28631e-03
R1943 1619 1620 1.696 0.8 13.568 37
I1620 1620 0 1.23684e-03
R1944 1620 3001 2.5 0.8 20 37
*seg: 163
R1945 3001 1621 2.5 0.8 20 37
R1946 1625 1635 6.16 0.8 49.28 37
I1621 1621 0 1.34816e-03
R1947 1621 1622 1.632 0.8 13.056 37
I1622 1622 0 1.28631e-03
R1948 1622 1623 1.712 0.8 13.696 37
I1623 1623 0 1.33579e-03
R1949 1623 1624 1.632 0.8 13.056 37
I1624 1624 0 1.24921e-03
R1950 1624 1625 1.648 0.8 13.184 37
I1625 1625 0 1.27395e-03
R1951 1625 1626 1.6 0.8 12.8 37
I1626 1626 0 1.26158e-03
R1952 1626 1627 1.728 0.8 13.824 37
I1627 1627 0 1.29868e-03
R1953 1627 1628 1.616 0.8 12.928 37
I1628 1628 0 1.32342e-03
R1954 1628 1629 1.6 0.8 12.8 37
I1629 1629 0 1.33579e-03
R1955 1629 1630 1.616 0.8 12.928 37
I1630 1630 0 1.23684e-03
R1956 1630 3001 2.5 0.8 20 37
*seg: 164
R1957 3001 1631 2.5 0.8 20 37
R1958 1635 1645 6.16 0.8 49.28 37
I1631 1631 0 1.27395e-03
R1959 1631 1632 1.664 0.8 13.312 37
I1632 1632 0 1.29868e-03
R1960 1632 1633 1.6 0.8 12.8 37
I1633 1633 0 1.27395e-03
R1961 1633 1634 1.632 0.8 13.056 37
I1634 1634 0 1.26158e-03
R1962 1634 1635 1.664 0.8 13.312 37
I1635 1635 0 1.28631e-03
R1963 1635 1636 1.648 0.8 13.184 37
I1636 1636 0 1.34816e-03
R1964 1636 1637 1.616 0.8 12.928 37
I1637 1637 0 1.34816e-03
R1965 1637 1638 1.632 0.8 13.056 37
I1638 1638 0 1.33579e-03
R1966 1638 1639 1.712 0.8 13.696 37
I1639 1639 0 1.33579e-03
R1967 1639 1640 1.616 0.8 12.928 37
I1640 1640 0 1.23684e-03
R1968 1640 3001 2.5 0.8 20 37
*seg: 165
R1969 3001 1641 2.5 0.8 20 37
R1970 1645 1655 6.16 0.8 49.28 37
I1641 1641 0 1.24921e-03
R1971 1641 1642 1.664 0.8 13.312 37
I1642 1642 0 1.33579e-03
R1972 1642 1643 1.664 0.8 13.312 37
I1643 1643 0 1.24921e-03
R1973 1643 1644 1.728 0.8 13.824 37
I1644 1644 0 1.29868e-03
R1974 1644 1645 1.6 0.8 12.8 37
I1645 1645 0 1.27395e-03
R1975 1645 1646 1.728 0.8 13.824 37
I1646 1646 0 1.28631e-03
R1976 1646 1647 1.616 0.8 12.928 37
I1647 1647 0 1.29868e-03
R1977 1647 1648 1.696 0.8 13.568 37
I1648 1648 0 1.28631e-03
R1978 1648 1649 1.696 0.8 13.568 37
I1649 1649 0 1.23684e-03
R1979 1649 1650 1.664 0.8 13.312 37
I1650 1650 0 1.23684e-03
R1980 1650 3001 2.5 0.8 20 37
*seg: 166
R1981 3001 1651 2.5 0.8 20 37
R1982 1655 1665 6.16 0.8 49.28 37
I1651 1651 0 1.33579e-03
R1983 1651 1652 1.664 0.8 13.312 37
I1652 1652 0 1.24921e-03
R1984 1652 1653 1.6 0.8 12.8 37
I1653 1653 0 1.29868e-03
R1985 1653 1654 1.632 0.8 13.056 37
I1654 1654 0 1.33579e-03
R1986 1654 1655 1.68 0.8 13.44 37
I1655 1655 0 1.23684e-03
R1987 1655 1656 1.6 0.8 12.8 37
I1656 1656 0 1.31105e-03
R1988 1656 1657 1.68 0.8 13.44 37
I1657 1657 0 1.29868e-03
R1989 1657 1658 1.696 0.8 13.568 37
I1658 1658 0 1.33579e-03
R1990 1658 1659 1.632 0.8 13.056 37
I1659 1659 0 1.34816e-03
R1991 1659 1660 1.632 0.8 13.056 37
I1660 1660 0 1.23684e-03
R1992 1660 3001 2.5 0.8 20 37
*seg: 167
R1993 3001 1661 2.5 0.8 20 37
R1994 1665 1675 6.16 0.8 49.28 37
I1661 1661 0 1.27395e-03
R1995 1661 1662 1.6 0.8 12.8 37
I1662 1662 0 1.28631e-03
R1996 1662 1663 1.664 0.8 13.312 37
I1663 1663 0 1.27395e-03
R1997 1663 1664 1.712 0.8 13.696 37
I1664 1664 0 1.33579e-03
R1998 1664 1665 1.712 0.8 13.696 37
I1665 1665 0 1.23684e-03
R1999 1665 1666 1.648 0.8 13.184 37
I1666 1666 0 1.26158e-03
R2000 1666 1667 1.744 0.8 13.952 37
I1667 1667 0 1.27395e-03
R2001 1667 1668 1.68 0.8 13.44 37
I1668 1668 0 1.32342e-03
R2002 1668 1669 1.648 0.8 13.184 37
I1669 1669 0 1.31105e-03
R2003 1669 1670 1.744 0.8 13.952 37
I1670 1670 0 1.23684e-03
R2004 1670 3001 2.5 0.8 20 37
*seg: 168
R2005 3001 1671 2.5 0.8 20 37
R2006 1675 1685 6.16 0.8 49.28 37
I1671 1671 0 1.28631e-03
R2007 1671 1672 1.68 0.8 13.44 37
I1672 1672 0 1.24921e-03
R2008 1672 1673 1.696 0.8 13.568 37
I1673 1673 0 1.28631e-03
R2009 1673 1674 1.632 0.8 13.056 37
I1674 1674 0 1.28631e-03
R2010 1674 1675 1.648 0.8 13.184 37
I1675 1675 0 1.26158e-03
R2011 1675 1676 1.6 0.8 12.8 37
I1676 1676 0 1.32342e-03
R2012 1676 1677 1.648 0.8 13.184 37
I1677 1677 0 1.31105e-03
R2013 1677 1678 1.744 0.8 13.952 37
I1678 1678 0 1.32342e-03
R2014 1678 1679 1.632 0.8 13.056 37
I1679 1679 0 1.33579e-03
R2015 1679 1680 1.712 0.8 13.696 37
I1680 1680 0 1.23684e-03
R2016 1680 3001 2.5 0.8 20 37
*seg: 169
R2017 3001 1681 2.5 0.8 20 37
R2018 1685 1695 6.16 0.8 49.28 37
I1681 1681 0 1.33579e-03
R2019 1681 1682 1.648 0.8 13.184 37
I1682 1682 0 1.24921e-03
R2020 1682 1683 1.712 0.8 13.696 37
I1683 1683 0 1.31105e-03
R2021 1683 1684 1.712 0.8 13.696 37
I1684 1684 0 1.29868e-03
R2022 1684 1685 1.664 0.8 13.312 37
I1685 1685 0 1.26158e-03
R2023 1685 1686 1.648 0.8 13.184 37
I1686 1686 0 1.28631e-03
R2024 1686 1687 1.616 0.8 12.928 37
I1687 1687 0 1.34816e-03
R2025 1687 1688 1.728 0.8 13.824 37
I1688 1688 0 1.32342e-03
R2026 1688 1689 1.616 0.8 12.928 37
I1689 1689 0 1.34816e-03
R2027 1689 1690 1.744 0.8 13.952 37
I1690 1690 0 1.23684e-03
R2028 1690 3001 2.5 0.8 20 37
*seg: 170
R2029 3001 1691 2.5 0.8 20 37
R2030 1695 1705 6.16 0.8 49.28 37
I1691 1691 0 1.28631e-03
R2031 1691 1692 1.632 0.8 13.056 37
I1692 1692 0 1.26158e-03
R2032 1692 1693 1.664 0.8 13.312 37
I1693 1693 0 1.27395e-03
R2033 1693 1694 1.6 0.8 12.8 37
I1694 1694 0 1.31105e-03
R2034 1694 1695 1.6 0.8 12.8 37
I1695 1695 0 1.27395e-03
R2035 1695 1696 1.696 0.8 13.568 37
I1696 1696 0 1.34816e-03
R2036 1696 1697 1.728 0.8 13.824 37
I1697 1697 0 1.33579e-03
R2037 1697 1698 1.712 0.8 13.696 37
I1698 1698 0 1.31105e-03
R2038 1698 1699 1.664 0.8 13.312 37
I1699 1699 0 1.26158e-03
R2039 1699 1700 1.616 0.8 12.928 37
I1700 1700 0 1.23684e-03
R2040 1700 3001 2.5 0.8 20 37
*seg: 171
R2041 3001 1701 2.5 0.8 20 37
R2042 1705 1715 6.16 0.8 49.28 37
I1701 1701 0 1.29868e-03
R2043 1701 1702 1.616 0.8 12.928 37
I1702 1702 0 1.26158e-03
R2044 1702 1703 1.616 0.8 12.928 37
I1703 1703 0 1.27395e-03
R2045 1703 1704 1.648 0.8 13.184 37
I1704 1704 0 1.26158e-03
R2046 1704 1705 1.616 0.8 12.928 37
I1705 1705 0 1.23684e-03
R2047 1705 1706 1.744 0.8 13.952 37
I1706 1706 0 1.34816e-03
R2048 1706 1707 1.728 0.8 13.824 37
I1707 1707 0 1.27395e-03
R2049 1707 1708 1.664 0.8 13.312 37
I1708 1708 0 1.28631e-03
R2050 1708 1709 1.728 0.8 13.824 37
I1709 1709 0 1.33579e-03
R2051 1709 1710 1.632 0.8 13.056 37
I1710 1710 0 1.23684e-03
R2052 1710 3001 2.5 0.8 20 37
*seg: 172
R2053 3001 1711 2.5 0.8 20 37
R2054 1715 1725 6.16 0.8 49.28 37
I1711 1711 0 1.24921e-03
R2055 1711 1712 1.696 0.8 13.568 37
I1712 1712 0 1.32342e-03
R2056 1712 1713 1.648 0.8 13.184 37
I1713 1713 0 1.34816e-03
R2057 1713 1714 1.616 0.8 12.928 37
I1714 1714 0 1.29868e-03
R2058 1714 1715 1.6 0.8 12.8 37
I1715 1715 0 1.31105e-03
R2059 1715 1716 1.696 0.8 13.568 37
I1716 1716 0 1.29868e-03
R2060 1716 1717 1.6 0.8 12.8 37
I1717 1717 0 1.33579e-03
R2061 1717 1718 1.648 0.8 13.184 37
I1718 1718 0 1.28631e-03
R2062 1718 1719 1.6 0.8 12.8 37
I1719 1719 0 1.24921e-03
R2063 1719 1720 1.68 0.8 13.44 37
I1720 1720 0 1.23684e-03
R2064 1720 3001 2.5 0.8 20 37
*seg: 173
R2065 3001 1721 2.5 0.8 20 37
R2066 1725 1735 6.16 0.8 49.28 37
I1721 1721 0 1.34816e-03
R2067 1721 1722 1.696 0.8 13.568 37
I1722 1722 0 1.24921e-03
R2068 1722 1723 1.616 0.8 12.928 37
I1723 1723 0 1.31105e-03
R2069 1723 1724 1.616 0.8 12.928 37
I1724 1724 0 1.28631e-03
R2070 1724 1725 1.712 0.8 13.696 37
I1725 1725 0 1.31105e-03
R2071 1725 1726 1.728 0.8 13.824 37
I1726 1726 0 1.24921e-03
R2072 1726 1727 1.728 0.8 13.824 37
I1727 1727 0 1.27395e-03
R2073 1727 1728 1.664 0.8 13.312 37
I1728 1728 0 1.32342e-03
R2074 1728 1729 1.712 0.8 13.696 37
I1729 1729 0 1.32342e-03
R2075 1729 1730 1.648 0.8 13.184 37
I1730 1730 0 1.23684e-03
R2076 1730 3001 2.5 0.8 20 37
*seg: 174
R2077 3001 1731 2.5 0.8 20 37
R2078 1735 1745 6.16 0.8 49.28 37
I1731 1731 0 1.34816e-03
R2079 1731 1732 1.6 0.8 12.8 37
I1732 1732 0 1.31105e-03
R2080 1732 1733 1.728 0.8 13.824 37
I1733 1733 0 1.33579e-03
R2081 1733 1734 1.712 0.8 13.696 37
I1734 1734 0 1.26158e-03
R2082 1734 1735 1.6 0.8 12.8 37
I1735 1735 0 1.33579e-03
R2083 1735 1736 1.6 0.8 12.8 37
I1736 1736 0 1.34816e-03
R2084 1736 1737 1.68 0.8 13.44 37
I1737 1737 0 1.27395e-03
R2085 1737 1738 1.68 0.8 13.44 37
I1738 1738 0 1.23684e-03
R2086 1738 1739 1.696 0.8 13.568 37
I1739 1739 0 1.33579e-03
R2087 1739 1740 1.68 0.8 13.44 37
I1740 1740 0 1.23684e-03
R2088 1740 3001 2.5 0.8 20 37
*seg: 175
R2089 3001 1741 2.5 0.8 20 37
R2090 1745 1755 6.16 0.8 49.28 37
I1741 1741 0 1.27395e-03
R2091 1741 1742 1.664 0.8 13.312 37
I1742 1742 0 1.32342e-03
R2092 1742 1743 1.696 0.8 13.568 37
I1743 1743 0 1.28631e-03
R2093 1743 1744 1.648 0.8 13.184 37
I1744 1744 0 1.33579e-03
R2094 1744 1745 1.696 0.8 13.568 37
I1745 1745 0 1.27395e-03
R2095 1745 1746 1.632 0.8 13.056 37
I1746 1746 0 1.23684e-03
R2096 1746 1747 1.712 0.8 13.696 37
I1747 1747 0 1.32342e-03
R2097 1747 1748 1.616 0.8 12.928 37
I1748 1748 0 1.27395e-03
R2098 1748 1749 1.712 0.8 13.696 37
I1749 1749 0 1.34816e-03
R2099 1749 1750 1.744 0.8 13.952 37
I1750 1750 0 1.23684e-03
R2100 1750 3001 2.5 0.8 20 37
*seg: 176
R2101 3001 1751 2.5 0.8 20 37
R2102 1755 1765 6.16 0.8 49.28 37
I1751 1751 0 1.28631e-03
R2103 1751 1752 1.696 0.8 13.568 37
I1752 1752 0 1.29868e-03
R2104 1752 1753 1.712 0.8 13.696 37
I1753 1753 0 1.31105e-03
R2105 1753 1754 1.632 0.8 13.056 37
I1754 1754 0 1.23684e-03
R2106 1754 1755 1.648 0.8 13.184 37
I1755 1755 0 1.24921e-03
R2107 1755 1756 1.616 0.8 12.928 37
I1756 1756 0 1.28631e-03
R2108 1756 1757 1.648 0.8 13.184 37
I1757 1757 0 1.26158e-03
R2109 1757 1758 1.616 0.8 12.928 37
I1758 1758 0 1.27395e-03
R2110 1758 1759 1.744 0.8 13.952 37
I1759 1759 0 1.24921e-03
R2111 1759 1760 1.616 0.8 12.928 37
I1760 1760 0 1.23684e-03
R2112 1760 3001 2.5 0.8 20 37
*seg: 177
R2113 3001 1761 2.5 0.8 20 37
R2114 1765 1775 6.16 0.8 49.28 37
I1761 1761 0 1.28631e-03
R2115 1761 1762 1.632 0.8 13.056 37
I1762 1762 0 1.34816e-03
R2116 1762 1763 1.664 0.8 13.312 37
I1763 1763 0 1.24921e-03
R2117 1763 1764 1.648 0.8 13.184 37
I1764 1764 0 1.33579e-03
R2118 1764 1765 1.696 0.8 13.568 37
I1765 1765 0 1.24921e-03
R2119 1765 1766 1.6 0.8 12.8 37
I1766 1766 0 1.26158e-03
R2120 1766 1767 1.632 0.8 13.056 37
I1767 1767 0 1.32342e-03
R2121 1767 1768 1.68 0.8 13.44 37
I1768 1768 0 1.32342e-03
R2122 1768 1769 1.648 0.8 13.184 37
I1769 1769 0 1.31105e-03
R2123 1769 1770 1.712 0.8 13.696 37
I1770 1770 0 1.23684e-03
R2124 1770 3001 2.5 0.8 20 37
*seg: 178
R2125 3001 1771 2.5 0.8 20 37
R2126 1775 1785 6.16 0.8 49.28 37
I1771 1771 0 1.23684e-03
R2127 1771 1772 1.728 0.8 13.824 37
I1772 1772 0 1.33579e-03
R2128 1772 1773 1.712 0.8 13.696 37
I1773 1773 0 1.32342e-03
R2129 1773 1774 1.648 0.8 13.184 37
I1774 1774 0 1.28631e-03
R2130 1774 1775 1.696 0.8 13.568 37
I1775 1775 0 1.29868e-03
R2131 1775 1776 1.712 0.8 13.696 37
I1776 1776 0 1.27395e-03
R2132 1776 1777 1.744 0.8 13.952 37
I1777 1777 0 1.27395e-03
R2133 1777 1778 1.616 0.8 12.928 37
I1778 1778 0 1.32342e-03
R2134 1778 1779 1.648 0.8 13.184 37
I1779 1779 0 1.29868e-03
R2135 1779 1780 1.728 0.8 13.824 37
I1780 1780 0 1.23684e-03
R2136 1780 3001 2.5 0.8 20 37
*seg: 179
R2137 3001 1781 2.5 0.8 20 37
R2138 1785 1795 6.16 0.8 49.28 37
I1781 1781 0 1.32342e-03
R2139 1781 1782 1.712 0.8 13.696 37
I1782 1782 0 1.29868e-03
R2140 1782 1783 1.6 0.8 12.8 37
I1783 1783 0 1.27395e-03
R2141 1783 1784 1.616 0.8 12.928 37
I1784 1784 0 1.33579e-03
R2142 1784 1785 1.648 0.8 13.184 37
I1785 1785 0 1.31105e-03
R2143 1785 1786 1.712 0.8 13.696 37
I1786 1786 0 1.24921e-03
R2144 1786 1787 1.6 0.8 12.8 37
I1787 1787 0 1.23684e-03
R2145 1787 1788 1.664 0.8 13.312 37
I1788 1788 0 1.27395e-03
R2146 1788 1789 1.664 0.8 13.312 37
I1789 1789 0 1.34816e-03
R2147 1789 1790 1.728 0.8 13.824 37
I1790 1790 0 1.23684e-03
R2148 1790 3001 2.5 0.8 20 37
*seg: 180
R2149 3001 1791 2.5 0.8 20 37
R2150 1795 1805 6.16 0.8 49.28 37
I1791 1791 0 1.31105e-03
R2151 1791 1792 1.6 0.8 12.8 37
I1792 1792 0 1.27395e-03
R2152 1792 1793 1.648 0.8 13.184 37
I1793 1793 0 1.23684e-03
R2153 1793 1794 1.648 0.8 13.184 37
I1794 1794 0 1.23684e-03
R2154 1794 1795 1.6 0.8 12.8 37
I1795 1795 0 1.27395e-03
R2155 1795 1796 1.68 0.8 13.44 37
I1796 1796 0 1.29868e-03
R2156 1796 1797 1.616 0.8 12.928 37
I1797 1797 0 1.29868e-03
R2157 1797 1798 1.616 0.8 12.928 37
I1798 1798 0 1.24921e-03
R2158 1798 1799 1.712 0.8 13.696 37
I1799 1799 0 1.28631e-03
R2159 1799 1800 1.696 0.8 13.568 37
I1800 1800 0 1.23684e-03
R2160 1800 3001 2.5 0.8 20 37
*seg: 181
R2161 3001 1801 2.5 0.8 20 37
R2162 1805 1815 6.16 0.8 49.28 37
I1801 1801 0 1.27395e-03
R2163 1801 1802 1.648 0.8 13.184 37
I1802 1802 0 1.23684e-03
R2164 1802 1803 1.6 0.8 12.8 37
I1803 1803 0 1.31105e-03
R2165 1803 1804 1.648 0.8 13.184 37
I1804 1804 0 1.31105e-03
R2166 1804 1805 1.728 0.8 13.824 37
I1805 1805 0 1.24921e-03
R2167 1805 1806 1.68 0.8 13.44 37
I1806 1806 0 1.26158e-03
R2168 1806 1807 1.712 0.8 13.696 37
I1807 1807 0 1.23684e-03
R2169 1807 1808 1.696 0.8 13.568 37
I1808 1808 0 1.33579e-03
R2170 1808 1809 1.712 0.8 13.696 37
I1809 1809 0 1.34816e-03
R2171 1809 1810 1.712 0.8 13.696 37
I1810 1810 0 1.23684e-03
R2172 1810 3001 2.5 0.8 20 37
*seg: 182
R2173 3001 1811 2.5 0.8 20 37
R2174 1815 1825 6.16 0.8 49.28 37
I1811 1811 0 1.24921e-03
R2175 1811 1812 1.744 0.8 13.952 37
I1812 1812 0 1.28631e-03
R2176 1812 1813 1.712 0.8 13.696 37
I1813 1813 0 1.29868e-03
R2177 1813 1814 1.648 0.8 13.184 37
I1814 1814 0 1.28631e-03
R2178 1814 1815 1.616 0.8 12.928 37
I1815 1815 0 1.29868e-03
R2179 1815 1816 1.648 0.8 13.184 37
I1816 1816 0 1.28631e-03
R2180 1816 1817 1.6 0.8 12.8 37
I1817 1817 0 1.28631e-03
R2181 1817 1818 1.728 0.8 13.824 37
I1818 1818 0 1.23684e-03
R2182 1818 1819 1.616 0.8 12.928 37
I1819 1819 0 1.34816e-03
R2183 1819 1820 1.648 0.8 13.184 37
I1820 1820 0 1.23684e-03
R2184 1820 3001 2.5 0.8 20 37
*seg: 183
R2185 3001 1821 2.5 0.8 20 37
R2186 1825 1835 6.16 0.8 49.28 37
I1821 1821 0 1.23684e-03
R2187 1821 1822 1.632 0.8 13.056 37
I1822 1822 0 1.24921e-03
R2188 1822 1823 1.744 0.8 13.952 37
I1823 1823 0 1.32342e-03
R2189 1823 1824 1.664 0.8 13.312 37
I1824 1824 0 1.27395e-03
R2190 1824 1825 1.648 0.8 13.184 37
I1825 1825 0 1.32342e-03
R2191 1825 1826 1.6 0.8 12.8 37
I1826 1826 0 1.31105e-03
R2192 1826 1827 1.664 0.8 13.312 37
I1827 1827 0 1.33579e-03
R2193 1827 1828 1.68 0.8 13.44 37
I1828 1828 0 1.34816e-03
R2194 1828 1829 1.648 0.8 13.184 37
I1829 1829 0 1.24921e-03
R2195 1829 1830 1.6 0.8 12.8 37
I1830 1830 0 1.23684e-03
R2196 1830 3001 2.5 0.8 20 37
*seg: 184
R2197 3001 1831 2.5 0.8 20 37
R2198 1835 1845 6.16 0.8 49.28 37
I1831 1831 0 1.27395e-03
R2199 1831 1832 1.664 0.8 13.312 37
I1832 1832 0 1.32342e-03
R2200 1832 1833 1.728 0.8 13.824 37
I1833 1833 0 1.26158e-03
R2201 1833 1834 1.728 0.8 13.824 37
I1834 1834 0 1.28631e-03
R2202 1834 1835 1.664 0.8 13.312 37
I1835 1835 0 1.23684e-03
R2203 1835 1836 1.712 0.8 13.696 37
I1836 1836 0 1.28631e-03
R2204 1836 1837 1.68 0.8 13.44 37
I1837 1837 0 1.29868e-03
R2205 1837 1838 1.632 0.8 13.056 37
I1838 1838 0 1.24921e-03
R2206 1838 1839 1.728 0.8 13.824 37
I1839 1839 0 1.26158e-03
R2207 1839 1840 1.6 0.8 12.8 37
I1840 1840 0 1.23684e-03
R2208 1840 3001 2.5 0.8 20 37
*seg: 185
R2209 3001 1841 2.5 0.8 20 37
R2210 1845 1855 6.16 0.8 49.28 37
I1841 1841 0 1.34816e-03
R2211 1841 1842 1.696 0.8 13.568 37
I1842 1842 0 1.24921e-03
R2212 1842 1843 1.6 0.8 12.8 37
I1843 1843 0 1.26158e-03
R2213 1843 1844 1.696 0.8 13.568 37
I1844 1844 0 1.34816e-03
R2214 1844 1845 1.728 0.8 13.824 37
I1845 1845 0 1.26158e-03
R2215 1845 1846 1.728 0.8 13.824 37
I1846 1846 0 1.32342e-03
R2216 1846 1847 1.616 0.8 12.928 37
I1847 1847 0 1.27395e-03
R2217 1847 1848 1.6 0.8 12.8 37
I1848 1848 0 1.24921e-03
R2218 1848 1849 1.6 0.8 12.8 37
I1849 1849 0 1.28631e-03
R2219 1849 1850 1.744 0.8 13.952 37
I1850 1850 0 1.23684e-03
R2220 1850 3001 2.5 0.8 20 37
*seg: 186
R2221 3001 1851 2.5 0.8 20 37
R2222 1855 1865 6.16 0.8 49.28 37
I1851 1851 0 1.33579e-03
R2223 1851 1852 1.6 0.8 12.8 37
I1852 1852 0 1.27395e-03
R2224 1852 1853 1.744 0.8 13.952 37
I1853 1853 0 1.28631e-03
R2225 1853 1854 1.6 0.8 12.8 37
I1854 1854 0 1.27395e-03
R2226 1854 1855 1.696 0.8 13.568 37
I1855 1855 0 1.34816e-03
R2227 1855 1856 1.728 0.8 13.824 37
I1856 1856 0 1.29868e-03
R2228 1856 1857 1.712 0.8 13.696 37
I1857 1857 0 1.33579e-03
R2229 1857 1858 1.616 0.8 12.928 37
I1858 1858 0 1.34816e-03
R2230 1858 1859 1.728 0.8 13.824 37
I1859 1859 0 1.34816e-03
R2231 1859 1860 1.728 0.8 13.824 37
I1860 1860 0 1.23684e-03
R2232 1860 3001 2.5 0.8 20 37
*seg: 187
R2233 3001 1861 2.5 0.8 20 37
R2234 1865 1875 6.16 0.8 49.28 37
I1861 1861 0 1.23684e-03
R2235 1861 1862 1.632 0.8 13.056 37
I1862 1862 0 1.23684e-03
R2236 1862 1863 1.616 0.8 12.928 37
I1863 1863 0 1.29868e-03
R2237 1863 1864 1.744 0.8 13.952 37
I1864 1864 0 1.34816e-03
R2238 1864 1865 1.632 0.8 13.056 37
I1865 1865 0 1.23684e-03
R2239 1865 1866 1.68 0.8 13.44 37
I1866 1866 0 1.34816e-03
R2240 1866 1867 1.648 0.8 13.184 37
I1867 1867 0 1.34816e-03
R2241 1867 1868 1.696 0.8 13.568 37
I1868 1868 0 1.28631e-03
R2242 1868 1869 1.744 0.8 13.952 37
I1869 1869 0 1.31105e-03
R2243 1869 1870 1.664 0.8 13.312 37
I1870 1870 0 1.23684e-03
R2244 1870 3001 2.5 0.8 20 37
*seg: 188
R2245 3001 1871 2.5 0.8 20 37
R2246 1875 1885 6.16 0.8 49.28 37
I1871 1871 0 1.26158e-03
R2247 1871 1872 1.68 0.8 13.44 37
I1872 1872 0 1.23684e-03
R2248 1872 1873 1.744 0.8 13.952 37
I1873 1873 0 1.33579e-03
R2249 1873 1874 1.744 0.8 13.952 37
I1874 1874 0 1.26158e-03
R2250 1874 1875 1.6 0.8 12.8 37
I1875 1875 0 1.31105e-03
R2251 1875 1876 1.648 0.8 13.184 37
I1876 1876 0 1.23684e-03
R2252 1876 1877 1.712 0.8 13.696 37
I1877 1877 0 1.27395e-03
R2253 1877 1878 1.68 0.8 13.44 37
I1878 1878 0 1.24921e-03
R2254 1878 1879 1.712 0.8 13.696 37
I1879 1879 0 1.24921e-03
R2255 1879 1880 1.616 0.8 12.928 37
I1880 1880 0 1.23684e-03
R2256 1880 3001 2.5 0.8 20 37
*seg: 189
R2257 3001 1881 2.5 0.8 20 37
R2258 1885 1895 6.16 0.8 49.28 37
I1881 1881 0 1.24921e-03
R2259 1881 1882 1.68 0.8 13.44 37
I1882 1882 0 1.26158e-03
R2260 1882 1883 1.632 0.8 13.056 37
I1883 1883 0 1.34816e-03
R2261 1883 1884 1.664 0.8 13.312 37
I1884 1884 0 1.33579e-03
R2262 1884 1885 1.6 0.8 12.8 37
I1885 1885 0 1.24921e-03
R2263 1885 1886 1.6 0.8 12.8 37
I1886 1886 0 1.34816e-03
R2264 1886 1887 1.664 0.8 13.312 37
I1887 1887 0 1.33579e-03
R2265 1887 1888 1.68 0.8 13.44 37
I1888 1888 0 1.33579e-03
R2266 1888 1889 1.648 0.8 13.184 37
I1889 1889 0 1.33579e-03
R2267 1889 1890 1.648 0.8 13.184 37
I1890 1890 0 1.23684e-03
R2268 1890 3001 2.5 0.8 20 37
*seg: 190
R2269 3001 1891 2.5 0.8 20 37
R2270 1895 1905 6.16 0.8 49.28 37
I1891 1891 0 1.27395e-03
R2271 1891 1892 1.728 0.8 13.824 37
I1892 1892 0 1.23684e-03
R2272 1892 1893 1.68 0.8 13.44 37
I1893 1893 0 1.23684e-03
R2273 1893 1894 1.68 0.8 13.44 37
I1894 1894 0 1.26158e-03
R2274 1894 1895 1.664 0.8 13.312 37
I1895 1895 0 1.31105e-03
R2275 1895 1896 1.664 0.8 13.312 37
I1896 1896 0 1.32342e-03
R2276 1896 1897 1.728 0.8 13.824 37
I1897 1897 0 1.23684e-03
R2277 1897 1898 1.664 0.8 13.312 37
I1898 1898 0 1.31105e-03
R2278 1898 1899 1.712 0.8 13.696 37
I1899 1899 0 1.27395e-03
R2279 1899 1900 1.648 0.8 13.184 37
I1900 1900 0 1.23684e-03
R2280 1900 3001 2.5 0.8 20 37
*seg: 191
R2281 3001 1901 2.5 0.8 20 37
R2282 1905 1915 6.16 0.8 49.28 37
I1901 1901 0 1.27395e-03
R2283 1901 1902 1.6 0.8 12.8 37
I1902 1902 0 1.24921e-03
R2284 1902 1903 1.632 0.8 13.056 37
I1903 1903 0 1.31105e-03
R2285 1903 1904 1.664 0.8 13.312 37
I1904 1904 0 1.24921e-03
R2286 1904 1905 1.632 0.8 13.056 37
I1905 1905 0 1.31105e-03
R2287 1905 1906 1.648 0.8 13.184 37
I1906 1906 0 1.28631e-03
R2288 1906 1907 1.616 0.8 12.928 37
I1907 1907 0 1.27395e-03
R2289 1907 1908 1.616 0.8 12.928 37
I1908 1908 0 1.26158e-03
R2290 1908 1909 1.696 0.8 13.568 37
I1909 1909 0 1.27395e-03
R2291 1909 1910 1.616 0.8 12.928 37
I1910 1910 0 1.23684e-03
R2292 1910 3001 2.5 0.8 20 37
*seg: 192
R2293 3001 1911 2.5 0.8 20 37
R2294 1915 1925 6.16 0.8 49.28 37
I1911 1911 0 1.24921e-03
R2295 1911 1912 1.648 0.8 13.184 37
I1912 1912 0 1.34816e-03
R2296 1912 1913 1.632 0.8 13.056 37
I1913 1913 0 1.24921e-03
R2297 1913 1914 1.664 0.8 13.312 37
I1914 1914 0 1.29868e-03
R2298 1914 1915 1.616 0.8 12.928 37
I1915 1915 0 1.33579e-03
R2299 1915 1916 1.728 0.8 13.824 37
I1916 1916 0 1.28631e-03
R2300 1916 1917 1.712 0.8 13.696 37
I1917 1917 0 1.33579e-03
R2301 1917 1918 1.68 0.8 13.44 37
I1918 1918 0 1.31105e-03
R2302 1918 1919 1.6 0.8 12.8 37
I1919 1919 0 1.24921e-03
R2303 1919 1920 1.696 0.8 13.568 37
I1920 1920 0 1.23684e-03
R2304 1920 3001 2.5 0.8 20 37
*seg: 193
R2305 3001 1921 2.5 0.8 20 37
R2306 1925 1935 6.16 0.8 49.28 37
I1921 1921 0 1.28631e-03
R2307 1921 1922 1.648 0.8 13.184 37
I1922 1922 0 1.27395e-03
R2308 1922 1923 1.68 0.8 13.44 37
I1923 1923 0 1.31105e-03
R2309 1923 1924 1.712 0.8 13.696 37
I1924 1924 0 1.31105e-03
R2310 1924 1925 1.6 0.8 12.8 37
I1925 1925 0 1.27395e-03
R2311 1925 1926 1.728 0.8 13.824 37
I1926 1926 0 1.27395e-03
R2312 1926 1927 1.68 0.8 13.44 37
I1927 1927 0 1.33579e-03
R2313 1927 1928 1.664 0.8 13.312 37
I1928 1928 0 1.26158e-03
R2314 1928 1929 1.712 0.8 13.696 37
I1929 1929 0 1.33579e-03
R2315 1929 1930 1.6 0.8 12.8 37
I1930 1930 0 1.23684e-03
R2316 1930 3001 2.5 0.8 20 37
*seg: 194
R2317 3001 1931 2.5 0.8 20 37
R2318 1935 1945 6.16 0.8 49.28 37
I1931 1931 0 1.26158e-03
R2319 1931 1932 1.712 0.8 13.696 37
I1932 1932 0 1.32342e-03
R2320 1932 1933 1.6 0.8 12.8 37
I1933 1933 0 1.31105e-03
R2321 1933 1934 1.744 0.8 13.952 37
I1934 1934 0 1.24921e-03
R2322 1934 1935 1.664 0.8 13.312 37
I1935 1935 0 1.26158e-03
R2323 1935 1936 1.6 0.8 12.8 37
I1936 1936 0 1.26158e-03
R2324 1936 1937 1.648 0.8 13.184 37
I1937 1937 0 1.31105e-03
R2325 1937 1938 1.68 0.8 13.44 37
I1938 1938 0 1.26158e-03
R2326 1938 1939 1.696 0.8 13.568 37
I1939 1939 0 1.27395e-03
R2327 1939 1940 1.696 0.8 13.568 37
I1940 1940 0 1.23684e-03
R2328 1940 3001 2.5 0.8 20 37
*seg: 195
R2329 3001 1941 2.5 0.8 20 37
R2330 1945 1955 6.16 0.8 49.28 37
I1941 1941 0 1.28631e-03
R2331 1941 1942 1.728 0.8 13.824 37
I1942 1942 0 1.32342e-03
R2332 1942 1943 1.616 0.8 12.928 37
I1943 1943 0 1.31105e-03
R2333 1943 1944 1.616 0.8 12.928 37
I1944 1944 0 1.29868e-03
R2334 1944 1945 1.68 0.8 13.44 37
I1945 1945 0 1.33579e-03
R2335 1945 1946 1.744 0.8 13.952 37
I1946 1946 0 1.23684e-03
R2336 1946 1947 1.664 0.8 13.312 37
I1947 1947 0 1.34816e-03
R2337 1947 1948 1.696 0.8 13.568 37
I1948 1948 0 1.28631e-03
R2338 1948 1949 1.6 0.8 12.8 37
I1949 1949 0 1.34816e-03
R2339 1949 1950 1.728 0.8 13.824 37
I1950 1950 0 1.23684e-03
R2340 1950 3001 2.5 0.8 20 37
*seg: 196
R2341 3001 1951 2.5 0.8 20 37
R2342 1955 1965 6.16 0.8 49.28 37
I1951 1951 0 1.24921e-03
R2343 1951 1952 1.744 0.8 13.952 37
I1952 1952 0 1.27395e-03
R2344 1952 1953 1.744 0.8 13.952 37
I1953 1953 0 1.26158e-03
R2345 1953 1954 1.728 0.8 13.824 37
I1954 1954 0 1.24921e-03
R2346 1954 1955 1.632 0.8 13.056 37
I1955 1955 0 1.23684e-03
R2347 1955 1956 1.648 0.8 13.184 37
I1956 1956 0 1.29868e-03
R2348 1956 1957 1.728 0.8 13.824 37
I1957 1957 0 1.28631e-03
R2349 1957 1958 1.616 0.8 12.928 37
I1958 1958 0 1.23684e-03
R2350 1958 1959 1.744 0.8 13.952 37
I1959 1959 0 1.28631e-03
R2351 1959 1960 1.6 0.8 12.8 37
I1960 1960 0 1.23684e-03
R2352 1960 3001 2.5 0.8 20 37
*seg: 197
R2353 3001 1961 2.5 0.8 20 37
R2354 1965 1975 6.16 0.8 49.28 37
I1961 1961 0 1.33579e-03
R2355 1961 1962 1.712 0.8 13.696 37
I1962 1962 0 1.29868e-03
R2356 1962 1963 1.616 0.8 12.928 37
I1963 1963 0 1.27395e-03
R2357 1963 1964 1.632 0.8 13.056 37
I1964 1964 0 1.24921e-03
R2358 1964 1965 1.728 0.8 13.824 37
I1965 1965 0 1.33579e-03
R2359 1965 1966 1.616 0.8 12.928 37
I1966 1966 0 1.31105e-03
R2360 1966 1967 1.68 0.8 13.44 37
I1967 1967 0 1.28631e-03
R2361 1967 1968 1.648 0.8 13.184 37
I1968 1968 0 1.29868e-03
R2362 1968 1969 1.712 0.8 13.696 37
I1969 1969 0 1.32342e-03
R2363 1969 1970 1.712 0.8 13.696 37
I1970 1970 0 1.23684e-03
R2364 1970 3001 2.5 0.8 20 37
*seg: 198
R2365 3001 1971 2.5 0.8 20 37
R2366 1975 1985 6.16 0.8 49.28 37
I1971 1971 0 1.26158e-03
R2367 1971 1972 1.712 0.8 13.696 37
I1972 1972 0 1.28631e-03
R2368 1972 1973 1.696 0.8 13.568 37
I1973 1973 0 1.23684e-03
R2369 1973 1974 1.632 0.8 13.056 37
I1974 1974 0 1.27395e-03
R2370 1974 1975 1.632 0.8 13.056 37
I1975 1975 0 1.27395e-03
R2371 1975 1976 1.632 0.8 13.056 37
I1976 1976 0 1.33579e-03
R2372 1976 1977 1.712 0.8 13.696 37
I1977 1977 0 1.31105e-03
R2373 1977 1978 1.696 0.8 13.568 37
I1978 1978 0 1.27395e-03
R2374 1978 1979 1.712 0.8 13.696 37
I1979 1979 0 1.24921e-03
R2375 1979 1980 1.712 0.8 13.696 37
I1980 1980 0 1.23684e-03
R2376 1980 3001 2.5 0.8 20 37
*seg: 199
R2377 3001 1981 2.5 0.8 20 37
R2378 1985 1995 6.16 0.8 49.28 37
I1981 1981 0 1.32342e-03
R2379 1981 1982 1.616 0.8 12.928 37
I1982 1982 0 1.34816e-03
R2380 1982 1983 1.664 0.8 13.312 37
I1983 1983 0 1.26158e-03
R2381 1983 1984 1.696 0.8 13.568 37
I1984 1984 0 1.28631e-03
R2382 1984 1985 1.696 0.8 13.568 37
I1985 1985 0 1.26158e-03
R2383 1985 1986 1.6 0.8 12.8 37
I1986 1986 0 1.29868e-03
R2384 1986 1987 1.744 0.8 13.952 37
I1987 1987 0 1.26158e-03
R2385 1987 1988 1.616 0.8 12.928 37
I1988 1988 0 1.33579e-03
R2386 1988 1989 1.696 0.8 13.568 37
I1989 1989 0 1.26158e-03
R2387 1989 1990 1.616 0.8 12.928 37
I1990 1990 0 1.23684e-03
R2388 1990 3001 2.5 0.8 20 37
*seg: 200
R2389 3001 1991 2.5 0.8 20 37
R2390 1995 2005 6.16 0.8 49.28 37
I1991 1991 0 1.32342e-03
R2391 1991 1992 1.648 0.8 13.184 37
I1992 1992 0 1.28631e-03
R2392 1992 1993 1.616 0.8 12.928 37
I1993 1993 0 1.31105e-03
R2393 1993 1994 1.744 0.8 13.952 37
I1994 1994 0 1.24921e-03
R2394 1994 1995 1.712 0.8 13.696 37
I1995 1995 0 1.29868e-03
R2395 1995 1996 1.68 0.8 13.44 37
I1996 1996 0 1.27395e-03
R2396 1996 1997 1.648 0.8 13.184 37
I1997 1997 0 1.33579e-03
R2397 1997 1998 1.664 0.8 13.312 37
I1998 1998 0 1.26158e-03
R2398 1998 1999 1.696 0.8 13.568 37
I1999 1999 0 1.24921e-03
R2399 1999 2000 1.632 0.8 13.056 37
I2000 2000 0 1.23684e-03
R2400 2000 3001 2.5 0.8 20 37
*seg: 201
R2401 3001 2001 2.5 0.8 20 37
R2402 2005 2015 6.16 0.8 49.28 37
I2001 2001 0 1.24921e-03
R2403 2001 2002 1.6 0.8 12.8 37
I2002 2002 0 1.33579e-03
R2404 2002 2003 1.648 0.8 13.184 37
I2003 2003 0 1.28631e-03
R2405 2003 2004 1.632 0.8 13.056 37
I2004 2004 0 1.23684e-03
R2406 2004 2005 1.6 0.8 12.8 37
I2005 2005 0 1.28631e-03
R2407 2005 2006 1.728 0.8 13.824 37
I2006 2006 0 1.24921e-03
R2408 2006 2007 1.68 0.8 13.44 37
I2007 2007 0 1.34816e-03
R2409 2007 2008 1.696 0.8 13.568 37
I2008 2008 0 1.26158e-03
R2410 2008 2009 1.696 0.8 13.568 37
I2009 2009 0 1.33579e-03
R2411 2009 2010 1.696 0.8 13.568 37
I2010 2010 0 1.23684e-03
R2412 2010 3001 2.5 0.8 20 37
*seg: 202
R2413 3001 2011 2.5 0.8 20 37
R2414 2015 2025 6.16 0.8 49.28 37
I2011 2011 0 1.28631e-03
R2415 2011 2012 1.632 0.8 13.056 37
I2012 2012 0 1.29868e-03
R2416 2012 2013 1.728 0.8 13.824 37
I2013 2013 0 1.31105e-03
R2417 2013 2014 1.648 0.8 13.184 37
I2014 2014 0 1.31105e-03
R2418 2014 2015 1.728 0.8 13.824 37
I2015 2015 0 1.32342e-03
R2419 2015 2016 1.664 0.8 13.312 37
I2016 2016 0 1.29868e-03
R2420 2016 2017 1.616 0.8 12.928 37
I2017 2017 0 1.33579e-03
R2421 2017 2018 1.712 0.8 13.696 37
I2018 2018 0 1.32342e-03
R2422 2018 2019 1.728 0.8 13.824 37
I2019 2019 0 1.34816e-03
R2423 2019 2020 1.6 0.8 12.8 37
I2020 2020 0 1.23684e-03
R2424 2020 3001 2.5 0.8 20 37
*seg: 203
R2425 3001 2021 2.5 0.8 20 37
R2426 2025 2035 6.16 0.8 49.28 37
I2021 2021 0 1.26158e-03
R2427 2021 2022 1.728 0.8 13.824 37
I2022 2022 0 1.23684e-03
R2428 2022 2023 1.744 0.8 13.952 37
I2023 2023 0 1.24921e-03
R2429 2023 2024 1.744 0.8 13.952 37
I2024 2024 0 1.23684e-03
R2430 2024 2025 1.696 0.8 13.568 37
I2025 2025 0 1.27395e-03
R2431 2025 2026 1.664 0.8 13.312 37
I2026 2026 0 1.31105e-03
R2432 2026 2027 1.648 0.8 13.184 37
I2027 2027 0 1.27395e-03
R2433 2027 2028 1.68 0.8 13.44 37
I2028 2028 0 1.28631e-03
R2434 2028 2029 1.68 0.8 13.44 37
I2029 2029 0 1.23684e-03
R2435 2029 2030 1.632 0.8 13.056 37
I2030 2030 0 1.23684e-03
R2436 2030 3001 2.5 0.8 20 37
*seg: 204
R2437 3001 2031 2.5 0.8 20 37
R2438 2035 2045 6.16 0.8 49.28 37
I2031 2031 0 1.34816e-03
R2439 2031 2032 1.728 0.8 13.824 37
I2032 2032 0 1.26158e-03
R2440 2032 2033 1.712 0.8 13.696 37
I2033 2033 0 1.26158e-03
R2441 2033 2034 1.728 0.8 13.824 37
I2034 2034 0 1.26158e-03
R2442 2034 2035 1.744 0.8 13.952 37
I2035 2035 0 1.32342e-03
R2443 2035 2036 1.744 0.8 13.952 37
I2036 2036 0 1.32342e-03
R2444 2036 2037 1.744 0.8 13.952 37
I2037 2037 0 1.23684e-03
R2445 2037 2038 1.728 0.8 13.824 37
I2038 2038 0 1.23684e-03
R2446 2038 2039 1.616 0.8 12.928 37
I2039 2039 0 1.27395e-03
R2447 2039 2040 1.728 0.8 13.824 37
I2040 2040 0 1.23684e-03
R2448 2040 3001 2.5 0.8 20 37
*seg: 205
R2449 3001 2041 2.5 0.8 20 37
R2450 2045 2055 6.16 0.8 49.28 37
I2041 2041 0 1.28631e-03
R2451 2041 2042 1.6 0.8 12.8 37
I2042 2042 0 1.28631e-03
R2452 2042 2043 1.616 0.8 12.928 37
I2043 2043 0 1.28631e-03
R2453 2043 2044 1.6 0.8 12.8 37
I2044 2044 0 1.27395e-03
R2454 2044 2045 1.664 0.8 13.312 37
I2045 2045 0 1.32342e-03
R2455 2045 2046 1.68 0.8 13.44 37
I2046 2046 0 1.31105e-03
R2456 2046 2047 1.648 0.8 13.184 37
I2047 2047 0 1.28631e-03
R2457 2047 2048 1.728 0.8 13.824 37
I2048 2048 0 1.26158e-03
R2458 2048 2049 1.632 0.8 13.056 37
I2049 2049 0 1.29868e-03
R2459 2049 2050 1.616 0.8 12.928 37
I2050 2050 0 1.23684e-03
R2460 2050 3001 2.5 0.8 20 37
*seg: 206
R2461 3001 2051 2.5 0.8 20 37
R2462 2055 2065 6.16 0.8 49.28 37
I2051 2051 0 1.23684e-03
R2463 2051 2052 1.728 0.8 13.824 37
I2052 2052 0 1.27395e-03
R2464 2052 2053 1.632 0.8 13.056 37
I2053 2053 0 1.28631e-03
R2465 2053 2054 1.6 0.8 12.8 37
I2054 2054 0 1.28631e-03
R2466 2054 2055 1.696 0.8 13.568 37
I2055 2055 0 1.26158e-03
R2467 2055 2056 1.648 0.8 13.184 37
I2056 2056 0 1.29868e-03
R2468 2056 2057 1.696 0.8 13.568 37
I2057 2057 0 1.26158e-03
R2469 2057 2058 1.616 0.8 12.928 37
I2058 2058 0 1.27395e-03
R2470 2058 2059 1.728 0.8 13.824 37
I2059 2059 0 1.24921e-03
R2471 2059 2060 1.632 0.8 13.056 37
I2060 2060 0 1.23684e-03
R2472 2060 3001 2.5 0.8 20 37
*seg: 207
R2473 3001 2061 2.5 0.8 20 37
R2474 2065 2075 6.16 0.8 49.28 37
I2061 2061 0 1.24921e-03
R2475 2061 2062 1.616 0.8 12.928 37
I2062 2062 0 1.32342e-03
R2476 2062 2063 1.68 0.8 13.44 37
I2063 2063 0 1.33579e-03
R2477 2063 2064 1.648 0.8 13.184 37
I2064 2064 0 1.34816e-03
R2478 2064 2065 1.6 0.8 12.8 37
I2065 2065 0 1.31105e-03
R2479 2065 2066 1.648 0.8 13.184 37
I2066 2066 0 1.34816e-03
R2480 2066 2067 1.744 0.8 13.952 37
I2067 2067 0 1.29868e-03
R2481 2067 2068 1.616 0.8 12.928 37
I2068 2068 0 1.28631e-03
R2482 2068 2069 1.728 0.8 13.824 37
I2069 2069 0 1.27395e-03
R2483 2069 2070 1.648 0.8 13.184 37
I2070 2070 0 1.23684e-03
R2484 2070 3001 2.5 0.8 20 37
*seg: 208
R2485 3001 2071 2.5 0.8 20 37
R2486 2075 2085 6.16 0.8 49.28 37
I2071 2071 0 1.34816e-03
R2487 2071 2072 1.712 0.8 13.696 37
I2072 2072 0 1.31105e-03
R2488 2072 2073 1.632 0.8 13.056 37
I2073 2073 0 1.32342e-03
R2489 2073 2074 1.696 0.8 13.568 37
I2074 2074 0 1.29868e-03
R2490 2074 2075 1.632 0.8 13.056 37
I2075 2075 0 1.23684e-03
R2491 2075 2076 1.712 0.8 13.696 37
I2076 2076 0 1.26158e-03
R2492 2076 2077 1.68 0.8 13.44 37
I2077 2077 0 1.26158e-03
R2493 2077 2078 1.68 0.8 13.44 37
I2078 2078 0 1.23684e-03
R2494 2078 2079 1.632 0.8 13.056 37
I2079 2079 0 1.29868e-03
R2495 2079 2080 1.728 0.8 13.824 37
I2080 2080 0 1.23684e-03
R2496 2080 3001 2.5 0.8 20 37
*seg: 209
R2497 3001 2081 2.5 0.8 20 37
R2498 2085 2095 6.16 0.8 49.28 37
I2081 2081 0 1.32342e-03
R2499 2081 2082 1.696 0.8 13.568 37
I2082 2082 0 1.26158e-03
R2500 2082 2083 1.744 0.8 13.952 37
I2083 2083 0 1.28631e-03
R2501 2083 2084 1.664 0.8 13.312 37
I2084 2084 0 1.27395e-03
R2502 2084 2085 1.648 0.8 13.184 37
I2085 2085 0 1.23684e-03
R2503 2085 2086 1.696 0.8 13.568 37
I2086 2086 0 1.28631e-03
R2504 2086 2087 1.632 0.8 13.056 37
I2087 2087 0 1.32342e-03
R2505 2087 2088 1.632 0.8 13.056 37
I2088 2088 0 1.31105e-03
R2506 2088 2089 1.664 0.8 13.312 37
I2089 2089 0 1.32342e-03
R2507 2089 2090 1.696 0.8 13.568 37
I2090 2090 0 1.23684e-03
R2508 2090 3001 2.5 0.8 20 37
*seg: 210
R2509 3001 2091 2.5 0.8 20 37
R2510 2095 2105 6.16 0.8 49.28 37
I2091 2091 0 1.27395e-03
R2511 2091 2092 1.6 0.8 12.8 37
I2092 2092 0 1.32342e-03
R2512 2092 2093 1.616 0.8 12.928 37
I2093 2093 0 1.23684e-03
R2513 2093 2094 1.616 0.8 12.928 37
I2094 2094 0 1.32342e-03
R2514 2094 2095 1.728 0.8 13.824 37
I2095 2095 0 1.26158e-03
R2515 2095 2096 1.664 0.8 13.312 37
I2096 2096 0 1.29868e-03
R2516 2096 2097 1.728 0.8 13.824 37
I2097 2097 0 1.28631e-03
R2517 2097 2098 1.712 0.8 13.696 37
I2098 2098 0 1.24921e-03
R2518 2098 2099 1.648 0.8 13.184 37
I2099 2099 0 1.34816e-03
R2519 2099 2100 1.744 0.8 13.952 37
I2100 2100 0 1.23684e-03
R2520 2100 3001 2.5 0.8 20 37
*seg: 211
R2521 3001 2101 2.5 0.8 20 37
R2522 2105 2115 6.16 0.8 49.28 37
I2101 2101 0 1.23684e-03
R2523 2101 2102 1.632 0.8 13.056 37
I2102 2102 0 1.31105e-03
R2524 2102 2103 1.696 0.8 13.568 37
I2103 2103 0 1.34816e-03
R2525 2103 2104 1.68 0.8 13.44 37
I2104 2104 0 1.28631e-03
R2526 2104 2105 1.68 0.8 13.44 37
I2105 2105 0 1.32342e-03
R2527 2105 2106 1.632 0.8 13.056 37
I2106 2106 0 1.34816e-03
R2528 2106 2107 1.696 0.8 13.568 37
I2107 2107 0 1.33579e-03
R2529 2107 2108 1.6 0.8 12.8 37
I2108 2108 0 1.23684e-03
R2530 2108 2109 1.68 0.8 13.44 37
I2109 2109 0 1.32342e-03
R2531 2109 2110 1.6 0.8 12.8 37
I2110 2110 0 1.23684e-03
R2532 2110 3001 2.5 0.8 20 37
*seg: 212
R2533 3001 2111 2.5 0.8 20 37
R2534 2115 2125 6.16 0.8 49.28 37
I2111 2111 0 1.26158e-03
R2535 2111 2112 1.616 0.8 12.928 37
I2112 2112 0 1.24921e-03
R2536 2112 2113 1.616 0.8 12.928 37
I2113 2113 0 1.34816e-03
R2537 2113 2114 1.648 0.8 13.184 37
I2114 2114 0 1.29868e-03
R2538 2114 2115 1.712 0.8 13.696 37
I2115 2115 0 1.26158e-03
R2539 2115 2116 1.712 0.8 13.696 37
I2116 2116 0 1.29868e-03
R2540 2116 2117 1.712 0.8 13.696 37
I2117 2117 0 1.27395e-03
R2541 2117 2118 1.728 0.8 13.824 37
I2118 2118 0 1.31105e-03
R2542 2118 2119 1.664 0.8 13.312 37
I2119 2119 0 1.33579e-03
R2543 2119 2120 1.744 0.8 13.952 37
I2120 2120 0 1.23684e-03
R2544 2120 3001 2.5 0.8 20 37
*seg: 213
R2545 3001 2121 2.5 0.8 20 37
R2546 2125 2135 6.16 0.8 49.28 37
I2121 2121 0 1.34816e-03
R2547 2121 2122 1.6 0.8 12.8 37
I2122 2122 0 1.32342e-03
R2548 2122 2123 1.68 0.8 13.44 37
I2123 2123 0 1.32342e-03
R2549 2123 2124 1.648 0.8 13.184 37
I2124 2124 0 1.23684e-03
R2550 2124 2125 1.616 0.8 12.928 37
I2125 2125 0 1.29868e-03
R2551 2125 2126 1.648 0.8 13.184 37
I2126 2126 0 1.26158e-03
R2552 2126 2127 1.648 0.8 13.184 37
I2127 2127 0 1.32342e-03
R2553 2127 2128 1.696 0.8 13.568 37
I2128 2128 0 1.23684e-03
R2554 2128 2129 1.696 0.8 13.568 37
I2129 2129 0 1.34816e-03
R2555 2129 2130 1.696 0.8 13.568 37
I2130 2130 0 1.23684e-03
R2556 2130 3001 2.5 0.8 20 37
*seg: 214
R2557 3001 2131 2.5 0.8 20 37
R2558 2135 2145 6.16 0.8 49.28 37
I2131 2131 0 1.23684e-03
R2559 2131 2132 1.616 0.8 12.928 37
I2132 2132 0 1.24921e-03
R2560 2132 2133 1.696 0.8 13.568 37
I2133 2133 0 1.31105e-03
R2561 2133 2134 1.728 0.8 13.824 37
I2134 2134 0 1.24921e-03
R2562 2134 2135 1.712 0.8 13.696 37
I2135 2135 0 1.31105e-03
R2563 2135 2136 1.6 0.8 12.8 37
I2136 2136 0 1.31105e-03
R2564 2136 2137 1.744 0.8 13.952 37
I2137 2137 0 1.26158e-03
R2565 2137 2138 1.696 0.8 13.568 37
I2138 2138 0 1.32342e-03
R2566 2138 2139 1.728 0.8 13.824 37
I2139 2139 0 1.34816e-03
R2567 2139 2140 1.616 0.8 12.928 37
I2140 2140 0 1.23684e-03
R2568 2140 3001 2.5 0.8 20 37
*seg: 215
R2569 3001 2141 2.5 0.8 20 37
R2570 2145 2155 6.16 0.8 49.28 37
I2141 2141 0 1.28631e-03
R2571 2141 2142 1.68 0.8 13.44 37
I2142 2142 0 1.24921e-03
R2572 2142 2143 1.6 0.8 12.8 37
I2143 2143 0 1.28631e-03
R2573 2143 2144 1.696 0.8 13.568 37
I2144 2144 0 1.27395e-03
R2574 2144 2145 1.6 0.8 12.8 37
I2145 2145 0 1.23684e-03
R2575 2145 2146 1.728 0.8 13.824 37
I2146 2146 0 1.26158e-03
R2576 2146 2147 1.696 0.8 13.568 37
I2147 2147 0 1.32342e-03
R2577 2147 2148 1.68 0.8 13.44 37
I2148 2148 0 1.29868e-03
R2578 2148 2149 1.696 0.8 13.568 37
I2149 2149 0 1.24921e-03
R2579 2149 2150 1.68 0.8 13.44 37
I2150 2150 0 1.23684e-03
R2580 2150 3001 2.5 0.8 20 37
*seg: 216
R2581 3001 2151 2.5 0.8 20 37
R2582 2155 2165 6.16 0.8 49.28 37
I2151 2151 0 1.33579e-03
R2583 2151 2152 1.664 0.8 13.312 37
I2152 2152 0 1.29868e-03
R2584 2152 2153 1.616 0.8 12.928 37
I2153 2153 0 1.34816e-03
R2585 2153 2154 1.744 0.8 13.952 37
I2154 2154 0 1.24921e-03
R2586 2154 2155 1.712 0.8 13.696 37
I2155 2155 0 1.32342e-03
R2587 2155 2156 1.68 0.8 13.44 37
I2156 2156 0 1.32342e-03
R2588 2156 2157 1.648 0.8 13.184 37
I2157 2157 0 1.31105e-03
R2589 2157 2158 1.664 0.8 13.312 37
I2158 2158 0 1.31105e-03
R2590 2158 2159 1.712 0.8 13.696 37
I2159 2159 0 1.33579e-03
R2591 2159 2160 1.648 0.8 13.184 37
I2160 2160 0 1.23684e-03
R2592 2160 3001 2.5 0.8 20 37
*seg: 217
R2593 3001 2161 2.5 0.8 20 37
R2594 2165 2175 6.16 0.8 49.28 37
I2161 2161 0 1.29868e-03
R2595 2161 2162 1.632 0.8 13.056 37
I2162 2162 0 1.32342e-03
R2596 2162 2163 1.728 0.8 13.824 37
I2163 2163 0 1.23684e-03
R2597 2163 2164 1.68 0.8 13.44 37
I2164 2164 0 1.26158e-03
R2598 2164 2165 1.648 0.8 13.184 37
I2165 2165 0 1.34816e-03
R2599 2165 2166 1.712 0.8 13.696 37
I2166 2166 0 1.32342e-03
R2600 2166 2167 1.68 0.8 13.44 37
I2167 2167 0 1.27395e-03
R2601 2167 2168 1.744 0.8 13.952 37
I2168 2168 0 1.34816e-03
R2602 2168 2169 1.712 0.8 13.696 37
I2169 2169 0 1.28631e-03
R2603 2169 2170 1.696 0.8 13.568 37
I2170 2170 0 1.23684e-03
R2604 2170 3001 2.5 0.8 20 37
*seg: 218
R2605 3001 2171 2.5 0.8 20 37
R2606 2175 2185 6.16 0.8 49.28 37
I2171 2171 0 1.32342e-03
R2607 2171 2172 1.648 0.8 13.184 37
I2172 2172 0 1.28631e-03
R2608 2172 2173 1.68 0.8 13.44 37
I2173 2173 0 1.32342e-03
R2609 2173 2174 1.664 0.8 13.312 37
I2174 2174 0 1.24921e-03
R2610 2174 2175 1.68 0.8 13.44 37
I2175 2175 0 1.33579e-03
R2611 2175 2176 1.632 0.8 13.056 37
I2176 2176 0 1.27395e-03
R2612 2176 2177 1.712 0.8 13.696 37
I2177 2177 0 1.32342e-03
R2613 2177 2178 1.6 0.8 12.8 37
I2178 2178 0 1.24921e-03
R2614 2178 2179 1.696 0.8 13.568 37
I2179 2179 0 1.23684e-03
R2615 2179 2180 1.696 0.8 13.568 37
I2180 2180 0 1.23684e-03
R2616 2180 3001 2.5 0.8 20 37
*seg: 219
R2617 3001 2181 2.5 0.8 20 37
R2618 2185 2195 6.16 0.8 49.28 37
I2181 2181 0 1.32342e-03
R2619 2181 2182 1.6 0.8 12.8 37
I2182 2182 0 1.31105e-03
R2620 2182 2183 1.712 0.8 13.696 37
I2183 2183 0 1.27395e-03
R2621 2183 2184 1.6 0.8 12.8 37
I2184 2184 0 1.29868e-03
R2622 2184 2185 1.744 0.8 13.952 37
I2185 2185 0 1.26158e-03
R2623 2185 2186 1.728 0.8 13.824 37
I2186 2186 0 1.33579e-03
R2624 2186 2187 1.648 0.8 13.184 37
I2187 2187 0 1.27395e-03
R2625 2187 2188 1.728 0.8 13.824 37
I2188 2188 0 1.31105e-03
R2626 2188 2189 1.68 0.8 13.44 37
I2189 2189 0 1.28631e-03
R2627 2189 2190 1.744 0.8 13.952 37
I2190 2190 0 1.23684e-03
R2628 2190 3001 2.5 0.8 20 37
*seg: 220
R2629 3001 2191 2.5 0.8 20 37
R2630 2195 2205 6.16 0.8 49.28 37
I2191 2191 0 1.32342e-03
R2631 2191 2192 1.68 0.8 13.44 37
I2192 2192 0 1.31105e-03
R2632 2192 2193 1.616 0.8 12.928 37
I2193 2193 0 1.28631e-03
R2633 2193 2194 1.744 0.8 13.952 37
I2194 2194 0 1.32342e-03
R2634 2194 2195 1.664 0.8 13.312 37
I2195 2195 0 1.27395e-03
R2635 2195 2196 1.712 0.8 13.696 37
I2196 2196 0 1.28631e-03
R2636 2196 2197 1.712 0.8 13.696 37
I2197 2197 0 1.26158e-03
R2637 2197 2198 1.744 0.8 13.952 37
I2198 2198 0 1.31105e-03
R2638 2198 2199 1.696 0.8 13.568 37
I2199 2199 0 1.23684e-03
R2639 2199 2200 1.6 0.8 12.8 37
I2200 2200 0 1.23684e-03
R2640 2200 3001 2.5 0.8 20 37
*seg: 221
R2641 3001 2201 2.5 0.8 20 37
R2642 2205 2215 6.16 0.8 49.28 37
I2201 2201 0 1.33579e-03
R2643 2201 2202 1.632 0.8 13.056 37
I2202 2202 0 1.27395e-03
R2644 2202 2203 1.6 0.8 12.8 37
I2203 2203 0 1.33579e-03
R2645 2203 2204 1.728 0.8 13.824 37
I2204 2204 0 1.27395e-03
R2646 2204 2205 1.696 0.8 13.568 37
I2205 2205 0 1.29868e-03
R2647 2205 2206 1.6 0.8 12.8 37
I2206 2206 0 1.24921e-03
R2648 2206 2207 1.648 0.8 13.184 37
I2207 2207 0 1.27395e-03
R2649 2207 2208 1.68 0.8 13.44 37
I2208 2208 0 1.28631e-03
R2650 2208 2209 1.728 0.8 13.824 37
I2209 2209 0 1.33579e-03
R2651 2209 2210 1.664 0.8 13.312 37
I2210 2210 0 1.23684e-03
R2652 2210 3001 2.5 0.8 20 37
*seg: 222
R2653 3001 2211 2.5 0.8 20 37
R2654 2215 2225 6.16 0.8 49.28 37
I2211 2211 0 1.26158e-03
R2655 2211 2212 1.744 0.8 13.952 37
I2212 2212 0 1.29868e-03
R2656 2212 2213 1.728 0.8 13.824 37
I2213 2213 0 1.32342e-03
R2657 2213 2214 1.632 0.8 13.056 37
I2214 2214 0 1.26158e-03
R2658 2214 2215 1.6 0.8 12.8 37
I2215 2215 0 1.24921e-03
R2659 2215 2216 1.68 0.8 13.44 37
I2216 2216 0 1.27395e-03
R2660 2216 2217 1.6 0.8 12.8 37
I2217 2217 0 1.33579e-03
R2661 2217 2218 1.728 0.8 13.824 37
I2218 2218 0 1.32342e-03
R2662 2218 2219 1.68 0.8 13.44 37
I2219 2219 0 1.34816e-03
R2663 2219 2220 1.664 0.8 13.312 37
I2220 2220 0 1.23684e-03
R2664 2220 3001 2.5 0.8 20 37
*seg: 223
R2665 3001 2221 2.5 0.8 20 37
R2666 2225 2235 6.16 0.8 49.28 37
I2221 2221 0 1.24921e-03
R2667 2221 2222 1.616 0.8 12.928 37
I2222 2222 0 1.32342e-03
R2668 2222 2223 1.664 0.8 13.312 37
I2223 2223 0 1.31105e-03
R2669 2223 2224 1.664 0.8 13.312 37
I2224 2224 0 1.26158e-03
R2670 2224 2225 1.696 0.8 13.568 37
I2225 2225 0 1.24921e-03
R2671 2225 2226 1.728 0.8 13.824 37
I2226 2226 0 1.26158e-03
R2672 2226 2227 1.648 0.8 13.184 37
I2227 2227 0 1.24921e-03
R2673 2227 2228 1.696 0.8 13.568 37
I2228 2228 0 1.34816e-03
R2674 2228 2229 1.632 0.8 13.056 37
I2229 2229 0 1.26158e-03
R2675 2229 2230 1.664 0.8 13.312 37
I2230 2230 0 1.23684e-03
R2676 2230 3001 2.5 0.8 20 37
*seg: 224
R2677 3001 2231 2.5 0.8 20 37
R2678 2235 2245 6.16 0.8 49.28 37
I2231 2231 0 1.23684e-03
R2679 2231 2232 1.664 0.8 13.312 37
I2232 2232 0 1.27395e-03
R2680 2232 2233 1.712 0.8 13.696 37
I2233 2233 0 1.32342e-03
R2681 2233 2234 1.744 0.8 13.952 37
I2234 2234 0 1.23684e-03
R2682 2234 2235 1.6 0.8 12.8 37
I2235 2235 0 1.31105e-03
R2683 2235 2236 1.68 0.8 13.44 37
I2236 2236 0 1.23684e-03
R2684 2236 2237 1.696 0.8 13.568 37
I2237 2237 0 1.31105e-03
R2685 2237 2238 1.728 0.8 13.824 37
I2238 2238 0 1.29868e-03
R2686 2238 2239 1.6 0.8 12.8 37
I2239 2239 0 1.32342e-03
R2687 2239 2240 1.616 0.8 12.928 37
I2240 2240 0 1.23684e-03
R2688 2240 3001 2.5 0.8 20 37
*seg: 225
R2689 3001 2241 2.5 0.8 20 37
R2690 2245 2255 6.16 0.8 49.28 37
I2241 2241 0 1.28631e-03
R2691 2241 2242 1.728 0.8 13.824 37
I2242 2242 0 1.33579e-03
R2692 2242 2243 1.632 0.8 13.056 37
I2243 2243 0 1.29868e-03
R2693 2243 2244 1.68 0.8 13.44 37
I2244 2244 0 1.26158e-03
R2694 2244 2245 1.648 0.8 13.184 37
I2245 2245 0 1.28631e-03
R2695 2245 2246 1.712 0.8 13.696 37
I2246 2246 0 1.28631e-03
R2696 2246 2247 1.616 0.8 12.928 37
I2247 2247 0 1.26158e-03
R2697 2247 2248 1.728 0.8 13.824 37
I2248 2248 0 1.23684e-03
R2698 2248 2249 1.728 0.8 13.824 37
I2249 2249 0 1.32342e-03
R2699 2249 2250 1.648 0.8 13.184 37
I2250 2250 0 1.23684e-03
R2700 2250 3001 2.5 0.8 20 37
*seg: 226
R2701 3001 2251 2.5 0.8 20 37
R2702 2255 2265 6.16 0.8 49.28 37
I2251 2251 0 1.26158e-03
R2703 2251 2252 1.712 0.8 13.696 37
I2252 2252 0 1.28631e-03
R2704 2252 2253 1.648 0.8 13.184 37
I2253 2253 0 1.29868e-03
R2705 2253 2254 1.664 0.8 13.312 37
I2254 2254 0 1.32342e-03
R2706 2254 2255 1.616 0.8 12.928 37
I2255 2255 0 1.24921e-03
R2707 2255 2256 1.712 0.8 13.696 37
I2256 2256 0 1.29868e-03
R2708 2256 2257 1.616 0.8 12.928 37
I2257 2257 0 1.23684e-03
R2709 2257 2258 1.728 0.8 13.824 37
I2258 2258 0 1.27395e-03
R2710 2258 2259 1.664 0.8 13.312 37
I2259 2259 0 1.23684e-03
R2711 2259 2260 1.728 0.8 13.824 37
I2260 2260 0 1.23684e-03
R2712 2260 3001 2.5 0.8 20 37
*seg: 227
R2713 3001 2261 2.5 0.8 20 37
R2714 2265 2275 6.16 0.8 49.28 37
I2261 2261 0 1.24921e-03
R2715 2261 2262 1.6 0.8 12.8 37
I2262 2262 0 1.28631e-03
R2716 2262 2263 1.632 0.8 13.056 37
I2263 2263 0 1.26158e-03
R2717 2263 2264 1.696 0.8 13.568 37
I2264 2264 0 1.29868e-03
R2718 2264 2265 1.648 0.8 13.184 37
I2265 2265 0 1.32342e-03
R2719 2265 2266 1.664 0.8 13.312 37
I2266 2266 0 1.24921e-03
R2720 2266 2267 1.728 0.8 13.824 37
I2267 2267 0 1.27395e-03
R2721 2267 2268 1.68 0.8 13.44 37
I2268 2268 0 1.24921e-03
R2722 2268 2269 1.648 0.8 13.184 37
I2269 2269 0 1.24921e-03
R2723 2269 2270 1.616 0.8 12.928 37
I2270 2270 0 1.23684e-03
R2724 2270 3001 2.5 0.8 20 37
*seg: 228
R2725 3001 2271 2.5 0.8 20 37
R2726 2275 2285 6.16 0.8 49.28 37
I2271 2271 0 1.26158e-03
R2727 2271 2272 1.68 0.8 13.44 37
I2272 2272 0 1.28631e-03
R2728 2272 2273 1.696 0.8 13.568 37
I2273 2273 0 1.32342e-03
R2729 2273 2274 1.616 0.8 12.928 37
I2274 2274 0 1.32342e-03
R2730 2274 2275 1.696 0.8 13.568 37
I2275 2275 0 1.23684e-03
R2731 2275 2276 1.648 0.8 13.184 37
I2276 2276 0 1.27395e-03
R2732 2276 2277 1.712 0.8 13.696 37
I2277 2277 0 1.33579e-03
R2733 2277 2278 1.632 0.8 13.056 37
I2278 2278 0 1.34816e-03
R2734 2278 2279 1.648 0.8 13.184 37
I2279 2279 0 1.29868e-03
R2735 2279 2280 1.648 0.8 13.184 37
I2280 2280 0 1.23684e-03
R2736 2280 3001 2.5 0.8 20 37
*seg: 229
R2737 3001 2281 2.5 0.8 20 37
R2738 2285 2295 6.16 0.8 49.28 37
I2281 2281 0 1.27395e-03
R2739 2281 2282 1.68 0.8 13.44 37
I2282 2282 0 1.34816e-03
R2740 2282 2283 1.6 0.8 12.8 37
I2283 2283 0 1.24921e-03
R2741 2283 2284 1.632 0.8 13.056 37
I2284 2284 0 1.23684e-03
R2742 2284 2285 1.744 0.8 13.952 37
I2285 2285 0 1.28631e-03
R2743 2285 2286 1.664 0.8 13.312 37
I2286 2286 0 1.27395e-03
R2744 2286 2287 1.616 0.8 12.928 37
I2287 2287 0 1.28631e-03
R2745 2287 2288 1.6 0.8 12.8 37
I2288 2288 0 1.23684e-03
R2746 2288 2289 1.648 0.8 13.184 37
I2289 2289 0 1.27395e-03
R2747 2289 2290 1.68 0.8 13.44 37
I2290 2290 0 1.23684e-03
R2748 2290 3001 2.5 0.8 20 37
*seg: 230
R2749 3001 2291 2.5 0.8 20 37
R2750 2295 2305 6.16 0.8 49.28 37
I2291 2291 0 1.24921e-03
R2751 2291 2292 1.712 0.8 13.696 37
I2292 2292 0 1.29868e-03
R2752 2292 2293 1.68 0.8 13.44 37
I2293 2293 0 1.24921e-03
R2753 2293 2294 1.712 0.8 13.696 37
I2294 2294 0 1.31105e-03
R2754 2294 2295 1.68 0.8 13.44 37
I2295 2295 0 1.24921e-03
R2755 2295 2296 1.712 0.8 13.696 37
I2296 2296 0 1.26158e-03
R2756 2296 2297 1.712 0.8 13.696 37
I2297 2297 0 1.31105e-03
R2757 2297 2298 1.664 0.8 13.312 37
I2298 2298 0 1.32342e-03
R2758 2298 2299 1.712 0.8 13.696 37
I2299 2299 0 1.27395e-03
R2759 2299 2300 1.712 0.8 13.696 37
I2300 2300 0 1.23684e-03
R2760 2300 3001 2.5 0.8 20 37
*seg: 231
R2761 3001 2301 2.5 0.8 20 37
R2762 2305 2315 6.16 0.8 49.28 37
I2301 2301 0 1.24921e-03
R2763 2301 2302 1.696 0.8 13.568 37
I2302 2302 0 1.23684e-03
R2764 2302 2303 1.68 0.8 13.44 37
I2303 2303 0 1.34816e-03
R2765 2303 2304 1.712 0.8 13.696 37
I2304 2304 0 1.27395e-03
R2766 2304 2305 1.68 0.8 13.44 37
I2305 2305 0 1.27395e-03
R2767 2305 2306 1.744 0.8 13.952 37
I2306 2306 0 1.27395e-03
R2768 2306 2307 1.68 0.8 13.44 37
I2307 2307 0 1.27395e-03
R2769 2307 2308 1.744 0.8 13.952 37
I2308 2308 0 1.27395e-03
R2770 2308 2309 1.616 0.8 12.928 37
I2309 2309 0 1.32342e-03
R2771 2309 2310 1.616 0.8 12.928 37
I2310 2310 0 1.23684e-03
R2772 2310 3001 2.5 0.8 20 37
*seg: 232
R2773 3001 2311 2.5 0.8 20 37
R2774 2315 2325 6.16 0.8 49.28 37
I2311 2311 0 1.31105e-03
R2775 2311 2312 1.744 0.8 13.952 37
I2312 2312 0 1.23684e-03
R2776 2312 2313 1.6 0.8 12.8 37
I2313 2313 0 1.33579e-03
R2777 2313 2314 1.648 0.8 13.184 37
I2314 2314 0 1.23684e-03
R2778 2314 2315 1.728 0.8 13.824 37
I2315 2315 0 1.27395e-03
R2779 2315 2316 1.728 0.8 13.824 37
I2316 2316 0 1.26158e-03
R2780 2316 2317 1.744 0.8 13.952 37
I2317 2317 0 1.24921e-03
R2781 2317 2318 1.664 0.8 13.312 37
I2318 2318 0 1.28631e-03
R2782 2318 2319 1.648 0.8 13.184 37
I2319 2319 0 1.31105e-03
R2783 2319 2320 1.632 0.8 13.056 37
I2320 2320 0 1.23684e-03
R2784 2320 3001 2.5 0.8 20 37
*seg: 233
R2785 3001 2321 2.5 0.8 20 37
R2786 2325 2335 6.16 0.8 49.28 37
I2321 2321 0 1.26158e-03
R2787 2321 2322 1.616 0.8 12.928 37
I2322 2322 0 1.24921e-03
R2788 2322 2323 1.664 0.8 13.312 37
I2323 2323 0 1.33579e-03
R2789 2323 2324 1.712 0.8 13.696 37
I2324 2324 0 1.24921e-03
R2790 2324 2325 1.648 0.8 13.184 37
I2325 2325 0 1.29868e-03
R2791 2325 2326 1.6 0.8 12.8 37
I2326 2326 0 1.29868e-03
R2792 2326 2327 1.616 0.8 12.928 37
I2327 2327 0 1.32342e-03
R2793 2327 2328 1.728 0.8 13.824 37
I2328 2328 0 1.28631e-03
R2794 2328 2329 1.664 0.8 13.312 37
I2329 2329 0 1.27395e-03
R2795 2329 2330 1.696 0.8 13.568 37
I2330 2330 0 1.23684e-03
R2796 2330 3001 2.5 0.8 20 37
*seg: 234
R2797 3001 2331 2.5 0.8 20 37
R2798 2335 2345 6.16 0.8 49.28 37
I2331 2331 0 1.34816e-03
R2799 2331 2332 1.744 0.8 13.952 37
I2332 2332 0 1.28631e-03
R2800 2332 2333 1.616 0.8 12.928 37
I2333 2333 0 1.29868e-03
R2801 2333 2334 1.712 0.8 13.696 37
I2334 2334 0 1.26158e-03
R2802 2334 2335 1.728 0.8 13.824 37
I2335 2335 0 1.26158e-03
R2803 2335 2336 1.68 0.8 13.44 37
I2336 2336 0 1.23684e-03
R2804 2336 2337 1.712 0.8 13.696 37
I2337 2337 0 1.23684e-03
R2805 2337 2338 1.728 0.8 13.824 37
I2338 2338 0 1.27395e-03
R2806 2338 2339 1.712 0.8 13.696 37
I2339 2339 0 1.34816e-03
R2807 2339 2340 1.696 0.8 13.568 37
I2340 2340 0 1.23684e-03
R2808 2340 3001 2.5 0.8 20 37
*seg: 235
R2809 3001 2341 2.5 0.8 20 37
R2810 2345 2355 6.16 0.8 49.28 37
I2341 2341 0 1.33579e-03
R2811 2341 2342 1.664 0.8 13.312 37
I2342 2342 0 1.34816e-03
R2812 2342 2343 1.712 0.8 13.696 37
I2343 2343 0 1.24921e-03
R2813 2343 2344 1.648 0.8 13.184 37
I2344 2344 0 1.23684e-03
R2814 2344 2345 1.68 0.8 13.44 37
I2345 2345 0 1.28631e-03
R2815 2345 2346 1.664 0.8 13.312 37
I2346 2346 0 1.29868e-03
R2816 2346 2347 1.616 0.8 12.928 37
I2347 2347 0 1.24921e-03
R2817 2347 2348 1.664 0.8 13.312 37
I2348 2348 0 1.24921e-03
R2818 2348 2349 1.648 0.8 13.184 37
I2349 2349 0 1.31105e-03
R2819 2349 2350 1.744 0.8 13.952 37
I2350 2350 0 1.23684e-03
R2820 2350 3001 2.5 0.8 20 37
*seg: 236
R2821 3001 2351 2.5 0.8 20 37
R2822 2355 2365 6.16 0.8 49.28 37
I2351 2351 0 1.34816e-03
R2823 2351 2352 1.632 0.8 13.056 37
I2352 2352 0 1.31105e-03
R2824 2352 2353 1.616 0.8 12.928 37
I2353 2353 0 1.27395e-03
R2825 2353 2354 1.632 0.8 13.056 37
I2354 2354 0 1.24921e-03
R2826 2354 2355 1.744 0.8 13.952 37
I2355 2355 0 1.33579e-03
R2827 2355 2356 1.712 0.8 13.696 37
I2356 2356 0 1.32342e-03
R2828 2356 2357 1.632 0.8 13.056 37
I2357 2357 0 1.31105e-03
R2829 2357 2358 1.664 0.8 13.312 37
I2358 2358 0 1.34816e-03
R2830 2358 2359 1.712 0.8 13.696 37
I2359 2359 0 1.23684e-03
R2831 2359 2360 1.696 0.8 13.568 37
I2360 2360 0 1.23684e-03
R2832 2360 3001 2.5 0.8 20 37
*seg: 237
R2833 3001 2361 2.5 0.8 20 37
R2834 2365 2375 6.16 0.8 49.28 37
I2361 2361 0 1.24921e-03
R2835 2361 2362 1.6 0.8 12.8 37
I2362 2362 0 1.24921e-03
R2836 2362 2363 1.616 0.8 12.928 37
I2363 2363 0 1.27395e-03
R2837 2363 2364 1.68 0.8 13.44 37
I2364 2364 0 1.26158e-03
R2838 2364 2365 1.728 0.8 13.824 37
I2365 2365 0 1.34816e-03
R2839 2365 2366 1.616 0.8 12.928 37
I2366 2366 0 1.24921e-03
R2840 2366 2367 1.696 0.8 13.568 37
I2367 2367 0 1.23684e-03
R2841 2367 2368 1.648 0.8 13.184 37
I2368 2368 0 1.24921e-03
R2842 2368 2369 1.712 0.8 13.696 37
I2369 2369 0 1.32342e-03
R2843 2369 2370 1.744 0.8 13.952 37
I2370 2370 0 1.23684e-03
R2844 2370 3001 2.5 0.8 20 37
*seg: 238
R2845 3001 2371 2.5 0.8 20 37
R2846 2375 2385 6.16 0.8 49.28 37
I2371 2371 0 1.28631e-03
R2847 2371 2372 1.616 0.8 12.928 37
I2372 2372 0 1.29868e-03
R2848 2372 2373 1.616 0.8 12.928 37
I2373 2373 0 1.26158e-03
R2849 2373 2374 1.728 0.8 13.824 37
I2374 2374 0 1.28631e-03
R2850 2374 2375 1.632 0.8 13.056 37
I2375 2375 0 1.27395e-03
R2851 2375 2376 1.648 0.8 13.184 37
I2376 2376 0 1.34816e-03
R2852 2376 2377 1.6 0.8 12.8 37
I2377 2377 0 1.27395e-03
R2853 2377 2378 1.68 0.8 13.44 37
I2378 2378 0 1.33579e-03
R2854 2378 2379 1.696 0.8 13.568 37
I2379 2379 0 1.27395e-03
R2855 2379 2380 1.744 0.8 13.952 37
I2380 2380 0 1.23684e-03
R2856 2380 3001 2.5 0.8 20 37
*seg: 239
R2857 3001 2381 2.5 0.8 20 37
R2858 2385 2395 6.16 0.8 49.28 37
I2381 2381 0 1.34816e-03
R2859 2381 2382 1.632 0.8 13.056 37
I2382 2382 0 1.26158e-03
R2860 2382 2383 1.696 0.8 13.568 37
I2383 2383 0 1.26158e-03
R2861 2383 2384 1.728 0.8 13.824 37
I2384 2384 0 1.24921e-03
R2862 2384 2385 1.6 0.8 12.8 37
I2385 2385 0 1.34816e-03
R2863 2385 2386 1.6 0.8 12.8 37
I2386 2386 0 1.24921e-03
R2864 2386 2387 1.616 0.8 12.928 37
I2387 2387 0 1.34816e-03
R2865 2387 2388 1.744 0.8 13.952 37
I2388 2388 0 1.31105e-03
R2866 2388 2389 1.664 0.8 13.312 37
I2389 2389 0 1.26158e-03
R2867 2389 2390 1.664 0.8 13.312 37
I2390 2390 0 1.23684e-03
R2868 2390 3001 2.5 0.8 20 37
*seg: 240
R2869 3001 2391 2.5 0.8 20 37
R2870 2395 2405 6.16 0.8 49.28 37
I2391 2391 0 1.33579e-03
R2871 2391 2392 1.68 0.8 13.44 37
I2392 2392 0 1.23684e-03
R2872 2392 2393 1.664 0.8 13.312 37
I2393 2393 0 1.26158e-03
R2873 2393 2394 1.648 0.8 13.184 37
I2394 2394 0 1.27395e-03
R2874 2394 2395 1.696 0.8 13.568 37
I2395 2395 0 1.28631e-03
R2875 2395 2396 1.664 0.8 13.312 37
I2396 2396 0 1.28631e-03
R2876 2396 2397 1.632 0.8 13.056 37
I2397 2397 0 1.28631e-03
R2877 2397 2398 1.616 0.8 12.928 37
I2398 2398 0 1.26158e-03
R2878 2398 2399 1.616 0.8 12.928 37
I2399 2399 0 1.27395e-03
R2879 2399 2400 1.696 0.8 13.568 37
I2400 2400 0 1.23684e-03
R2880 2400 3001 2.5 0.8 20 37
*seg: 241
R2881 3001 2401 2.5 0.8 20 37
R2882 2405 2415 6.16 0.8 49.28 37
I2401 2401 0 1.29868e-03
R2883 2401 2402 1.728 0.8 13.824 37
I2402 2402 0 1.28631e-03
R2884 2402 2403 1.712 0.8 13.696 37
I2403 2403 0 1.32342e-03
R2885 2403 2404 1.616 0.8 12.928 37
I2404 2404 0 1.24921e-03
R2886 2404 2405 1.728 0.8 13.824 37
I2405 2405 0 1.26158e-03
R2887 2405 2406 1.712 0.8 13.696 37
I2406 2406 0 1.26158e-03
R2888 2406 2407 1.632 0.8 13.056 37
I2407 2407 0 1.34816e-03
R2889 2407 2408 1.632 0.8 13.056 37
I2408 2408 0 1.28631e-03
R2890 2408 2409 1.68 0.8 13.44 37
I2409 2409 0 1.23684e-03
R2891 2409 2410 1.728 0.8 13.824 37
I2410 2410 0 1.23684e-03
R2892 2410 3001 2.5 0.8 20 37
*seg: 242
R2893 3001 2411 2.5 0.8 20 37
R2894 2415 2425 6.16 0.8 49.28 37
I2411 2411 0 1.23684e-03
R2895 2411 2412 1.6 0.8 12.8 37
I2412 2412 0 1.31105e-03
R2896 2412 2413 1.712 0.8 13.696 37
I2413 2413 0 1.24921e-03
R2897 2413 2414 1.728 0.8 13.824 37
I2414 2414 0 1.27395e-03
R2898 2414 2415 1.648 0.8 13.184 37
I2415 2415 0 1.28631e-03
R2899 2415 2416 1.728 0.8 13.824 37
I2416 2416 0 1.31105e-03
R2900 2416 2417 1.712 0.8 13.696 37
I2417 2417 0 1.26158e-03
R2901 2417 2418 1.728 0.8 13.824 37
I2418 2418 0 1.33579e-03
R2902 2418 2419 1.744 0.8 13.952 37
I2419 2419 0 1.26158e-03
R2903 2419 2420 1.616 0.8 12.928 37
I2420 2420 0 1.23684e-03
R2904 2420 3001 2.5 0.8 20 37
*seg: 243
R2905 3001 2421 2.5 0.8 20 37
R2906 2425 2435 6.16 0.8 49.28 37
I2421 2421 0 1.33579e-03
R2907 2421 2422 1.744 0.8 13.952 37
I2422 2422 0 1.29868e-03
R2908 2422 2423 1.648 0.8 13.184 37
I2423 2423 0 1.24921e-03
R2909 2423 2424 1.728 0.8 13.824 37
I2424 2424 0 1.33579e-03
R2910 2424 2425 1.744 0.8 13.952 37
I2425 2425 0 1.34816e-03
R2911 2425 2426 1.616 0.8 12.928 37
I2426 2426 0 1.32342e-03
R2912 2426 2427 1.68 0.8 13.44 37
I2427 2427 0 1.23684e-03
R2913 2427 2428 1.696 0.8 13.568 37
I2428 2428 0 1.23684e-03
R2914 2428 2429 1.664 0.8 13.312 37
I2429 2429 0 1.31105e-03
R2915 2429 2430 1.664 0.8 13.312 37
I2430 2430 0 1.23684e-03
R2916 2430 3001 2.5 0.8 20 37
*seg: 244
R2917 3001 2431 2.5 0.8 20 37
R2918 2435 2445 6.16 0.8 49.28 37
I2431 2431 0 1.31105e-03
R2919 2431 2432 1.616 0.8 12.928 37
I2432 2432 0 1.33579e-03
R2920 2432 2433 1.632 0.8 13.056 37
I2433 2433 0 1.29868e-03
R2921 2433 2434 1.632 0.8 13.056 37
I2434 2434 0 1.23684e-03
R2922 2434 2435 1.632 0.8 13.056 37
I2435 2435 0 1.23684e-03
R2923 2435 2436 1.648 0.8 13.184 37
I2436 2436 0 1.28631e-03
R2924 2436 2437 1.648 0.8 13.184 37
I2437 2437 0 1.31105e-03
R2925 2437 2438 1.696 0.8 13.568 37
I2438 2438 0 1.32342e-03
R2926 2438 2439 1.6 0.8 12.8 37
I2439 2439 0 1.34816e-03
R2927 2439 2440 1.664 0.8 13.312 37
I2440 2440 0 1.23684e-03
R2928 2440 3001 2.5 0.8 20 37
*seg: 245
R2929 3001 2441 2.5 0.8 20 37
R2930 2445 2455 6.16 0.8 49.28 37
I2441 2441 0 1.23684e-03
R2931 2441 2442 1.664 0.8 13.312 37
I2442 2442 0 1.28631e-03
R2932 2442 2443 1.696 0.8 13.568 37
I2443 2443 0 1.26158e-03
R2933 2443 2444 1.632 0.8 13.056 37
I2444 2444 0 1.28631e-03
R2934 2444 2445 1.744 0.8 13.952 37
I2445 2445 0 1.24921e-03
R2935 2445 2446 1.744 0.8 13.952 37
I2446 2446 0 1.33579e-03
R2936 2446 2447 1.616 0.8 12.928 37
I2447 2447 0 1.27395e-03
R2937 2447 2448 1.664 0.8 13.312 37
I2448 2448 0 1.24921e-03
R2938 2448 2449 1.616 0.8 12.928 37
I2449 2449 0 1.29868e-03
R2939 2449 2450 1.664 0.8 13.312 37
I2450 2450 0 1.23684e-03
R2940 2450 3001 2.5 0.8 20 37
*seg: 246
R2941 3001 2451 2.5 0.8 20 37
R2942 2455 2465 6.16 0.8 49.28 37
I2451 2451 0 1.34816e-03
R2943 2451 2452 1.744 0.8 13.952 37
I2452 2452 0 1.28631e-03
R2944 2452 2453 1.648 0.8 13.184 37
I2453 2453 0 1.32342e-03
R2945 2453 2454 1.744 0.8 13.952 37
I2454 2454 0 1.34816e-03
R2946 2454 2455 1.616 0.8 12.928 37
I2455 2455 0 1.32342e-03
R2947 2455 2456 1.696 0.8 13.568 37
I2456 2456 0 1.33579e-03
R2948 2456 2457 1.68 0.8 13.44 37
I2457 2457 0 1.32342e-03
R2949 2457 2458 1.616 0.8 12.928 37
I2458 2458 0 1.27395e-03
R2950 2458 2459 1.68 0.8 13.44 37
I2459 2459 0 1.34816e-03
R2951 2459 2460 1.728 0.8 13.824 37
I2460 2460 0 1.23684e-03
R2952 2460 3001 2.5 0.8 20 37
*seg: 247
R2953 3001 2461 2.5 0.8 20 37
R2954 2465 2475 6.16 0.8 49.28 37
I2461 2461 0 1.23684e-03
R2955 2461 2462 1.744 0.8 13.952 37
I2462 2462 0 1.26158e-03
R2956 2462 2463 1.68 0.8 13.44 37
I2463 2463 0 1.24921e-03
R2957 2463 2464 1.664 0.8 13.312 37
I2464 2464 0 1.29868e-03
R2958 2464 2465 1.664 0.8 13.312 37
I2465 2465 0 1.24921e-03
R2959 2465 2466 1.696 0.8 13.568 37
I2466 2466 0 1.31105e-03
R2960 2466 2467 1.632 0.8 13.056 37
I2467 2467 0 1.32342e-03
R2961 2467 2468 1.6 0.8 12.8 37
I2468 2468 0 1.23684e-03
R2962 2468 2469 1.616 0.8 12.928 37
I2469 2469 0 1.33579e-03
R2963 2469 2470 1.68 0.8 13.44 37
I2470 2470 0 1.23684e-03
R2964 2470 3001 2.5 0.8 20 37
*seg: 248
R2965 3001 2471 2.5 0.8 20 37
R2966 2475 2485 6.16 0.8 49.28 37
I2471 2471 0 1.31105e-03
R2967 2471 2472 1.728 0.8 13.824 37
I2472 2472 0 1.32342e-03
R2968 2472 2473 1.648 0.8 13.184 37
I2473 2473 0 1.24921e-03
R2969 2473 2474 1.744 0.8 13.952 37
I2474 2474 0 1.34816e-03
R2970 2474 2475 1.6 0.8 12.8 37
I2475 2475 0 1.34816e-03
R2971 2475 2476 1.664 0.8 13.312 37
I2476 2476 0 1.29868e-03
R2972 2476 2477 1.664 0.8 13.312 37
I2477 2477 0 1.28631e-03
R2973 2477 2478 1.616 0.8 12.928 37
I2478 2478 0 1.28631e-03
R2974 2478 2479 1.744 0.8 13.952 37
I2479 2479 0 1.34816e-03
R2975 2479 2480 1.744 0.8 13.952 37
I2480 2480 0 1.23684e-03
R2976 2480 3001 2.5 0.8 20 37
*seg: 249
R2977 3001 2481 2.5 0.8 20 37
R2978 2485 2495 6.16 0.8 49.28 37
I2481 2481 0 1.33579e-03
R2979 2481 2482 1.744 0.8 13.952 37
I2482 2482 0 1.23684e-03
R2980 2482 2483 1.728 0.8 13.824 37
I2483 2483 0 1.23684e-03
R2981 2483 2484 1.712 0.8 13.696 37
I2484 2484 0 1.34816e-03
R2982 2484 2485 1.696 0.8 13.568 37
I2485 2485 0 1.33579e-03
R2983 2485 2486 1.664 0.8 13.312 37
I2486 2486 0 1.28631e-03
R2984 2486 2487 1.696 0.8 13.568 37
I2487 2487 0 1.32342e-03
R2985 2487 2488 1.616 0.8 12.928 37
I2488 2488 0 1.23684e-03
R2986 2488 2489 1.664 0.8 13.312 37
I2489 2489 0 1.33579e-03
R2987 2489 2490 1.728 0.8 13.824 37
I2490 2490 0 1.23684e-03
R2988 2490 3001 2.5 0.8 20 37
*seg: 250
R2989 3001 2491 2.5 0.8 20 37
R2990 2495 2505 6.16 0.8 49.28 37
I2491 2491 0 1.27395e-03
R2991 2491 2492 1.6 0.8 12.8 37
I2492 2492 0 1.29868e-03
R2992 2492 2493 1.6 0.8 12.8 37
I2493 2493 0 1.27395e-03
R2993 2493 2494 1.68 0.8 13.44 37
I2494 2494 0 1.26158e-03
R2994 2494 2495 1.664 0.8 13.312 37
I2495 2495 0 1.28631e-03
R2995 2495 2496 1.744 0.8 13.952 37
I2496 2496 0 1.33579e-03
R2996 2496 2497 1.664 0.8 13.312 37
I2497 2497 0 1.23684e-03
R2997 2497 2498 1.648 0.8 13.184 37
I2498 2498 0 1.29868e-03
R2998 2498 2499 1.744 0.8 13.952 37
I2499 2499 0 1.34816e-03
R2999 2499 2500 1.616 0.8 12.928 37
I2500 2500 0 1.23684e-03
R3000 2500 3001 2.5 0.8 20 37
*seg: 251
R3001 3001 2501 2.5 0.8 20 37
R3002 2505 2515 6.16 0.8 49.28 37
I2501 2501 0 1.27395e-03
R3003 2501 2502 1.712 0.8 13.696 37
I2502 2502 0 1.28631e-03
R3004 2502 2503 1.68 0.8 13.44 37
I2503 2503 0 1.33579e-03
R3005 2503 2504 1.68 0.8 13.44 37
I2504 2504 0 1.29868e-03
R3006 2504 2505 1.728 0.8 13.824 37
I2505 2505 0 1.32342e-03
R3007 2505 2506 1.696 0.8 13.568 37
I2506 2506 0 1.34816e-03
R3008 2506 2507 1.712 0.8 13.696 37
I2507 2507 0 1.32342e-03
R3009 2507 2508 1.68 0.8 13.44 37
I2508 2508 0 1.34816e-03
R3010 2508 2509 1.712 0.8 13.696 37
I2509 2509 0 1.29868e-03
R3011 2509 2510 1.68 0.8 13.44 37
I2510 2510 0 1.23684e-03
R3012 2510 3001 2.5 0.8 20 37
*seg: 252
R3013 3001 2511 2.5 0.8 20 37
R3014 2515 2525 6.16 0.8 49.28 37
I2511 2511 0 1.34816e-03
R3015 2511 2512 1.616 0.8 12.928 37
I2512 2512 0 1.23684e-03
R3016 2512 2513 1.712 0.8 13.696 37
I2513 2513 0 1.24921e-03
R3017 2513 2514 1.616 0.8 12.928 37
I2514 2514 0 1.23684e-03
R3018 2514 2515 1.68 0.8 13.44 37
I2515 2515 0 1.23684e-03
R3019 2515 2516 1.744 0.8 13.952 37
I2516 2516 0 1.28631e-03
R3020 2516 2517 1.728 0.8 13.824 37
I2517 2517 0 1.24921e-03
R3021 2517 2518 1.696 0.8 13.568 37
I2518 2518 0 1.27395e-03
R3022 2518 2519 1.648 0.8 13.184 37
I2519 2519 0 1.29868e-03
R3023 2519 2520 1.68 0.8 13.44 37
I2520 2520 0 1.23684e-03
R3024 2520 3001 2.5 0.8 20 37
*seg: 253
R3025 3001 2521 2.5 0.8 20 37
R3026 2525 2535 6.16 0.8 49.28 37
I2521 2521 0 1.23684e-03
R3027 2521 2522 1.632 0.8 13.056 37
I2522 2522 0 1.27395e-03
R3028 2522 2523 1.712 0.8 13.696 37
I2523 2523 0 1.29868e-03
R3029 2523 2524 1.712 0.8 13.696 37
I2524 2524 0 1.24921e-03
R3030 2524 2525 1.6 0.8 12.8 37
I2525 2525 0 1.27395e-03
R3031 2525 2526 1.68 0.8 13.44 37
I2526 2526 0 1.28631e-03
R3032 2526 2527 1.632 0.8 13.056 37
I2527 2527 0 1.29868e-03
R3033 2527 2528 1.648 0.8 13.184 37
I2528 2528 0 1.24921e-03
R3034 2528 2529 1.744 0.8 13.952 37
I2529 2529 0 1.28631e-03
R3035 2529 2530 1.68 0.8 13.44 37
I2530 2530 0 1.23684e-03
R3036 2530 3001 2.5 0.8 20 37
*seg: 254
R3037 3001 2531 2.5 0.8 20 37
R3038 2535 2545 6.16 0.8 49.28 37
I2531 2531 0 1.34816e-03
R3039 2531 2532 1.664 0.8 13.312 37
I2532 2532 0 1.34816e-03
R3040 2532 2533 1.648 0.8 13.184 37
I2533 2533 0 1.32342e-03
R3041 2533 2534 1.712 0.8 13.696 37
I2534 2534 0 1.24921e-03
R3042 2534 2535 1.712 0.8 13.696 37
I2535 2535 0 1.33579e-03
R3043 2535 2536 1.616 0.8 12.928 37
I2536 2536 0 1.28631e-03
R3044 2536 2537 1.648 0.8 13.184 37
I2537 2537 0 1.32342e-03
R3045 2537 2538 1.616 0.8 12.928 37
I2538 2538 0 1.23684e-03
R3046 2538 2539 1.6 0.8 12.8 37
I2539 2539 0 1.34816e-03
R3047 2539 2540 1.6 0.8 12.8 37
I2540 2540 0 1.23684e-03
R3048 2540 3001 2.5 0.8 20 37
*seg: 255
R3049 3001 2541 2.5 0.8 20 37
R3050 2545 2555 6.16 0.8 49.28 37
I2541 2541 0 1.27395e-03
R3051 2541 2542 1.712 0.8 13.696 37
I2542 2542 0 1.24921e-03
R3052 2542 2543 1.648 0.8 13.184 37
I2543 2543 0 1.24921e-03
R3053 2543 2544 1.68 0.8 13.44 37
I2544 2544 0 1.27395e-03
R3054 2544 2545 1.616 0.8 12.928 37
I2545 2545 0 1.34816e-03
R3055 2545 2546 1.728 0.8 13.824 37
I2546 2546 0 1.27395e-03
R3056 2546 2547 1.744 0.8 13.952 37
I2547 2547 0 1.31105e-03
R3057 2547 2548 1.616 0.8 12.928 37
I2548 2548 0 1.33579e-03
R3058 2548 2549 1.696 0.8 13.568 37
I2549 2549 0 1.32342e-03
R3059 2549 2550 1.712 0.8 13.696 37
I2550 2550 0 1.23684e-03
R3060 2550 3001 2.5 0.8 20 37
*seg: 256
R3061 3001 2551 2.5 0.8 20 37
R3062 2555 2565 6.16 0.8 49.28 37
I2551 2551 0 1.29868e-03
R3063 2551 2552 1.728 0.8 13.824 37
I2552 2552 0 1.27395e-03
R3064 2552 2553 1.696 0.8 13.568 37
I2553 2553 0 1.34816e-03
R3065 2553 2554 1.6 0.8 12.8 37
I2554 2554 0 1.33579e-03
R3066 2554 2555 1.68 0.8 13.44 37
I2555 2555 0 1.29868e-03
R3067 2555 2556 1.744 0.8 13.952 37
I2556 2556 0 1.33579e-03
R3068 2556 2557 1.664 0.8 13.312 37
I2557 2557 0 1.23684e-03
R3069 2557 2558 1.696 0.8 13.568 37
I2558 2558 0 1.24921e-03
R3070 2558 2559 1.632 0.8 13.056 37
I2559 2559 0 1.31105e-03
R3071 2559 2560 1.712 0.8 13.696 37
I2560 2560 0 1.23684e-03
R3072 2560 3001 2.5 0.8 20 37
*seg: 257
R3073 3001 2561 2.5 0.8 20 37
R3074 2565 2575 6.16 0.8 49.28 37
I2561 2561 0 1.33579e-03
R3075 2561 2562 1.68 0.8 13.44 37
I2562 2562 0 1.26158e-03
R3076 2562 2563 1.728 0.8 13.824 37
I2563 2563 0 1.28631e-03
R3077 2563 2564 1.648 0.8 13.184 37
I2564 2564 0 1.31105e-03
R3078 2564 2565 1.728 0.8 13.824 37
I2565 2565 0 1.32342e-03
R3079 2565 2566 1.744 0.8 13.952 37
I2566 2566 0 1.26158e-03
R3080 2566 2567 1.6 0.8 12.8 37
I2567 2567 0 1.34816e-03
R3081 2567 2568 1.632 0.8 13.056 37
I2568 2568 0 1.32342e-03
R3082 2568 2569 1.632 0.8 13.056 37
I2569 2569 0 1.24921e-03
R3083 2569 2570 1.696 0.8 13.568 37
I2570 2570 0 1.23684e-03
R3084 2570 3001 2.5 0.8 20 37
*seg: 258
R3085 3001 2571 2.5 0.8 20 37
R3086 2575 2585 6.16 0.8 49.28 37
I2571 2571 0 1.34816e-03
R3087 2571 2572 1.712 0.8 13.696 37
I2572 2572 0 1.31105e-03
R3088 2572 2573 1.632 0.8 13.056 37
I2573 2573 0 1.23684e-03
R3089 2573 2574 1.712 0.8 13.696 37
I2574 2574 0 1.27395e-03
R3090 2574 2575 1.744 0.8 13.952 37
I2575 2575 0 1.34816e-03
R3091 2575 2576 1.68 0.8 13.44 37
I2576 2576 0 1.31105e-03
R3092 2576 2577 1.744 0.8 13.952 37
I2577 2577 0 1.29868e-03
R3093 2577 2578 1.744 0.8 13.952 37
I2578 2578 0 1.24921e-03
R3094 2578 2579 1.728 0.8 13.824 37
I2579 2579 0 1.28631e-03
R3095 2579 2580 1.648 0.8 13.184 37
I2580 2580 0 1.23684e-03
R3096 2580 3001 2.5 0.8 20 37
*seg: 259
R3097 3001 2581 2.5 0.8 20 37
R3098 2585 2595 6.16 0.8 49.28 37
I2581 2581 0 1.28631e-03
R3099 2581 2582 1.6 0.8 12.8 37
I2582 2582 0 1.32342e-03
R3100 2582 2583 1.728 0.8 13.824 37
I2583 2583 0 1.34816e-03
R3101 2583 2584 1.728 0.8 13.824 37
I2584 2584 0 1.27395e-03
R3102 2584 2585 1.632 0.8 13.056 37
I2585 2585 0 1.32342e-03
R3103 2585 2586 1.712 0.8 13.696 37
I2586 2586 0 1.23684e-03
R3104 2586 2587 1.68 0.8 13.44 37
I2587 2587 0 1.32342e-03
R3105 2587 2588 1.632 0.8 13.056 37
I2588 2588 0 1.23684e-03
R3106 2588 2589 1.632 0.8 13.056 37
I2589 2589 0 1.28631e-03
R3107 2589 2590 1.68 0.8 13.44 37
I2590 2590 0 1.23684e-03
R3108 2590 3001 2.5 0.8 20 37
*seg: 260
R3109 3001 2591 2.5 0.8 20 37
R3110 2595 2605 6.16 0.8 49.28 37
I2591 2591 0 1.33579e-03
R3111 2591 2592 1.68 0.8 13.44 37
I2592 2592 0 1.34816e-03
R3112 2592 2593 1.728 0.8 13.824 37
I2593 2593 0 1.26158e-03
R3113 2593 2594 1.6 0.8 12.8 37
I2594 2594 0 1.28631e-03
R3114 2594 2595 1.616 0.8 12.928 37
I2595 2595 0 1.23684e-03
R3115 2595 2596 1.648 0.8 13.184 37
I2596 2596 0 1.26158e-03
R3116 2596 2597 1.632 0.8 13.056 37
I2597 2597 0 1.28631e-03
R3117 2597 2598 1.728 0.8 13.824 37
I2598 2598 0 1.32342e-03
R3118 2598 2599 1.648 0.8 13.184 37
I2599 2599 0 1.29868e-03
R3119 2599 2600 1.744 0.8 13.952 37
I2600 2600 0 1.23684e-03
R3120 2600 3001 2.5 0.8 20 37
*seg: 261
R3121 3001 2601 2.5 0.8 20 37
R3122 2605 2615 6.16 0.8 49.28 37
I2601 2601 0 1.26158e-03
R3123 2601 2602 1.696 0.8 13.568 37
I2602 2602 0 1.24921e-03
R3124 2602 2603 1.728 0.8 13.824 37
I2603 2603 0 1.27395e-03
R3125 2603 2604 1.616 0.8 12.928 37
I2604 2604 0 1.33579e-03
R3126 2604 2605 1.744 0.8 13.952 37
I2605 2605 0 1.27395e-03
R3127 2605 2606 1.648 0.8 13.184 37
I2606 2606 0 1.24921e-03
R3128 2606 2607 1.632 0.8 13.056 37
I2607 2607 0 1.28631e-03
R3129 2607 2608 1.648 0.8 13.184 37
I2608 2608 0 1.34816e-03
R3130 2608 2609 1.712 0.8 13.696 37
I2609 2609 0 1.33579e-03
R3131 2609 2610 1.728 0.8 13.824 37
I2610 2610 0 1.23684e-03
R3132 2610 3001 2.5 0.8 20 37
*seg: 262
R3133 3001 2611 2.5 0.8 20 37
R3134 2615 2625 6.16 0.8 49.28 37
I2611 2611 0 1.24921e-03
R3135 2611 2612 1.648 0.8 13.184 37
I2612 2612 0 1.31105e-03
R3136 2612 2613 1.648 0.8 13.184 37
I2613 2613 0 1.34816e-03
R3137 2613 2614 1.744 0.8 13.952 37
I2614 2614 0 1.27395e-03
R3138 2614 2615 1.664 0.8 13.312 37
I2615 2615 0 1.28631e-03
R3139 2615 2616 1.744 0.8 13.952 37
I2616 2616 0 1.27395e-03
R3140 2616 2617 1.696 0.8 13.568 37
I2617 2617 0 1.33579e-03
R3141 2617 2618 1.712 0.8 13.696 37
I2618 2618 0 1.24921e-03
R3142 2618 2619 1.616 0.8 12.928 37
I2619 2619 0 1.23684e-03
R3143 2619 2620 1.728 0.8 13.824 37
I2620 2620 0 1.23684e-03
R3144 2620 3001 2.5 0.8 20 37
*seg: 263
R3145 3001 2621 2.5 0.8 20 37
R3146 2625 2635 6.16 0.8 49.28 37
I2621 2621 0 1.31105e-03
R3147 2621 2622 1.6 0.8 12.8 37
I2622 2622 0 1.28631e-03
R3148 2622 2623 1.632 0.8 13.056 37
I2623 2623 0 1.32342e-03
R3149 2623 2624 1.6 0.8 12.8 37
I2624 2624 0 1.29868e-03
R3150 2624 2625 1.712 0.8 13.696 37
I2625 2625 0 1.34816e-03
R3151 2625 2626 1.68 0.8 13.44 37
I2626 2626 0 1.23684e-03
R3152 2626 2627 1.744 0.8 13.952 37
I2627 2627 0 1.24921e-03
R3153 2627 2628 1.632 0.8 13.056 37
I2628 2628 0 1.24921e-03
R3154 2628 2629 1.664 0.8 13.312 37
I2629 2629 0 1.33579e-03
R3155 2629 2630 1.664 0.8 13.312 37
I2630 2630 0 1.23684e-03
R3156 2630 3001 2.5 0.8 20 37
*seg: 264
R3157 3001 2631 2.5 0.8 20 37
R3158 2635 2645 6.16 0.8 49.28 37
I2631 2631 0 1.26158e-03
R3159 2631 2632 1.616 0.8 12.928 37
I2632 2632 0 1.33579e-03
R3160 2632 2633 1.6 0.8 12.8 37
I2633 2633 0 1.34816e-03
R3161 2633 2634 1.712 0.8 13.696 37
I2634 2634 0 1.24921e-03
R3162 2634 2635 1.728 0.8 13.824 37
I2635 2635 0 1.28631e-03
R3163 2635 2636 1.6 0.8 12.8 37
I2636 2636 0 1.33579e-03
R3164 2636 2637 1.744 0.8 13.952 37
I2637 2637 0 1.23684e-03
R3165 2637 2638 1.696 0.8 13.568 37
I2638 2638 0 1.31105e-03
R3166 2638 2639 1.648 0.8 13.184 37
I2639 2639 0 1.27395e-03
R3167 2639 2640 1.696 0.8 13.568 37
I2640 2640 0 1.23684e-03
R3168 2640 3001 2.5 0.8 20 37
*seg: 265
R3169 3001 2641 2.5 0.8 20 37
R3170 2645 2655 6.16 0.8 49.28 37
I2641 2641 0 1.34816e-03
R3171 2641 2642 1.712 0.8 13.696 37
I2642 2642 0 1.26158e-03
R3172 2642 2643 1.696 0.8 13.568 37
I2643 2643 0 1.24921e-03
R3173 2643 2644 1.68 0.8 13.44 37
I2644 2644 0 1.33579e-03
R3174 2644 2645 1.744 0.8 13.952 37
I2645 2645 0 1.27395e-03
R3175 2645 2646 1.632 0.8 13.056 37
I2646 2646 0 1.29868e-03
R3176 2646 2647 1.616 0.8 12.928 37
I2647 2647 0 1.23684e-03
R3177 2647 2648 1.712 0.8 13.696 37
I2648 2648 0 1.29868e-03
R3178 2648 2649 1.744 0.8 13.952 37
I2649 2649 0 1.31105e-03
R3179 2649 2650 1.712 0.8 13.696 37
I2650 2650 0 1.23684e-03
R3180 2650 3001 2.5 0.8 20 37
*seg: 266
R3181 3001 2651 2.5 0.8 20 37
R3182 2655 2665 6.16 0.8 49.28 37
I2651 2651 0 1.28631e-03
R3183 2651 2652 1.632 0.8 13.056 37
I2652 2652 0 1.34816e-03
R3184 2652 2653 1.696 0.8 13.568 37
I2653 2653 0 1.33579e-03
R3185 2653 2654 1.696 0.8 13.568 37
I2654 2654 0 1.31105e-03
R3186 2654 2655 1.664 0.8 13.312 37
I2655 2655 0 1.33579e-03
R3187 2655 2656 1.696 0.8 13.568 37
I2656 2656 0 1.34816e-03
R3188 2656 2657 1.632 0.8 13.056 37
I2657 2657 0 1.32342e-03
R3189 2657 2658 1.616 0.8 12.928 37
I2658 2658 0 1.31105e-03
R3190 2658 2659 1.68 0.8 13.44 37
I2659 2659 0 1.28631e-03
R3191 2659 2660 1.6 0.8 12.8 37
I2660 2660 0 1.23684e-03
R3192 2660 3001 2.5 0.8 20 37
*seg: 267
R3193 3001 2661 2.5 0.8 20 37
R3194 2665 2675 6.16 0.8 49.28 37
I2661 2661 0 1.33579e-03
R3195 2661 2662 1.648 0.8 13.184 37
I2662 2662 0 1.33579e-03
R3196 2662 2663 1.728 0.8 13.824 37
I2663 2663 0 1.31105e-03
R3197 2663 2664 1.744 0.8 13.952 37
I2664 2664 0 1.29868e-03
R3198 2664 2665 1.696 0.8 13.568 37
I2665 2665 0 1.29868e-03
R3199 2665 2666 1.744 0.8 13.952 37
I2666 2666 0 1.33579e-03
R3200 2666 2667 1.664 0.8 13.312 37
I2667 2667 0 1.29868e-03
R3201 2667 2668 1.664 0.8 13.312 37
I2668 2668 0 1.34816e-03
R3202 2668 2669 1.728 0.8 13.824 37
I2669 2669 0 1.34816e-03
R3203 2669 2670 1.68 0.8 13.44 37
I2670 2670 0 1.23684e-03
R3204 2670 3001 2.5 0.8 20 37
*seg: 268
R3205 3001 2671 2.5 0.8 20 37
R3206 2675 2685 6.16 0.8 49.28 37
I2671 2671 0 1.34816e-03
R3207 2671 2672 1.696 0.8 13.568 37
I2672 2672 0 1.34816e-03
R3208 2672 2673 1.712 0.8 13.696 37
I2673 2673 0 1.34816e-03
R3209 2673 2674 1.696 0.8 13.568 37
I2674 2674 0 1.28631e-03
R3210 2674 2675 1.744 0.8 13.952 37
I2675 2675 0 1.34816e-03
R3211 2675 2676 1.632 0.8 13.056 37
I2676 2676 0 1.32342e-03
R3212 2676 2677 1.696 0.8 13.568 37
I2677 2677 0 1.32342e-03
R3213 2677 2678 1.648 0.8 13.184 37
I2678 2678 0 1.32342e-03
R3214 2678 2679 1.68 0.8 13.44 37
I2679 2679 0 1.26158e-03
R3215 2679 2680 1.648 0.8 13.184 37
I2680 2680 0 1.23684e-03
R3216 2680 3001 2.5 0.8 20 37
*seg: 269
R3217 3001 2681 2.5 0.8 20 37
R3218 2685 2695 6.16 0.8 49.28 37
I2681 2681 0 1.31105e-03
R3219 2681 2682 1.664 0.8 13.312 37
I2682 2682 0 1.28631e-03
R3220 2682 2683 1.696 0.8 13.568 37
I2683 2683 0 1.34816e-03
R3221 2683 2684 1.696 0.8 13.568 37
I2684 2684 0 1.34816e-03
R3222 2684 2685 1.696 0.8 13.568 37
I2685 2685 0 1.32342e-03
R3223 2685 2686 1.696 0.8 13.568 37
I2686 2686 0 1.29868e-03
R3224 2686 2687 1.616 0.8 12.928 37
I2687 2687 0 1.33579e-03
R3225 2687 2688 1.664 0.8 13.312 37
I2688 2688 0 1.29868e-03
R3226 2688 2689 1.6 0.8 12.8 37
I2689 2689 0 1.29868e-03
R3227 2689 2690 1.616 0.8 12.928 37
I2690 2690 0 1.23684e-03
R3228 2690 3001 2.5 0.8 20 37
*seg: 270
R3229 3001 2691 2.5 0.8 20 37
R3230 2695 2705 6.16 0.8 49.28 37
I2691 2691 0 1.23684e-03
R3231 2691 2692 1.6 0.8 12.8 37
I2692 2692 0 1.29868e-03
R3232 2692 2693 1.68 0.8 13.44 37
I2693 2693 0 1.28631e-03
R3233 2693 2694 1.744 0.8 13.952 37
I2694 2694 0 1.23684e-03
R3234 2694 2695 1.68 0.8 13.44 37
I2695 2695 0 1.34816e-03
R3235 2695 2696 1.648 0.8 13.184 37
I2696 2696 0 1.24921e-03
R3236 2696 2697 1.664 0.8 13.312 37
I2697 2697 0 1.26158e-03
R3237 2697 2698 1.664 0.8 13.312 37
I2698 2698 0 1.32342e-03
R3238 2698 2699 1.632 0.8 13.056 37
I2699 2699 0 1.32342e-03
R3239 2699 2700 1.744 0.8 13.952 37
I2700 2700 0 1.23684e-03
R3240 2700 3001 2.5 0.8 20 37
*seg: 271
R3241 3001 2701 2.5 0.8 20 37
R3242 2705 2715 6.16 0.8 49.28 37
I2701 2701 0 1.28631e-03
R3243 2701 2702 1.68 0.8 13.44 37
I2702 2702 0 1.31105e-03
R3244 2702 2703 1.68 0.8 13.44 37
I2703 2703 0 1.32342e-03
R3245 2703 2704 1.728 0.8 13.824 37
I2704 2704 0 1.26158e-03
R3246 2704 2705 1.616 0.8 12.928 37
I2705 2705 0 1.27395e-03
R3247 2705 2706 1.712 0.8 13.696 37
I2706 2706 0 1.34816e-03
R3248 2706 2707 1.616 0.8 12.928 37
I2707 2707 0 1.27395e-03
R3249 2707 2708 1.632 0.8 13.056 37
I2708 2708 0 1.27395e-03
R3250 2708 2709 1.68 0.8 13.44 37
I2709 2709 0 1.33579e-03
R3251 2709 2710 1.648 0.8 13.184 37
I2710 2710 0 1.23684e-03
R3252 2710 3001 2.5 0.8 20 37
*seg: 272
R3253 3001 2711 2.5 0.8 20 37
R3254 2715 2725 6.16 0.8 49.28 37
I2711 2711 0 1.26158e-03
R3255 2711 2712 1.616 0.8 12.928 37
I2712 2712 0 1.32342e-03
R3256 2712 2713 1.728 0.8 13.824 37
I2713 2713 0 1.23684e-03
R3257 2713 2714 1.6 0.8 12.8 37
I2714 2714 0 1.33579e-03
R3258 2714 2715 1.728 0.8 13.824 37
I2715 2715 0 1.31105e-03
R3259 2715 2716 1.696 0.8 13.568 37
I2716 2716 0 1.32342e-03
R3260 2716 2717 1.632 0.8 13.056 37
I2717 2717 0 1.23684e-03
R3261 2717 2718 1.6 0.8 12.8 37
I2718 2718 0 1.24921e-03
R3262 2718 2719 1.728 0.8 13.824 37
I2719 2719 0 1.29868e-03
R3263 2719 2720 1.6 0.8 12.8 37
I2720 2720 0 1.23684e-03
R3264 2720 3001 2.5 0.8 20 37
*seg: 273
R3265 3001 2721 2.5 0.8 20 37
R3266 2725 2735 6.16 0.8 49.28 37
I2721 2721 0 1.26158e-03
R3267 2721 2722 1.632 0.8 13.056 37
I2722 2722 0 1.24921e-03
R3268 2722 2723 1.6 0.8 12.8 37
I2723 2723 0 1.23684e-03
R3269 2723 2724 1.664 0.8 13.312 37
I2724 2724 0 1.33579e-03
R3270 2724 2725 1.6 0.8 12.8 37
I2725 2725 0 1.27395e-03
R3271 2725 2726 1.648 0.8 13.184 37
I2726 2726 0 1.31105e-03
R3272 2726 2727 1.616 0.8 12.928 37
I2727 2727 0 1.31105e-03
R3273 2727 2728 1.68 0.8 13.44 37
I2728 2728 0 1.31105e-03
R3274 2728 2729 1.744 0.8 13.952 37
I2729 2729 0 1.31105e-03
R3275 2729 2730 1.632 0.8 13.056 37
I2730 2730 0 1.23684e-03
R3276 2730 3001 2.5 0.8 20 37
*seg: 274
R3277 3001 2731 2.5 0.8 20 37
R3278 2735 2745 6.16 0.8 49.28 37
I2731 2731 0 1.31105e-03
R3279 2731 2732 1.632 0.8 13.056 37
I2732 2732 0 1.23684e-03
R3280 2732 2733 1.68 0.8 13.44 37
I2733 2733 0 1.34816e-03
R3281 2733 2734 1.712 0.8 13.696 37
I2734 2734 0 1.33579e-03
R3282 2734 2735 1.664 0.8 13.312 37
I2735 2735 0 1.26158e-03
R3283 2735 2736 1.6 0.8 12.8 37
I2736 2736 0 1.31105e-03
R3284 2736 2737 1.728 0.8 13.824 37
I2737 2737 0 1.27395e-03
R3285 2737 2738 1.68 0.8 13.44 37
I2738 2738 0 1.28631e-03
R3286 2738 2739 1.68 0.8 13.44 37
I2739 2739 0 1.27395e-03
R3287 2739 2740 1.632 0.8 13.056 37
I2740 2740 0 1.23684e-03
R3288 2740 3001 2.5 0.8 20 37
*seg: 275
R3289 3001 2741 2.5 0.8 20 37
R3290 2745 2755 6.16 0.8 49.28 37
I2741 2741 0 1.24921e-03
R3291 2741 2742 1.6 0.8 12.8 37
I2742 2742 0 1.33579e-03
R3292 2742 2743 1.68 0.8 13.44 37
I2743 2743 0 1.24921e-03
R3293 2743 2744 1.696 0.8 13.568 37
I2744 2744 0 1.33579e-03
R3294 2744 2745 1.712 0.8 13.696 37
I2745 2745 0 1.24921e-03
R3295 2745 2746 1.648 0.8 13.184 37
I2746 2746 0 1.34816e-03
R3296 2746 2747 1.68 0.8 13.44 37
I2747 2747 0 1.23684e-03
R3297 2747 2748 1.728 0.8 13.824 37
I2748 2748 0 1.29868e-03
R3298 2748 2749 1.6 0.8 12.8 37
I2749 2749 0 1.34816e-03
R3299 2749 2750 1.68 0.8 13.44 37
I2750 2750 0 1.23684e-03
R3300 2750 3001 2.5 0.8 20 37
*seg: 276
R3301 3001 2751 2.5 0.8 20 37
R3302 2755 2765 6.16 0.8 49.28 37
I2751 2751 0 1.33579e-03
R3303 2751 2752 1.648 0.8 13.184 37
I2752 2752 0 1.33579e-03
R3304 2752 2753 1.68 0.8 13.44 37
I2753 2753 0 1.33579e-03
R3305 2753 2754 1.744 0.8 13.952 37
I2754 2754 0 1.29868e-03
R3306 2754 2755 1.68 0.8 13.44 37
I2755 2755 0 1.32342e-03
R3307 2755 2756 1.6 0.8 12.8 37
I2756 2756 0 1.34816e-03
R3308 2756 2757 1.6 0.8 12.8 37
I2757 2757 0 1.28631e-03
R3309 2757 2758 1.632 0.8 13.056 37
I2758 2758 0 1.29868e-03
R3310 2758 2759 1.68 0.8 13.44 37
I2759 2759 0 1.26158e-03
R3311 2759 2760 1.696 0.8 13.568 37
I2760 2760 0 1.23684e-03
R3312 2760 3001 2.5 0.8 20 37
*seg: 277
R3313 3001 2761 2.5 0.8 20 37
R3314 2765 2775 6.16 0.8 49.28 37
I2761 2761 0 1.34816e-03
R3315 2761 2762 1.712 0.8 13.696 37
I2762 2762 0 1.31105e-03
R3316 2762 2763 1.6 0.8 12.8 37
I2763 2763 0 1.28631e-03
R3317 2763 2764 1.696 0.8 13.568 37
I2764 2764 0 1.34816e-03
R3318 2764 2765 1.616 0.8 12.928 37
I2765 2765 0 1.23684e-03
R3319 2765 2766 1.6 0.8 12.8 37
I2766 2766 0 1.27395e-03
R3320 2766 2767 1.744 0.8 13.952 37
I2767 2767 0 1.32342e-03
R3321 2767 2768 1.616 0.8 12.928 37
I2768 2768 0 1.31105e-03
R3322 2768 2769 1.632 0.8 13.056 37
I2769 2769 0 1.29868e-03
R3323 2769 2770 1.68 0.8 13.44 37
I2770 2770 0 1.23684e-03
R3324 2770 3001 2.5 0.8 20 37
*seg: 278
R3325 3001 2771 2.5 0.8 20 37
R3326 2775 2785 6.16 0.8 49.28 37
I2771 2771 0 1.26158e-03
R3327 2771 2772 1.68 0.8 13.44 37
I2772 2772 0 1.32342e-03
R3328 2772 2773 1.712 0.8 13.696 37
I2773 2773 0 1.28631e-03
R3329 2773 2774 1.616 0.8 12.928 37
I2774 2774 0 1.33579e-03
R3330 2774 2775 1.6 0.8 12.8 37
I2775 2775 0 1.34816e-03
R3331 2775 2776 1.648 0.8 13.184 37
I2776 2776 0 1.33579e-03
R3332 2776 2777 1.6 0.8 12.8 37
I2777 2777 0 1.24921e-03
R3333 2777 2778 1.616 0.8 12.928 37
I2778 2778 0 1.26158e-03
R3334 2778 2779 1.696 0.8 13.568 37
I2779 2779 0 1.27395e-03
R3335 2779 2780 1.68 0.8 13.44 37
I2780 2780 0 1.23684e-03
R3336 2780 3001 2.5 0.8 20 37
*seg: 279
R3337 3001 2781 2.5 0.8 20 37
R3338 2785 2795 6.16 0.8 49.28 37
I2781 2781 0 1.24921e-03
R3339 2781 2782 1.664 0.8 13.312 37
I2782 2782 0 1.24921e-03
R3340 2782 2783 1.6 0.8 12.8 37
I2783 2783 0 1.31105e-03
R3341 2783 2784 1.712 0.8 13.696 37
I2784 2784 0 1.33579e-03
R3342 2784 2785 1.712 0.8 13.696 37
I2785 2785 0 1.27395e-03
R3343 2785 2786 1.648 0.8 13.184 37
I2786 2786 0 1.23684e-03
R3344 2786 2787 1.632 0.8 13.056 37
I2787 2787 0 1.29868e-03
R3345 2787 2788 1.68 0.8 13.44 37
I2788 2788 0 1.29868e-03
R3346 2788 2789 1.632 0.8 13.056 37
I2789 2789 0 1.23684e-03
R3347 2789 2790 1.664 0.8 13.312 37
I2790 2790 0 1.23684e-03
R3348 2790 3001 2.5 0.8 20 37
*seg: 280
R3349 3001 2791 2.5 0.8 20 37
R3350 2795 2805 6.16 0.8 49.28 37
I2791 2791 0 1.23684e-03
R3351 2791 2792 1.648 0.8 13.184 37
I2792 2792 0 1.29868e-03
R3352 2792 2793 1.616 0.8 12.928 37
I2793 2793 0 1.28631e-03
R3353 2793 2794 1.68 0.8 13.44 37
I2794 2794 0 1.28631e-03
R3354 2794 2795 1.632 0.8 13.056 37
I2795 2795 0 1.27395e-03
R3355 2795 2796 1.664 0.8 13.312 37
I2796 2796 0 1.27395e-03
R3356 2796 2797 1.648 0.8 13.184 37
I2797 2797 0 1.27395e-03
R3357 2797 2798 1.648 0.8 13.184 37
I2798 2798 0 1.23684e-03
R3358 2798 2799 1.632 0.8 13.056 37
I2799 2799 0 1.32342e-03
R3359 2799 2800 1.712 0.8 13.696 37
I2800 2800 0 1.23684e-03
R3360 2800 3001 2.5 0.8 20 37
*seg: 281
R3361 3001 2801 2.5 0.8 20 37
R3362 2805 2815 6.16 0.8 49.28 37
I2801 2801 0 1.28631e-03
R3363 2801 2802 1.616 0.8 12.928 37
I2802 2802 0 1.28631e-03
R3364 2802 2803 1.616 0.8 12.928 37
I2803 2803 0 1.31105e-03
R3365 2803 2804 1.664 0.8 13.312 37
I2804 2804 0 1.26158e-03
R3366 2804 2805 1.6 0.8 12.8 37
I2805 2805 0 1.31105e-03
R3367 2805 2806 1.616 0.8 12.928 37
I2806 2806 0 1.33579e-03
R3368 2806 2807 1.6 0.8 12.8 37
I2807 2807 0 1.27395e-03
R3369 2807 2808 1.616 0.8 12.928 37
I2808 2808 0 1.23684e-03
R3370 2808 2809 1.632 0.8 13.056 37
I2809 2809 0 1.33579e-03
R3371 2809 2810 1.712 0.8 13.696 37
I2810 2810 0 1.23684e-03
R3372 2810 3001 2.5 0.8 20 37
*seg: 282
R3373 3001 2811 2.5 0.8 20 37
R3374 2815 2825 6.16 0.8 49.28 37
I2811 2811 0 1.26158e-03
R3375 2811 2812 1.648 0.8 13.184 37
I2812 2812 0 1.26158e-03
R3376 2812 2813 1.6 0.8 12.8 37
I2813 2813 0 1.32342e-03
R3377 2813 2814 1.728 0.8 13.824 37
I2814 2814 0 1.23684e-03
R3378 2814 2815 1.744 0.8 13.952 37
I2815 2815 0 1.29868e-03
R3379 2815 2816 1.664 0.8 13.312 37
I2816 2816 0 1.23684e-03
R3380 2816 2817 1.712 0.8 13.696 37
I2817 2817 0 1.23684e-03
R3381 2817 2818 1.696 0.8 13.568 37
I2818 2818 0 1.28631e-03
R3382 2818 2819 1.648 0.8 13.184 37
I2819 2819 0 1.24921e-03
R3383 2819 2820 1.616 0.8 12.928 37
I2820 2820 0 1.23684e-03
R3384 2820 3001 2.5 0.8 20 37
*seg: 283
R3385 3001 2821 2.5 0.8 20 37
R3386 2825 2835 6.16 0.8 49.28 37
I2821 2821 0 1.31105e-03
R3387 2821 2822 1.632 0.8 13.056 37
I2822 2822 0 1.33579e-03
R3388 2822 2823 1.6 0.8 12.8 37
I2823 2823 0 1.34816e-03
R3389 2823 2824 1.632 0.8 13.056 37
I2824 2824 0 1.34816e-03
R3390 2824 2825 1.696 0.8 13.568 37
I2825 2825 0 1.31105e-03
R3391 2825 2826 1.632 0.8 13.056 37
I2826 2826 0 1.23684e-03
R3392 2826 2827 1.728 0.8 13.824 37
I2827 2827 0 1.29868e-03
R3393 2827 2828 1.632 0.8 13.056 37
I2828 2828 0 1.26158e-03
R3394 2828 2829 1.648 0.8 13.184 37
I2829 2829 0 1.28631e-03
R3395 2829 2830 1.68 0.8 13.44 37
I2830 2830 0 1.23684e-03
R3396 2830 3001 2.5 0.8 20 37
*seg: 284
R3397 3001 2831 2.5 0.8 20 37
R3398 2835 2845 6.16 0.8 49.28 37
I2831 2831 0 1.28631e-03
R3399 2831 2832 1.68 0.8 13.44 37
I2832 2832 0 1.27395e-03
R3400 2832 2833 1.728 0.8 13.824 37
I2833 2833 0 1.33579e-03
R3401 2833 2834 1.712 0.8 13.696 37
I2834 2834 0 1.34816e-03
R3402 2834 2835 1.6 0.8 12.8 37
I2835 2835 0 1.34816e-03
R3403 2835 2836 1.664 0.8 13.312 37
I2836 2836 0 1.34816e-03
R3404 2836 2837 1.648 0.8 13.184 37
I2837 2837 0 1.28631e-03
R3405 2837 2838 1.712 0.8 13.696 37
I2838 2838 0 1.32342e-03
R3406 2838 2839 1.632 0.8 13.056 37
I2839 2839 0 1.26158e-03
R3407 2839 2840 1.648 0.8 13.184 37
I2840 2840 0 1.23684e-03
R3408 2840 3001 2.5 0.8 20 37
*seg: 285
R3409 3001 2841 2.5 0.8 20 37
R3410 2845 2855 6.16 0.8 49.28 37
I2841 2841 0 1.34816e-03
R3411 2841 2842 1.744 0.8 13.952 37
I2842 2842 0 1.23684e-03
R3412 2842 2843 1.6 0.8 12.8 37
I2843 2843 0 1.24921e-03
R3413 2843 2844 1.744 0.8 13.952 37
I2844 2844 0 1.28631e-03
R3414 2844 2845 1.728 0.8 13.824 37
I2845 2845 0 1.32342e-03
R3415 2845 2846 1.632 0.8 13.056 37
I2846 2846 0 1.31105e-03
R3416 2846 2847 1.744 0.8 13.952 37
I2847 2847 0 1.28631e-03
R3417 2847 2848 1.712 0.8 13.696 37
I2848 2848 0 1.26158e-03
R3418 2848 2849 1.712 0.8 13.696 37
I2849 2849 0 1.29868e-03
R3419 2849 2850 1.632 0.8 13.056 37
I2850 2850 0 1.23684e-03
R3420 2850 3001 2.5 0.8 20 37
*seg: 286
R3421 3001 2851 2.5 0.8 20 37
R3422 2855 2865 6.16 0.8 49.28 37
I2851 2851 0 1.33579e-03
R3423 2851 2852 1.648 0.8 13.184 37
I2852 2852 0 1.33579e-03
R3424 2852 2853 1.664 0.8 13.312 37
I2853 2853 0 1.33579e-03
R3425 2853 2854 1.712 0.8 13.696 37
I2854 2854 0 1.29868e-03
R3426 2854 2855 1.664 0.8 13.312 37
I2855 2855 0 1.26158e-03
R3427 2855 2856 1.616 0.8 12.928 37
I2856 2856 0 1.31105e-03
R3428 2856 2857 1.712 0.8 13.696 37
I2857 2857 0 1.33579e-03
R3429 2857 2858 1.6 0.8 12.8 37
I2858 2858 0 1.33579e-03
R3430 2858 2859 1.616 0.8 12.928 37
I2859 2859 0 1.33579e-03
R3431 2859 2860 1.616 0.8 12.928 37
I2860 2860 0 1.23684e-03
R3432 2860 3001 2.5 0.8 20 37
*seg: 287
R3433 3001 2861 2.5 0.8 20 37
R3434 2865 2875 6.16 0.8 49.28 37
I2861 2861 0 1.27395e-03
R3435 2861 2862 1.632 0.8 13.056 37
I2862 2862 0 1.33579e-03
R3436 2862 2863 1.664 0.8 13.312 37
I2863 2863 0 1.24921e-03
R3437 2863 2864 1.632 0.8 13.056 37
I2864 2864 0 1.24921e-03
R3438 2864 2865 1.744 0.8 13.952 37
I2865 2865 0 1.34816e-03
R3439 2865 2866 1.616 0.8 12.928 37
I2866 2866 0 1.34816e-03
R3440 2866 2867 1.712 0.8 13.696 37
I2867 2867 0 1.31105e-03
R3441 2867 2868 1.616 0.8 12.928 37
I2868 2868 0 1.23684e-03
R3442 2868 2869 1.728 0.8 13.824 37
I2869 2869 0 1.27395e-03
R3443 2869 2870 1.6 0.8 12.8 37
I2870 2870 0 1.23684e-03
R3444 2870 3001 2.5 0.8 20 37
*seg: 288
R3445 3001 2871 2.5 0.8 20 37
R3446 2875 2885 6.16 0.8 49.28 37
I2871 2871 0 1.23684e-03
R3447 2871 2872 1.68 0.8 13.44 37
I2872 2872 0 1.33579e-03
R3448 2872 2873 1.712 0.8 13.696 37
I2873 2873 0 1.34816e-03
R3449 2873 2874 1.68 0.8 13.44 37
I2874 2874 0 1.29868e-03
R3450 2874 2875 1.728 0.8 13.824 37
I2875 2875 0 1.32342e-03
R3451 2875 2876 1.68 0.8 13.44 37
I2876 2876 0 1.33579e-03
R3452 2876 2877 1.712 0.8 13.696 37
I2877 2877 0 1.28631e-03
R3453 2877 2878 1.648 0.8 13.184 37
I2878 2878 0 1.31105e-03
R3454 2878 2879 1.696 0.8 13.568 37
I2879 2879 0 1.29868e-03
R3455 2879 2880 1.696 0.8 13.568 37
I2880 2880 0 1.23684e-03
R3456 2880 3001 2.5 0.8 20 37
*seg: 289
R3457 3001 2881 2.5 0.8 20 37
R3458 2885 2895 6.16 0.8 49.28 37
I2881 2881 0 1.32342e-03
R3459 2881 2882 1.696 0.8 13.568 37
I2882 2882 0 1.33579e-03
R3460 2882 2883 1.6 0.8 12.8 37
I2883 2883 0 1.29868e-03
R3461 2883 2884 1.68 0.8 13.44 37
I2884 2884 0 1.26158e-03
R3462 2884 2885 1.648 0.8 13.184 37
I2885 2885 0 1.28631e-03
R3463 2885 2886 1.696 0.8 13.568 37
I2886 2886 0 1.28631e-03
R3464 2886 2887 1.744 0.8 13.952 37
I2887 2887 0 1.26158e-03
R3465 2887 2888 1.712 0.8 13.696 37
I2888 2888 0 1.29868e-03
R3466 2888 2889 1.696 0.8 13.568 37
I2889 2889 0 1.34816e-03
R3467 2889 2890 1.68 0.8 13.44 37
I2890 2890 0 1.23684e-03
R3468 2890 3001 2.5 0.8 20 37
*seg: 290
R3469 3001 2891 2.5 0.8 20 37
R3470 2895 2905 6.16 0.8 49.28 37
I2891 2891 0 1.28631e-03
R3471 2891 2892 1.632 0.8 13.056 37
I2892 2892 0 1.23684e-03
R3472 2892 2893 1.664 0.8 13.312 37
I2893 2893 0 1.28631e-03
R3473 2893 2894 1.632 0.8 13.056 37
I2894 2894 0 1.28631e-03
R3474 2894 2895 1.712 0.8 13.696 37
I2895 2895 0 1.32342e-03
R3475 2895 2896 1.68 0.8 13.44 37
I2896 2896 0 1.31105e-03
R3476 2896 2897 1.648 0.8 13.184 37
I2897 2897 0 1.24921e-03
R3477 2897 2898 1.6 0.8 12.8 37
I2898 2898 0 1.32342e-03
R3478 2898 2899 1.712 0.8 13.696 37
I2899 2899 0 1.27395e-03
R3479 2899 2900 1.632 0.8 13.056 37
I2900 2900 0 1.23684e-03
R3480 2900 3001 2.5 0.8 20 37
*seg: 291
R3481 3001 2901 2.5 0.8 20 37
R3482 2905 2915 6.16 0.8 49.28 37
I2901 2901 0 1.34816e-03
R3483 2901 2902 1.6 0.8 12.8 37
I2902 2902 0 1.26158e-03
R3484 2902 2903 1.68 0.8 13.44 37
I2903 2903 0 1.23684e-03
R3485 2903 2904 1.6 0.8 12.8 37
I2904 2904 0 1.28631e-03
R3486 2904 2905 1.664 0.8 13.312 37
I2905 2905 0 1.33579e-03
R3487 2905 2906 1.616 0.8 12.928 37
I2906 2906 0 1.31105e-03
R3488 2906 2907 1.6 0.8 12.8 37
I2907 2907 0 1.28631e-03
R3489 2907 2908 1.68 0.8 13.44 37
I2908 2908 0 1.26158e-03
R3490 2908 2909 1.728 0.8 13.824 37
I2909 2909 0 1.23684e-03
R3491 2909 2910 1.664 0.8 13.312 37
I2910 2910 0 1.23684e-03
R3492 2910 3001 2.5 0.8 20 37
*seg: 292
R3493 3001 2911 2.5 0.8 20 37
R3494 2915 2925 6.16 0.8 49.28 37
I2911 2911 0 1.24921e-03
R3495 2911 2912 1.712 0.8 13.696 37
I2912 2912 0 1.26158e-03
R3496 2912 2913 1.632 0.8 13.056 37
I2913 2913 0 1.28631e-03
R3497 2913 2914 1.616 0.8 12.928 37
I2914 2914 0 1.33579e-03
R3498 2914 2915 1.648 0.8 13.184 37
I2915 2915 0 1.23684e-03
R3499 2915 2916 1.6 0.8 12.8 37
I2916 2916 0 1.32342e-03
R3500 2916 2917 1.664 0.8 13.312 37
I2917 2917 0 1.34816e-03
R3501 2917 2918 1.664 0.8 13.312 37
I2918 2918 0 1.32342e-03
R3502 2918 2919 1.728 0.8 13.824 37
I2919 2919 0 1.26158e-03
R3503 2919 2920 1.616 0.8 12.928 37
I2920 2920 0 1.23684e-03
R3504 2920 3001 2.5 0.8 20 37
*seg: 293
R3505 3001 2921 2.5 0.8 20 37
R3506 2925 2935 6.16 0.8 49.28 37
I2921 2921 0 1.26158e-03
R3507 2921 2922 1.696 0.8 13.568 37
I2922 2922 0 1.32342e-03
R3508 2922 2923 1.648 0.8 13.184 37
I2923 2923 0 1.32342e-03
R3509 2923 2924 1.712 0.8 13.696 37
I2924 2924 0 1.33579e-03
R3510 2924 2925 1.712 0.8 13.696 37
I2925 2925 0 1.31105e-03
R3511 2925 2926 1.68 0.8 13.44 37
I2926 2926 0 1.27395e-03
R3512 2926 2927 1.664 0.8 13.312 37
I2927 2927 0 1.34816e-03
R3513 2927 2928 1.68 0.8 13.44 37
I2928 2928 0 1.26158e-03
R3514 2928 2929 1.664 0.8 13.312 37
I2929 2929 0 1.28631e-03
R3515 2929 2930 1.728 0.8 13.824 37
I2930 2930 0 1.23684e-03
R3516 2930 3001 2.5 0.8 20 37
*seg: 294
R3517 3001 2931 2.5 0.8 20 37
R3518 2935 2945 6.16 0.8 49.28 37
I2931 2931 0 1.29868e-03
R3519 2931 2932 1.68 0.8 13.44 37
I2932 2932 0 1.34816e-03
R3520 2932 2933 1.6 0.8 12.8 37
I2933 2933 0 1.27395e-03
R3521 2933 2934 1.6 0.8 12.8 37
I2934 2934 0 1.31105e-03
R3522 2934 2935 1.6 0.8 12.8 37
I2935 2935 0 1.34816e-03
R3523 2935 2936 1.712 0.8 13.696 37
I2936 2936 0 1.34816e-03
R3524 2936 2937 1.664 0.8 13.312 37
I2937 2937 0 1.31105e-03
R3525 2937 2938 1.664 0.8 13.312 37
I2938 2938 0 1.28631e-03
R3526 2938 2939 1.712 0.8 13.696 37
I2939 2939 0 1.29868e-03
R3527 2939 2940 1.616 0.8 12.928 37
I2940 2940 0 1.23684e-03
R3528 2940 3001 2.5 0.8 20 37
*seg: 295
R3529 3001 2941 2.5 0.8 20 37
R3530 2945 2955 6.16 0.8 49.28 37
I2941 2941 0 1.24921e-03
R3531 2941 2942 1.648 0.8 13.184 37
I2942 2942 0 1.34816e-03
R3532 2942 2943 1.616 0.8 12.928 37
I2943 2943 0 1.26158e-03
R3533 2943 2944 1.664 0.8 13.312 37
I2944 2944 0 1.28631e-03
R3534 2944 2945 1.744 0.8 13.952 37
I2945 2945 0 1.29868e-03
R3535 2945 2946 1.744 0.8 13.952 37
I2946 2946 0 1.29868e-03
R3536 2946 2947 1.632 0.8 13.056 37
I2947 2947 0 1.31105e-03
R3537 2947 2948 1.744 0.8 13.952 37
I2948 2948 0 1.23684e-03
R3538 2948 2949 1.664 0.8 13.312 37
I2949 2949 0 1.23684e-03
R3539 2949 2950 1.712 0.8 13.696 37
I2950 2950 0 1.23684e-03
R3540 2950 3001 2.5 0.8 20 37
*seg: 296
R3541 3001 2951 2.5 0.8 20 37
R3542 2955 2965 6.16 0.8 49.28 37
I2951 2951 0 1.29868e-03
R3543 2951 2952 1.696 0.8 13.568 37
I2952 2952 0 1.23684e-03
R3544 2952 2953 1.6 0.8 12.8 37
I2953 2953 0 1.29868e-03
R3545 2953 2954 1.744 0.8 13.952 37
I2954 2954 0 1.23684e-03
R3546 2954 2955 1.648 0.8 13.184 37
I2955 2955 0 1.24921e-03
R3547 2955 2956 1.728 0.8 13.824 37
I2956 2956 0 1.34816e-03
R3548 2956 2957 1.68 0.8 13.44 37
I2957 2957 0 1.23684e-03
R3549 2957 2958 1.664 0.8 13.312 37
I2958 2958 0 1.24921e-03
R3550 2958 2959 1.712 0.8 13.696 37
I2959 2959 0 1.26158e-03
R3551 2959 2960 1.632 0.8 13.056 37
I2960 2960 0 1.23684e-03
R3552 2960 3001 2.5 0.8 20 37
*seg: 297
R3553 3001 2961 2.5 0.8 20 37
R3554 2965 2975 6.16 0.8 49.28 37
I2961 2961 0 1.27395e-03
R3555 2961 2962 1.664 0.8 13.312 37
I2962 2962 0 1.34816e-03
R3556 2962 2963 1.744 0.8 13.952 37
I2963 2963 0 1.29868e-03
R3557 2963 2964 1.648 0.8 13.184 37
I2964 2964 0 1.29868e-03
R3558 2964 2965 1.6 0.8 12.8 37
I2965 2965 0 1.32342e-03
R3559 2965 2966 1.664 0.8 13.312 37
I2966 2966 0 1.23684e-03
R3560 2966 2967 1.6 0.8 12.8 37
I2967 2967 0 1.31105e-03
R3561 2967 2968 1.696 0.8 13.568 37
I2968 2968 0 1.23684e-03
R3562 2968 2969 1.616 0.8 12.928 37
I2969 2969 0 1.24921e-03
R3563 2969 2970 1.648 0.8 13.184 37
I2970 2970 0 1.23684e-03
R3564 2970 3001 2.5 0.8 20 37
*seg: 298
R3565 3001 2971 2.5 0.8 20 37
R3566 2975 2985 6.16 0.8 49.28 37
I2971 2971 0 1.23684e-03
R3567 2971 2972 1.696 0.8 13.568 37
I2972 2972 0 1.28631e-03
R3568 2972 2973 1.68 0.8 13.44 37
I2973 2973 0 1.28631e-03
R3569 2973 2974 1.712 0.8 13.696 37
I2974 2974 0 1.31105e-03
R3570 2974 2975 1.696 0.8 13.568 37
I2975 2975 0 1.23684e-03
R3571 2975 2976 1.744 0.8 13.952 37
I2976 2976 0 1.34816e-03
R3572 2976 2977 1.664 0.8 13.312 37
I2977 2977 0 1.23684e-03
R3573 2977 2978 1.68 0.8 13.44 37
I2978 2978 0 1.34816e-03
R3574 2978 2979 1.744 0.8 13.952 37
I2979 2979 0 1.29868e-03
R3575 2979 2980 1.632 0.8 13.056 37
I2980 2980 0 1.23684e-03
R3576 2980 3001 2.5 0.8 20 37
*seg: 299
R3577 3001 2981 2.5 0.8 20 37
R3578 2985 2995 6.16 0.8 49.28 37
I2981 2981 0 1.26158e-03
R3579 2981 2982 1.744 0.8 13.952 37
I2982 2982 0 1.28631e-03
R3580 2982 2983 1.632 0.8 13.056 37
I2983 2983 0 1.23684e-03
R3581 2983 2984 1.6 0.8 12.8 37
I2984 2984 0 1.33579e-03
R3582 2984 2985 1.664 0.8 13.312 37
I2985 2985 0 1.26158e-03
R3583 2985 2986 1.728 0.8 13.824 37
I2986 2986 0 1.32342e-03
R3584 2986 2987 1.68 0.8 13.44 37
I2987 2987 0 1.31105e-03
R3585 2987 2988 1.632 0.8 13.056 37
I2988 2988 0 1.33579e-03
R3586 2988 2989 1.632 0.8 13.056 37
I2989 2989 0 1.29868e-03
R3587 2989 2990 1.68 0.8 13.44 37
I2990 2990 0 1.23684e-03
R3588 2990 3001 2.5 0.8 20 37
*seg: 300
R3589 3001 2991 2.5 0.8 20 37
I2991 2991 0 1.27395e-03
R3590 2991 2992 1.632 0.8 13.056 37
I2992 2992 0 1.27395e-03
R3591 2992 2993 1.648 0.8 13.184 37
I2993 2993 0 1.31105e-03
R3592 2993 2994 1.632 0.8 13.056 37
I2994 2994 0 1.27395e-03
R3593 2994 2995 1.616 0.8 12.928 37
I2995 2995 0 1.34816e-03
R3594 2995 2996 1.664 0.8 13.312 37
I2996 2996 0 1.31105e-03
R3595 2996 2997 1.6 0.8 12.8 37
I2997 2997 0 1.27395e-03
R3596 2997 2998 1.728 0.8 13.824 37
I2998 2998 0 1.31105e-03
R3597 2998 2999 1.648 0.8 13.184 37
I2999 2999 0 1.23684e-03
R3598 2999 3000 1.648 0.8 13.184 37
I3000 3000 0 1.23684e-03
R3599 3000 3001 2.5 0.8 20 37
V1 3001 0 5

.op
.end
