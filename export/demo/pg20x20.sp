num_node 400
matrix_size 400

* 20 x 20 ground network
*seg: 1
R1 0 1 0.1 49.28 49.28 37
R2 10 30 6.16 0.8 49.28 37
I1 0 1 1.33579e-05
R3 1 2 1.728 0.8 13.824 37
I2 0 2 1.27395e-05
R4 2 3 1.68 0.8 13.44 37
I3 0 3 1.24921e-05
R5 3 4 1.712 0.8 13.696 37
I4 0 4 1.23684e-05
R6 4 5 1.744 0.8 13.952 37
I5 0 5 1.26158e-05
R7 5 6 1.696 0.8 13.568 37
I6 0 6 1.34816e-05
R8 6 7 1.712 0.8 13.696 37
I7 0 7 1.28631e-05
R9 7 8 1.6 0.8 12.8 37
I8 0 8 1.29868e-05
R10 8 9 1.648 0.8 13.184 37
I9 0 9 1.34816e-05
R11 9 10 1.648 0.8 13.184 37
I10 0 10 1.32342e-05
R12 10 11 1.696 0.8 13.568 37
I11 0 11 1.31105e-05
R13 11 12 1.728 0.8 13.824 37
I12 0 12 1.29868e-05
R14 12 13 1.616 0.8 12.928 37
I13 0 13 1.32342e-05
R15 13 14 1.664 0.8 13.312 37
I14 0 14 1.24921e-05
R16 14 15 1.68 0.8 13.44 37
I15 0 15 1.26158e-05
R17 15 16 1.696 0.8 13.568 37
I16 0 16 1.28631e-05
R18 16 17 1.68 0.8 13.44 37
I17 0 17 1.28631e-05
R19 17 18 1.632 0.8 13.056 37
I18 0 18 1.24921e-05
R20 18 19 1.712 0.8 13.696 37
I19 0 19 1.28631e-05
R21 19 20 1.648 0.8 13.184 37
I20 0 20 1.23684e-05
R22 20 0 0.1 49.28 49.28 37
*seg: 2
R23 0 21 0.1 49.28 49.28 37
R24 30 50 6.16 0.8 49.28 37
I21 0 21 1.24921e-05
R25 21 22 1.696 0.8 13.568 37
I22 0 22 1.33579e-05
R26 22 23 1.728 0.8 13.824 37
I23 0 23 1.29868e-05
R27 23 24 1.648 0.8 13.184 37
I24 0 24 1.32342e-05
R28 24 25 1.696 0.8 13.568 37
I25 0 25 1.29868e-05
R29 25 26 1.648 0.8 13.184 37
I26 0 26 1.26158e-05
R30 26 27 1.664 0.8 13.312 37
I27 0 27 1.27395e-05
R31 27 28 1.6 0.8 12.8 37
I28 0 28 1.28631e-05
R32 28 29 1.648 0.8 13.184 37
I29 0 29 1.26158e-05
R33 29 30 1.728 0.8 13.824 37
I30 0 30 1.26158e-05
R34 30 31 1.712 0.8 13.696 37
I31 0 31 1.32342e-05
R35 31 32 1.68 0.8 13.44 37
I32 0 32 1.34816e-05
R36 32 33 1.648 0.8 13.184 37
I33 0 33 1.24921e-05
R37 33 34 1.664 0.8 13.312 37
I34 0 34 1.23684e-05
R38 34 35 1.744 0.8 13.952 37
I35 0 35 1.33579e-05
R39 35 36 1.712 0.8 13.696 37
I36 0 36 1.34816e-05
R40 36 37 1.696 0.8 13.568 37
I37 0 37 1.31105e-05
R41 37 38 1.6 0.8 12.8 37
I38 0 38 1.33579e-05
R42 38 39 1.696 0.8 13.568 37
I39 0 39 1.28631e-05
R43 39 40 1.632 0.8 13.056 37
I40 0 40 1.23684e-05
R44 40 0 0.1 49.28 49.28 37
*seg: 3
R45 0 41 0.1 49.28 49.28 37
R46 50 70 6.16 0.8 49.28 37
I41 0 41 1.31105e-05
R47 41 42 1.68 0.8 13.44 37
I42 0 42 1.24921e-05
R48 42 43 1.664 0.8 13.312 37
I43 0 43 1.27395e-05
R49 43 44 1.632 0.8 13.056 37
I44 0 44 1.27395e-05
R50 44 45 1.696 0.8 13.568 37
I45 0 45 1.23684e-05
R51 45 46 1.744 0.8 13.952 37
I46 0 46 1.24921e-05
R52 46 47 1.616 0.8 12.928 37
I47 0 47 1.31105e-05
R53 47 48 1.616 0.8 12.928 37
I48 0 48 1.23684e-05
R54 48 49 1.68 0.8 13.44 37
I49 0 49 1.34816e-05
R55 49 50 1.664 0.8 13.312 37
I50 0 50 1.29868e-05
R56 50 51 1.648 0.8 13.184 37
I51 0 51 1.28631e-05
R57 51 52 1.744 0.8 13.952 37
I52 0 52 1.33579e-05
R58 52 53 1.616 0.8 12.928 37
I53 0 53 1.26158e-05
R59 53 54 1.616 0.8 12.928 37
I54 0 54 1.28631e-05
R60 54 55 1.712 0.8 13.696 37
I55 0 55 1.26158e-05
R61 55 56 1.68 0.8 13.44 37
I56 0 56 1.31105e-05
R62 56 57 1.648 0.8 13.184 37
I57 0 57 1.31105e-05
R63 57 58 1.664 0.8 13.312 37
I58 0 58 1.24921e-05
R64 58 59 1.728 0.8 13.824 37
I59 0 59 1.27395e-05
R65 59 60 1.664 0.8 13.312 37
I60 0 60 1.23684e-05
R66 60 0 0.1 49.28 49.28 37
*seg: 4
R67 0 61 0.1 49.28 49.28 37
R68 70 90 6.16 0.8 49.28 37
I61 0 61 1.27395e-05
R69 61 62 1.6 0.8 12.8 37
I62 0 62 1.33579e-05
R70 62 63 1.6 0.8 12.8 37
I63 0 63 1.23684e-05
R71 63 64 1.744 0.8 13.952 37
I64 0 64 1.31105e-05
R72 64 65 1.632 0.8 13.056 37
I65 0 65 1.31105e-05
R73 65 66 1.712 0.8 13.696 37
I66 0 66 1.27395e-05
R74 66 67 1.6 0.8 12.8 37
I67 0 67 1.24921e-05
R75 67 68 1.744 0.8 13.952 37
I68 0 68 1.31105e-05
R76 68 69 1.68 0.8 13.44 37
I69 0 69 1.29868e-05
R77 69 70 1.632 0.8 13.056 37
I70 0 70 1.23684e-05
R78 70 71 1.6 0.8 12.8 37
I71 0 71 1.26158e-05
R79 71 72 1.68 0.8 13.44 37
I72 0 72 1.23684e-05
R80 72 73 1.6 0.8 12.8 37
I73 0 73 1.34816e-05
R81 73 74 1.664 0.8 13.312 37
I74 0 74 1.29868e-05
R82 74 75 1.68 0.8 13.44 37
I75 0 75 1.29868e-05
R83 75 76 1.68 0.8 13.44 37
I76 0 76 1.28631e-05
R84 76 77 1.616 0.8 12.928 37
I77 0 77 1.31105e-05
R85 77 78 1.712 0.8 13.696 37
I78 0 78 1.27395e-05
R86 78 79 1.712 0.8 13.696 37
I79 0 79 1.34816e-05
R87 79 80 1.712 0.8 13.696 37
I80 0 80 1.23684e-05
R88 80 0 0.1 49.28 49.28 37
*seg: 5
R89 0 81 0.1 49.28 49.28 37
R90 90 110 6.16 0.8 49.28 37
I81 0 81 1.27395e-05
R91 81 82 1.744 0.8 13.952 37
I82 0 82 1.29868e-05
R92 82 83 1.696 0.8 13.568 37
I83 0 83 1.27395e-05
R93 83 84 1.616 0.8 12.928 37
I84 0 84 1.27395e-05
R94 84 85 1.712 0.8 13.696 37
I85 0 85 1.34816e-05
R95 85 86 1.712 0.8 13.696 37
I86 0 86 1.27395e-05
R96 86 87 1.728 0.8 13.824 37
I87 0 87 1.31105e-05
R97 87 88 1.616 0.8 12.928 37
I88 0 88 1.31105e-05
R98 88 89 1.696 0.8 13.568 37
I89 0 89 1.31105e-05
R99 89 90 1.728 0.8 13.824 37
I90 0 90 1.33579e-05
R100 90 91 1.696 0.8 13.568 37
I91 0 91 1.27395e-05
R101 91 92 1.712 0.8 13.696 37
I92 0 92 1.24921e-05
R102 92 93 1.712 0.8 13.696 37
I93 0 93 1.26158e-05
R103 93 94 1.728 0.8 13.824 37
I94 0 94 1.24921e-05
R104 94 95 1.648 0.8 13.184 37
I95 0 95 1.26158e-05
R105 95 96 1.664 0.8 13.312 37
I96 0 96 1.33579e-05
R106 96 97 1.68 0.8 13.44 37
I97 0 97 1.27395e-05
R107 97 98 1.744 0.8 13.952 37
I98 0 98 1.24921e-05
R108 98 99 1.696 0.8 13.568 37
I99 0 99 1.29868e-05
R109 99 100 1.728 0.8 13.824 37
I100 0 100 1.23684e-05
R110 100 0 0.1 49.28 49.28 37
*seg: 6
R111 0 101 0.1 49.28 49.28 37
R112 110 130 6.16 0.8 49.28 37
I101 0 101 1.27395e-05
R113 101 102 1.68 0.8 13.44 37
I102 0 102 1.28631e-05
R114 102 103 1.744 0.8 13.952 37
I103 0 103 1.27395e-05
R115 103 104 1.616 0.8 12.928 37
I104 0 104 1.24921e-05
R116 104 105 1.696 0.8 13.568 37
I105 0 105 1.29868e-05
R117 105 106 1.696 0.8 13.568 37
I106 0 106 1.27395e-05
R118 106 107 1.6 0.8 12.8 37
I107 0 107 1.23684e-05
R119 107 108 1.744 0.8 13.952 37
I108 0 108 1.34816e-05
R120 108 109 1.6 0.8 12.8 37
I109 0 109 1.32342e-05
R121 109 110 1.728 0.8 13.824 37
I110 0 110 1.29868e-05
R122 110 111 1.712 0.8 13.696 37
I111 0 111 1.26158e-05
R123 111 112 1.664 0.8 13.312 37
I112 0 112 1.24921e-05
R124 112 113 1.632 0.8 13.056 37
I113 0 113 1.26158e-05
R125 113 114 1.664 0.8 13.312 37
I114 0 114 1.28631e-05
R126 114 115 1.68 0.8 13.44 37
I115 0 115 1.32342e-05
R127 115 116 1.696 0.8 13.568 37
I116 0 116 1.33579e-05
R128 116 117 1.68 0.8 13.44 37
I117 0 117 1.31105e-05
R129 117 118 1.696 0.8 13.568 37
I118 0 118 1.26158e-05
R130 118 119 1.616 0.8 12.928 37
I119 0 119 1.33579e-05
R131 119 120 1.648 0.8 13.184 37
I120 0 120 1.23684e-05
R132 120 0 0.1 49.28 49.28 37
*seg: 7
R133 0 121 0.1 49.28 49.28 37
R134 130 150 6.16 0.8 49.28 37
I121 0 121 1.24921e-05
R135 121 122 1.648 0.8 13.184 37
I122 0 122 1.26158e-05
R136 122 123 1.696 0.8 13.568 37
I123 0 123 1.24921e-05
R137 123 124 1.664 0.8 13.312 37
I124 0 124 1.33579e-05
R138 124 125 1.664 0.8 13.312 37
I125 0 125 1.34816e-05
R139 125 126 1.664 0.8 13.312 37
I126 0 126 1.24921e-05
R140 126 127 1.744 0.8 13.952 37
I127 0 127 1.29868e-05
R141 127 128 1.68 0.8 13.44 37
I128 0 128 1.28631e-05
R142 128 129 1.6 0.8 12.8 37
I129 0 129 1.26158e-05
R143 129 130 1.68 0.8 13.44 37
I130 0 130 1.34816e-05
R144 130 131 1.632 0.8 13.056 37
I131 0 131 1.23684e-05
R145 131 132 1.6 0.8 12.8 37
I132 0 132 1.29868e-05
R146 132 133 1.728 0.8 13.824 37
I133 0 133 1.24921e-05
R147 133 134 1.744 0.8 13.952 37
I134 0 134 1.24921e-05
R148 134 135 1.632 0.8 13.056 37
I135 0 135 1.23684e-05
R149 135 136 1.696 0.8 13.568 37
I136 0 136 1.24921e-05
R150 136 137 1.6 0.8 12.8 37
I137 0 137 1.24921e-05
R151 137 138 1.712 0.8 13.696 37
I138 0 138 1.34816e-05
R152 138 139 1.6 0.8 12.8 37
I139 0 139 1.31105e-05
R153 139 140 1.648 0.8 13.184 37
I140 0 140 1.23684e-05
R154 140 0 0.1 49.28 49.28 37
*seg: 8
R155 0 141 0.1 49.28 49.28 37
R156 150 170 6.16 0.8 49.28 37
I141 0 141 1.33579e-05
R157 141 142 1.648 0.8 13.184 37
I142 0 142 1.24921e-05
R158 142 143 1.616 0.8 12.928 37
I143 0 143 1.34816e-05
R159 143 144 1.696 0.8 13.568 37
I144 0 144 1.28631e-05
R160 144 145 1.744 0.8 13.952 37
I145 0 145 1.26158e-05
R161 145 146 1.712 0.8 13.696 37
I146 0 146 1.33579e-05
R162 146 147 1.632 0.8 13.056 37
I147 0 147 1.29868e-05
R163 147 148 1.6 0.8 12.8 37
I148 0 148 1.34816e-05
R164 148 149 1.68 0.8 13.44 37
I149 0 149 1.34816e-05
R165 149 150 1.616 0.8 12.928 37
I150 0 150 1.33579e-05
R166 150 151 1.632 0.8 13.056 37
I151 0 151 1.27395e-05
R167 151 152 1.68 0.8 13.44 37
I152 0 152 1.34816e-05
R168 152 153 1.632 0.8 13.056 37
I153 0 153 1.28631e-05
R169 153 154 1.632 0.8 13.056 37
I154 0 154 1.34816e-05
R170 154 155 1.648 0.8 13.184 37
I155 0 155 1.32342e-05
R171 155 156 1.632 0.8 13.056 37
I156 0 156 1.24921e-05
R172 156 157 1.68 0.8 13.44 37
I157 0 157 1.28631e-05
R173 157 158 1.744 0.8 13.952 37
I158 0 158 1.23684e-05
R174 158 159 1.744 0.8 13.952 37
I159 0 159 1.34816e-05
R175 159 160 1.664 0.8 13.312 37
I160 0 160 1.23684e-05
R176 160 0 0.1 49.28 49.28 37
*seg: 9
R177 0 161 0.1 49.28 49.28 37
R178 170 190 6.16 0.8 49.28 37
I161 0 161 1.26158e-05
R179 161 162 1.664 0.8 13.312 37
I162 0 162 1.23684e-05
R180 162 163 1.744 0.8 13.952 37
I163 0 163 1.29868e-05
R181 163 164 1.632 0.8 13.056 37
I164 0 164 1.29868e-05
R182 164 165 1.696 0.8 13.568 37
I165 0 165 1.27395e-05
R183 165 166 1.744 0.8 13.952 37
I166 0 166 1.33579e-05
R184 166 167 1.712 0.8 13.696 37
I167 0 167 1.34816e-05
R185 167 168 1.712 0.8 13.696 37
I168 0 168 1.28631e-05
R186 168 169 1.712 0.8 13.696 37
I169 0 169 1.23684e-05
R187 169 170 1.632 0.8 13.056 37
I170 0 170 1.34816e-05
R188 170 171 1.744 0.8 13.952 37
I171 0 171 1.34816e-05
R189 171 172 1.648 0.8 13.184 37
I172 0 172 1.31105e-05
R190 172 173 1.632 0.8 13.056 37
I173 0 173 1.34816e-05
R191 173 174 1.648 0.8 13.184 37
I174 0 174 1.34816e-05
R192 174 175 1.696 0.8 13.568 37
I175 0 175 1.32342e-05
R193 175 176 1.616 0.8 12.928 37
I176 0 176 1.24921e-05
R194 176 177 1.6 0.8 12.8 37
I177 0 177 1.27395e-05
R195 177 178 1.68 0.8 13.44 37
I178 0 178 1.34816e-05
R196 178 179 1.6 0.8 12.8 37
I179 0 179 1.32342e-05
R197 179 180 1.664 0.8 13.312 37
I180 0 180 1.23684e-05
R198 180 0 0.1 49.28 49.28 37
*seg: 10
R199 0 181 0.1 49.28 49.28 37
R200 190 210 6.16 0.8 49.28 37
I181 0 181 1.28631e-05
R201 181 182 1.648 0.8 13.184 37
I182 0 182 1.26158e-05
R202 182 183 1.744 0.8 13.952 37
I183 0 183 1.31105e-05
R203 183 184 1.648 0.8 13.184 37
I184 0 184 1.32342e-05
R204 184 185 1.68 0.8 13.44 37
I185 0 185 1.27395e-05
R205 185 186 1.664 0.8 13.312 37
I186 0 186 1.26158e-05
R206 186 187 1.632 0.8 13.056 37
I187 0 187 1.29868e-05
R207 187 188 1.632 0.8 13.056 37
I188 0 188 1.28631e-05
R208 188 189 1.6 0.8 12.8 37
I189 0 189 1.29868e-05
R209 189 190 1.696 0.8 13.568 37
I190 0 190 1.33579e-05
R210 190 191 1.68 0.8 13.44 37
I191 0 191 1.33579e-05
R211 191 192 1.6 0.8 12.8 37
I192 0 192 1.31105e-05
R212 192 193 1.68 0.8 13.44 37
I193 0 193 1.31105e-05
R213 193 194 1.648 0.8 13.184 37
I194 0 194 1.24921e-05
R214 194 195 1.616 0.8 12.928 37
I195 0 195 1.33579e-05
R215 195 196 1.744 0.8 13.952 37
I196 0 196 1.32342e-05
R216 196 197 1.616 0.8 12.928 37
I197 0 197 1.23684e-05
R217 197 198 1.664 0.8 13.312 37
I198 0 198 1.23684e-05
R218 198 199 1.648 0.8 13.184 37
I199 0 199 1.33579e-05
R219 199 200 1.728 0.8 13.824 37
I200 0 200 1.23684e-05
R220 200 0 0.1 49.28 49.28 37
*seg: 11
R221 0 201 0.1 49.28 49.28 37
R222 210 230 6.16 0.8 49.28 37
I201 0 201 1.28631e-05
R223 201 202 1.68 0.8 13.44 37
I202 0 202 1.29868e-05
R224 202 203 1.632 0.8 13.056 37
I203 0 203 1.33579e-05
R225 203 204 1.744 0.8 13.952 37
I204 0 204 1.29868e-05
R226 204 205 1.632 0.8 13.056 37
I205 0 205 1.33579e-05
R227 205 206 1.664 0.8 13.312 37
I206 0 206 1.33579e-05
R228 206 207 1.632 0.8 13.056 37
I207 0 207 1.28631e-05
R229 207 208 1.616 0.8 12.928 37
I208 0 208 1.28631e-05
R230 208 209 1.744 0.8 13.952 37
I209 0 209 1.24921e-05
R231 209 210 1.632 0.8 13.056 37
I210 0 210 1.27395e-05
R232 210 211 1.728 0.8 13.824 37
I211 0 211 1.33579e-05
R233 211 212 1.648 0.8 13.184 37
I212 0 212 1.32342e-05
R234 212 213 1.632 0.8 13.056 37
I213 0 213 1.29868e-05
R235 213 214 1.744 0.8 13.952 37
I214 0 214 1.29868e-05
R236 214 215 1.68 0.8 13.44 37
I215 0 215 1.29868e-05
R237 215 216 1.728 0.8 13.824 37
I216 0 216 1.27395e-05
R238 216 217 1.712 0.8 13.696 37
I217 0 217 1.33579e-05
R239 217 218 1.632 0.8 13.056 37
I218 0 218 1.33579e-05
R240 218 219 1.68 0.8 13.44 37
I219 0 219 1.28631e-05
R241 219 220 1.6 0.8 12.8 37
I220 0 220 1.23684e-05
R242 220 0 0.1 49.28 49.28 37
*seg: 12
R243 0 221 0.1 49.28 49.28 37
R244 230 250 6.16 0.8 49.28 37
I221 0 221 1.24921e-05
R245 221 222 1.68 0.8 13.44 37
I222 0 222 1.24921e-05
R246 222 223 1.616 0.8 12.928 37
I223 0 223 1.33579e-05
R247 223 224 1.664 0.8 13.312 37
I224 0 224 1.32342e-05
R248 224 225 1.68 0.8 13.44 37
I225 0 225 1.34816e-05
R249 225 226 1.68 0.8 13.44 37
I226 0 226 1.23684e-05
R250 226 227 1.712 0.8 13.696 37
I227 0 227 1.34816e-05
R251 227 228 1.712 0.8 13.696 37
I228 0 228 1.34816e-05
R252 228 229 1.744 0.8 13.952 37
I229 0 229 1.24921e-05
R253 229 230 1.712 0.8 13.696 37
I230 0 230 1.32342e-05
R254 230 231 1.744 0.8 13.952 37
I231 0 231 1.31105e-05
R255 231 232 1.712 0.8 13.696 37
I232 0 232 1.29868e-05
R256 232 233 1.616 0.8 12.928 37
I233 0 233 1.32342e-05
R257 233 234 1.744 0.8 13.952 37
I234 0 234 1.29868e-05
R258 234 235 1.68 0.8 13.44 37
I235 0 235 1.31105e-05
R259 235 236 1.648 0.8 13.184 37
I236 0 236 1.31105e-05
R260 236 237 1.6 0.8 12.8 37
I237 0 237 1.33579e-05
R261 237 238 1.6 0.8 12.8 37
I238 0 238 1.34816e-05
R262 238 239 1.728 0.8 13.824 37
I239 0 239 1.26158e-05
R263 239 240 1.744 0.8 13.952 37
I240 0 240 1.23684e-05
R264 240 0 0.1 49.28 49.28 37
*seg: 13
R265 0 241 0.1 49.28 49.28 37
R266 250 270 6.16 0.8 49.28 37
I241 0 241 1.34816e-05
R267 241 242 1.696 0.8 13.568 37
I242 0 242 1.33579e-05
R268 242 243 1.616 0.8 12.928 37
I243 0 243 1.24921e-05
R269 243 244 1.696 0.8 13.568 37
I244 0 244 1.33579e-05
R270 244 245 1.712 0.8 13.696 37
I245 0 245 1.32342e-05
R271 245 246 1.6 0.8 12.8 37
I246 0 246 1.34816e-05
R272 246 247 1.696 0.8 13.568 37
I247 0 247 1.31105e-05
R273 247 248 1.68 0.8 13.44 37
I248 0 248 1.24921e-05
R274 248 249 1.696 0.8 13.568 37
I249 0 249 1.27395e-05
R275 249 250 1.744 0.8 13.952 37
I250 0 250 1.24921e-05
R276 250 251 1.632 0.8 13.056 37
I251 0 251 1.31105e-05
R277 251 252 1.712 0.8 13.696 37
I252 0 252 1.31105e-05
R278 252 253 1.632 0.8 13.056 37
I253 0 253 1.23684e-05
R279 253 254 1.664 0.8 13.312 37
I254 0 254 1.27395e-05
R280 254 255 1.744 0.8 13.952 37
I255 0 255 1.34816e-05
R281 255 256 1.632 0.8 13.056 37
I256 0 256 1.26158e-05
R282 256 257 1.712 0.8 13.696 37
I257 0 257 1.33579e-05
R283 257 258 1.632 0.8 13.056 37
I258 0 258 1.26158e-05
R284 258 259 1.632 0.8 13.056 37
I259 0 259 1.29868e-05
R285 259 260 1.744 0.8 13.952 37
I260 0 260 1.23684e-05
R286 260 0 0.1 49.28 49.28 37
*seg: 14
R287 0 261 0.1 49.28 49.28 37
R288 270 290 6.16 0.8 49.28 37
I261 0 261 1.31105e-05
R289 261 262 1.664 0.8 13.312 37
I262 0 262 1.23684e-05
R290 262 263 1.68 0.8 13.44 37
I263 0 263 1.34816e-05
R291 263 264 1.68 0.8 13.44 37
I264 0 264 1.27395e-05
R292 264 265 1.616 0.8 12.928 37
I265 0 265 1.28631e-05
R293 265 266 1.744 0.8 13.952 37
I266 0 266 1.23684e-05
R294 266 267 1.616 0.8 12.928 37
I267 0 267 1.28631e-05
R295 267 268 1.68 0.8 13.44 37
I268 0 268 1.28631e-05
R296 268 269 1.6 0.8 12.8 37
I269 0 269 1.34816e-05
R297 269 270 1.616 0.8 12.928 37
I270 0 270 1.27395e-05
R298 270 271 1.616 0.8 12.928 37
I271 0 271 1.34816e-05
R299 271 272 1.6 0.8 12.8 37
I272 0 272 1.28631e-05
R300 272 273 1.712 0.8 13.696 37
I273 0 273 1.27395e-05
R301 273 274 1.712 0.8 13.696 37
I274 0 274 1.33579e-05
R302 274 275 1.6 0.8 12.8 37
I275 0 275 1.29868e-05
R303 275 276 1.6 0.8 12.8 37
I276 0 276 1.34816e-05
R304 276 277 1.696 0.8 13.568 37
I277 0 277 1.31105e-05
R305 277 278 1.712 0.8 13.696 37
I278 0 278 1.26158e-05
R306 278 279 1.648 0.8 13.184 37
I279 0 279 1.32342e-05
R307 279 280 1.632 0.8 13.056 37
I280 0 280 1.23684e-05
R308 280 0 0.1 49.28 49.28 37
*seg: 15
R309 0 281 0.1 49.28 49.28 37
R310 290 310 6.16 0.8 49.28 37
I281 0 281 1.31105e-05
R311 281 282 1.632 0.8 13.056 37
I282 0 282 1.34816e-05
R312 282 283 1.664 0.8 13.312 37
I283 0 283 1.26158e-05
R313 283 284 1.664 0.8 13.312 37
I284 0 284 1.29868e-05
R314 284 285 1.728 0.8 13.824 37
I285 0 285 1.28631e-05
R315 285 286 1.712 0.8 13.696 37
I286 0 286 1.31105e-05
R316 286 287 1.632 0.8 13.056 37
I287 0 287 1.28631e-05
R317 287 288 1.696 0.8 13.568 37
I288 0 288 1.26158e-05
R318 288 289 1.68 0.8 13.44 37
I289 0 289 1.33579e-05
R319 289 290 1.632 0.8 13.056 37
I290 0 290 1.23684e-05
R320 290 291 1.616 0.8 12.928 37
I291 0 291 1.34816e-05
R321 291 292 1.712 0.8 13.696 37
I292 0 292 1.28631e-05
R322 292 293 1.664 0.8 13.312 37
I293 0 293 1.29868e-05
R323 293 294 1.712 0.8 13.696 37
I294 0 294 1.29868e-05
R324 294 295 1.6 0.8 12.8 37
I295 0 295 1.33579e-05
R325 295 296 1.68 0.8 13.44 37
I296 0 296 1.23684e-05
R326 296 297 1.616 0.8 12.928 37
I297 0 297 1.34816e-05
R327 297 298 1.712 0.8 13.696 37
I298 0 298 1.32342e-05
R328 298 299 1.6 0.8 12.8 37
I299 0 299 1.32342e-05
R329 299 300 1.712 0.8 13.696 37
I300 0 300 1.23684e-05
R330 300 0 0.1 49.28 49.28 37
*seg: 16
R331 0 301 0.1 49.28 49.28 37
R332 310 330 6.16 0.8 49.28 37
I301 0 301 1.31105e-05
R333 301 302 1.648 0.8 13.184 37
I302 0 302 1.27395e-05
R334 302 303 1.712 0.8 13.696 37
I303 0 303 1.32342e-05
R335 303 304 1.68 0.8 13.44 37
I304 0 304 1.24921e-05
R336 304 305 1.68 0.8 13.44 37
I305 0 305 1.31105e-05
R337 305 306 1.712 0.8 13.696 37
I306 0 306 1.24921e-05
R338 306 307 1.616 0.8 12.928 37
I307 0 307 1.23684e-05
R339 307 308 1.696 0.8 13.568 37
I308 0 308 1.34816e-05
R340 308 309 1.68 0.8 13.44 37
I309 0 309 1.32342e-05
R341 309 310 1.728 0.8 13.824 37
I310 0 310 1.27395e-05
R342 310 311 1.616 0.8 12.928 37
I311 0 311 1.31105e-05
R343 311 312 1.664 0.8 13.312 37
I312 0 312 1.33579e-05
R344 312 313 1.632 0.8 13.056 37
I313 0 313 1.32342e-05
R345 313 314 1.664 0.8 13.312 37
I314 0 314 1.31105e-05
R346 314 315 1.68 0.8 13.44 37
I315 0 315 1.29868e-05
R347 315 316 1.632 0.8 13.056 37
I316 0 316 1.31105e-05
R348 316 317 1.68 0.8 13.44 37
I317 0 317 1.29868e-05
R349 317 318 1.632 0.8 13.056 37
I318 0 318 1.33579e-05
R350 318 319 1.68 0.8 13.44 37
I319 0 319 1.32342e-05
R351 319 320 1.632 0.8 13.056 37
I320 0 320 1.23684e-05
R352 320 0 0.1 49.28 49.28 37
*seg: 17
R353 0 321 0.1 49.28 49.28 37
R354 330 350 6.16 0.8 49.28 37
I321 0 321 1.23684e-05
R355 321 322 1.712 0.8 13.696 37
I322 0 322 1.26158e-05
R356 322 323 1.632 0.8 13.056 37
I323 0 323 1.27395e-05
R357 323 324 1.728 0.8 13.824 37
I324 0 324 1.29868e-05
R358 324 325 1.6 0.8 12.8 37
I325 0 325 1.33579e-05
R359 325 326 1.696 0.8 13.568 37
I326 0 326 1.26158e-05
R360 326 327 1.632 0.8 13.056 37
I327 0 327 1.28631e-05
R361 327 328 1.712 0.8 13.696 37
I328 0 328 1.29868e-05
R362 328 329 1.744 0.8 13.952 37
I329 0 329 1.28631e-05
R363 329 330 1.648 0.8 13.184 37
I330 0 330 1.34816e-05
R364 330 331 1.68 0.8 13.44 37
I331 0 331 1.29868e-05
R365 331 332 1.712 0.8 13.696 37
I332 0 332 1.24921e-05
R366 332 333 1.648 0.8 13.184 37
I333 0 333 1.32342e-05
R367 333 334 1.616 0.8 12.928 37
I334 0 334 1.32342e-05
R368 334 335 1.712 0.8 13.696 37
I335 0 335 1.26158e-05
R369 335 336 1.664 0.8 13.312 37
I336 0 336 1.24921e-05
R370 336 337 1.712 0.8 13.696 37
I337 0 337 1.27395e-05
R371 337 338 1.712 0.8 13.696 37
I338 0 338 1.32342e-05
R372 338 339 1.648 0.8 13.184 37
I339 0 339 1.24921e-05
R373 339 340 1.728 0.8 13.824 37
I340 0 340 1.23684e-05
R374 340 0 0.1 49.28 49.28 37
*seg: 18
R375 0 341 0.1 49.28 49.28 37
R376 350 370 6.16 0.8 49.28 37
I341 0 341 1.34816e-05
R377 341 342 1.728 0.8 13.824 37
I342 0 342 1.31105e-05
R378 342 343 1.632 0.8 13.056 37
I343 0 343 1.23684e-05
R379 343 344 1.632 0.8 13.056 37
I344 0 344 1.33579e-05
R380 344 345 1.68 0.8 13.44 37
I345 0 345 1.26158e-05
R381 345 346 1.696 0.8 13.568 37
I346 0 346 1.34816e-05
R382 346 347 1.664 0.8 13.312 37
I347 0 347 1.31105e-05
R383 347 348 1.744 0.8 13.952 37
I348 0 348 1.27395e-05
R384 348 349 1.712 0.8 13.696 37
I349 0 349 1.23684e-05
R385 349 350 1.728 0.8 13.824 37
I350 0 350 1.33579e-05
R386 350 351 1.712 0.8 13.696 37
I351 0 351 1.29868e-05
R387 351 352 1.632 0.8 13.056 37
I352 0 352 1.23684e-05
R388 352 353 1.648 0.8 13.184 37
I353 0 353 1.27395e-05
R389 353 354 1.616 0.8 12.928 37
I354 0 354 1.24921e-05
R390 354 355 1.632 0.8 13.056 37
I355 0 355 1.28631e-05
R391 355 356 1.68 0.8 13.44 37
I356 0 356 1.31105e-05
R392 356 357 1.728 0.8 13.824 37
I357 0 357 1.24921e-05
R393 357 358 1.632 0.8 13.056 37
I358 0 358 1.24921e-05
R394 358 359 1.744 0.8 13.952 37
I359 0 359 1.34816e-05
R395 359 360 1.632 0.8 13.056 37
I360 0 360 1.23684e-05
R396 360 0 0.1 49.28 49.28 37
*seg: 19
R397 0 361 0.1 49.28 49.28 37
R398 370 390 6.16 0.8 49.28 37
I361 0 361 1.34816e-05
R399 361 362 1.728 0.8 13.824 37
I362 0 362 1.27395e-05
R400 362 363 1.712 0.8 13.696 37
I363 0 363 1.24921e-05
R401 363 364 1.664 0.8 13.312 37
I364 0 364 1.24921e-05
R402 364 365 1.664 0.8 13.312 37
I365 0 365 1.32342e-05
R403 365 366 1.68 0.8 13.44 37
I366 0 366 1.27395e-05
R404 366 367 1.616 0.8 12.928 37
I367 0 367 1.24921e-05
R405 367 368 1.664 0.8 13.312 37
I368 0 368 1.28631e-05
R406 368 369 1.648 0.8 13.184 37
I369 0 369 1.29868e-05
R407 369 370 1.744 0.8 13.952 37
I370 0 370 1.26158e-05
R408 370 371 1.616 0.8 12.928 37
I371 0 371 1.34816e-05
R409 371 372 1.616 0.8 12.928 37
I372 0 372 1.27395e-05
R410 372 373 1.664 0.8 13.312 37
I373 0 373 1.33579e-05
R411 373 374 1.616 0.8 12.928 37
I374 0 374 1.31105e-05
R412 374 375 1.648 0.8 13.184 37
I375 0 375 1.28631e-05
R413 375 376 1.6 0.8 12.8 37
I376 0 376 1.29868e-05
R414 376 377 1.696 0.8 13.568 37
I377 0 377 1.33579e-05
R415 377 378 1.6 0.8 12.8 37
I378 0 378 1.26158e-05
R416 378 379 1.648 0.8 13.184 37
I379 0 379 1.28631e-05
R417 379 380 1.712 0.8 13.696 37
I380 0 380 1.23684e-05
R418 380 0 0.1 49.28 49.28 37
*seg: 20
R419 0 381 0.1 49.28 49.28 37
I381 0 381 1.27395e-05
R420 381 382 1.648 0.8 13.184 37
I382 0 382 1.27395e-05
R421 382 383 1.696 0.8 13.568 37
I383 0 383 1.28631e-05
R422 383 384 1.616 0.8 12.928 37
I384 0 384 1.24921e-05
R423 384 385 1.648 0.8 13.184 37
I385 0 385 1.28631e-05
R424 385 386 1.728 0.8 13.824 37
I386 0 386 1.32342e-05
R425 386 387 1.728 0.8 13.824 37
I387 0 387 1.33579e-05
R426 387 388 1.616 0.8 12.928 37
I388 0 388 1.24921e-05
R427 388 389 1.744 0.8 13.952 37
I389 0 389 1.34816e-05
R428 389 390 1.728 0.8 13.824 37
I390 0 390 1.29868e-05
R429 390 391 1.632 0.8 13.056 37
I391 0 391 1.28631e-05
R430 391 392 1.744 0.8 13.952 37
I392 0 392 1.23684e-05
R431 392 393 1.664 0.8 13.312 37
I393 0 393 1.28631e-05
R432 393 394 1.744 0.8 13.952 37
I394 0 394 1.23684e-05
R433 394 395 1.744 0.8 13.952 37
I395 0 395 1.34816e-05
R434 395 396 1.6 0.8 12.8 37
I396 0 396 1.24921e-05
R435 396 397 1.664 0.8 13.312 37
I397 0 397 1.26158e-05
R436 397 398 1.712 0.8 13.696 37
I398 0 398 1.24921e-05
R437 398 399 1.728 0.8 13.824 37
I399 0 399 1.26158e-05
R438 399 400 1.728 0.8 13.824 37
I400 0 400 1.23684e-05
R439 400 0 0.1 49.28 49.28 37

.op
.end
